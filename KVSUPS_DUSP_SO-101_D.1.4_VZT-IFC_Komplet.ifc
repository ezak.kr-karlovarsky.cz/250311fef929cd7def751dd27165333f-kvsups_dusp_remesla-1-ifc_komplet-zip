Properties of the parts of a building model (IFC4), part 16 of 21

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (96)
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odsazení šířky od základny (mm) | Odsazení výšky od základny (mm) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí 1 (mm) | Poloměr potrubí 2 (mm) | Rozdíl odsazení (mm) | Rozdíl poloměrů (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Číslo 1 | Číslo 2 | Číslo 3 | Číslo 5 | Délka 1 (mm) | Délka 2 (mm) | Délka 3 (mm) | Tlaková ztráta (Pa)
13540621 | -1.PP_SO-101 | 180 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0118 | 0118 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13542113 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0121 | 0121 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13542116 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0122 | 0122 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13542133 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0123 | 0123 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13544686 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.0138889 | 0.0138889 | 0.00152674 | 3048 | 3048 | 50 | 50 | 0.0387531 | 50 | 90 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0124 | 0124 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13544724 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0125 | 0125 | no | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13544726 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0126 | 0126 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13544750 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0127 | 0127 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13544752 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0128 | 0128 | no | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13546864 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0129 | 0129 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13546866 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0130 | 0130 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13546871 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0131 | 0131 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13546873 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 3048 | 125 | 125 | 0.0615557 | 125 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0132 | 0132 | no | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13546889 | -1.PP_SO-101 | 180 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.000548535 | 3048 | 3048 | 90 | 90 | 0.0230465 | 90 | 80 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0135 | 0135 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13547033 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0136 | 0136 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13547035 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0137 | 0137 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13547038 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0138 | 0138 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13547050 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0141 | 0141 | no | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13547054 | -1.PP_SO-101 | 180 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0142 | 0142 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13630224 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0160 | 0160 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630226 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0161 | 0161 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630246 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0162 | 0162 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630248 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0163 | 0163 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630324 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0164 | 0164 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630326 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0165 | 0165 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630350 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0166 | 0166 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13630352 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0167 | 0167 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13632122 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0171 | 0171 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13632124 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0172 | 0172 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13761749 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0217 | 0217 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13762065 | -1.PP_SO-101 | 160 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0218 | 0218 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13762389 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0219 | 0219 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13762391 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0220 | 0220 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13763089 | 4.NP_SO-101 | 180 mm-160 mm | 4.NP_SO-101 | 3300 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0224 | 0224 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13763485 | -1.PP_SO-101 | 160 mm-100 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0225 | 0225 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13763487 | -1.PP_SO-101 | 160 mm-100 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0226 | 0226 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13763853 | 2.NP_SO-101 | 160 mm-100 mm | 2.NP_SO-101 | 3150 |  | Nedefinovaný |  |  | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0228 | 0228 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0
13763947 | 2.NP_SO-101 | 160 mm-100 mm | 2.NP_SO-101 | 3150 |  | Nedefinovaný |  |  | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0229 | 0229 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0
13790673 | 4.NP_SO-101 | 160 mm-100 mm | 4.NP_SO-101 | 182.906 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0235 | 0235 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13790675 | 4.NP_SO-101 | 160 mm-100 mm | 4.NP_SO-101 | 182.906 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0236 | 0236 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13830389 | 2.NP_SO-101 | 225 mm-200 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.03125 | 0.03125 | 0.00107141 | 3048 | 3048 | 112.5 | 112.5 | 0.0360101 | 112.5 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.04.0286 | 0286 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | 0
13830392 | 2.NP_SO-101 | 225 mm-200 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.03125 | 0.03125 | 0.00107141 | 3048 | 3048 | 112.5 | 112.5 | 0.0360101 | 112.5 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.04.0287 | 0287 | no | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | 0
13830508 | 2.NP_SO-101 | 225 mm-200 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 3048 | 112.5 | 112.5 | 0.0360101 | 112.5 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.04.0288 | 0288 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | 0
13830510 | 2.NP_SO-101 | 225 mm-200 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 3048 | 112.5 | 112.5 | 0.0360101 | 112.5 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.04.0289 | 0289 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | 0
13831351 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0297 | 0297 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13831356 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0298 | 0298 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13831404 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0299 | 0299 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13831424 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0300 | 0300 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13831426 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0301 | 0301 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13844023 | 2.NP_SO-101 | 160 mm-125 mm | 2.NP_SO-101 | 5734.16 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0312 | 0312 | yes | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0 | 0
13844041 | 3.NP_SO-101 | 160 mm-125 mm | 3.NP_SO-101 | 2614.16 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0313 | 0313 | yes | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0
13844043 | 2.NP_SO-101 | 160 mm-125 mm | 2.NP_SO-101 | 6029.67 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0314 | 0314 | yes | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0 | 0
13905584 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0345 | 0345 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13905586 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0346 | 0346 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13908814 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0352 | 0352 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13911195 | 2.NP_SO-101 | 160 mm-100 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0354 | 0354 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13911362 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0356 | 0356 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13911364 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0357 | 0357 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13912820 | 4.NP_SO-101 | 160 mm-125 mm | 4.NP_SO-101 | 2360 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0360 | 0360 | no | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0
13920301 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 3048 | 125 | 125 | 0.0615557 | 125 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0365 | 0365 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13920413 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0366 | 0366 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13920415 | -1.PP_SO-101 | 180 mm-100 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.025 | 0.025 | 0.00152671 | 3048 | 3048 | 90 | 90 | 0.0387531 | 90 | 50 | 0 | 40 | 180-100 | 96.5685 | TA03.04.0367 | 0367 | yes | 1.6 | 1.6 | 3.2 | 3.86274 | 40 | 40 | 0 | 0
13920505 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0368 | 0368 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13920507 | -1.PP_SO-101 | 250 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.025 | 0.025 | 0.00309452 | 3048 | 3048 | 90 | 90 | 0.0615557 | 90 | 125 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0369 | 0369 | yes | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35 | 0 | 0
13921892 | 1.NP_SO-101 | 200 mm-100 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 0.0277778 | 0.0277778 | 0.00221168 | 3048 | 3048 | 100 | 100 | 0.050205 | 100 | 50 | 0 | 50 | 200-100 | 120.711 | TA03.04.0371 | 0371 | yes | 2 | 2 | 4 | 4.82843 | 50 | 50 | 0 | 0
13921895 | 1.NP_SO-101 | 200 mm-100 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 0.0277778 | 0.0277778 | 0.00221168 | 3048 | 3048 | 100 | 100 | 0.050205 | 100 | 50 | 0 | 50 | 200-100 | 120.711 | TA03.04.0372 | 0372 | yes | 2 | 2 | 4 | 4.82843 | 50 | 50 | 0 | 0
13930348 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0346821 | 0.0347222 | 0.00364296 | 3047.86 | 3048 | 124.855 | 125 | 0.0684022 | 125 | 80 | 0 | 45 | 250-160 | 108.639 | TA03.04.0409 | 0409 | yes | 1.80578 | 1.79422 | 3.6 | 4.34558 | 45.1446 | 44.8554 | 0.144608 | 0
13934398 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0422 | 0422 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
13935146 | 3.NP_SO-101 | 160 mm-100 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0424 | 0424 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13935178 | 3.NP_SO-101 | 160 mm-100 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0425 | 0425 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
13938317 | 2.NP_SO-101 | 180 mm-160 mm | 2.NP_SO-101 | 4110.2 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0445 | 0445 | yes | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13964593 | 2.NP_SO-101 | 355 mm-250 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.0493056 | 0.0493056 | 0.00919997 | 3048 | 3048 | 177.5 | 177.5 | 0.126972 | 177.5 | 125 | 0 | 52.5 | 355-250 | 126.746 | TA03.04.0467 | 0467 | yes | 2.1 | 2.1 | 4.2 | 5.06985 | 52.5 | 52.5 | 0
13971507 | 1.NP_SO-101 | 180 mm-180 mm | 1.NP_SO-101 | 3062.5 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0227192 | 0.025 | 0.00114497 | 3039.79 | 3048 | 81.7892 | 90 | 0.0325337 | 90 | 90 | 0 | 0 | 180-180 | 45 | TA03.04.0500 | 0500 | yes | 0.328434 | -0.328434 | 0 | 0 | 8.21085 | -8.21085 | 8.21085 | 0 | Qto_DuctFittingBaseQuantities - Length: 45 mm; GrossCrossSectionArea: 0.0254435 m2; NetCrossSectionArea: 0.0254435 m2; OuterSurfaceArea: 0.0254469 m2
13999348 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3270 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.0222222 | 0.00972222 | 0.00364293 | 3048 | 3093 | 80 | 35 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0513 | 0513 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
14030096 | 4.NP_SO-101 | 400 mm-160 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.0555556 | 0.0888889 | 0.0189296 | 3048 | 2928 | 200 | 320 | 0.215319 | 200 | 80 | 120 | 120 | 400-160 | 289.706 | TA03.04.0591 | 0591 | yes | 4.8 | 4.8 | 9.6 | 11.5882 | 120 | 120 | 0
14035648 | 4.NP_SO-101 | 250 mm-160 mm | 4.NP_SO-101 | 351.115 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0629 | 0629 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
14042345 | -1.PP_SO-101 | 160 mm-100 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0138889 | 0.0138889 | 0.000978194 | 3048 | 3048 | 50 | 50 | 0.0285066 | 50 | 80 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0638 | 0638 | yes | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
14048273 | 4.NP_SO-101 | 180 mm-125 mm | 4.NP_SO-101 | 3900.03 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.025 | 0.025 | 0.0012256 | 3048 | 3048 | 90 | 90 | 0.0330897 | 90 | 62.5 | 0 | 27.5 | 180-125 | 66.3909 | TA03.04.0668 | 0668 |  | 1.1 | 1.1 | 2.2 | 2.65563 | 27.5 | 27.5 | 0 | 0
14050509 | 3.NP_SO-101 | 400 mm-200 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0.0555556 | 0.0555556 | 0.017696 | 3048 | 3048 | 200 | 200 | 0.20082 | 200 | 100 | 0 | 100 | 400-200 | 241.421 | TA03.04.0673 | 0673 | yes | 4 | 4 | 8 | 9.65685 | 100 | 100 | 0 | 0
14061084 | 4.NP_SO-101 | 250 mm-180 mm | 4.NP_SO-101 | 2023.77 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 3048 | 125 | 125 | 0.0615557 | 125 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.04.0716 | 0716 |  | 1.4 | 1.4 | 2.8 | 3.3799 | 35.0001 | 34.9999 | 0.000115288 | 0
14064709 | 4.NP_SO-101 | 280 mm-180 mm | 4.NP_SO-101 | 4100 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.025 | 0.025 | 0.00509386 | 3048 | 3048 | 90 | 90 | 0.0855144 | 90 | 140 | 0 | 50 | 280-180 | 120.711 | TA03.04.0736 | 0736 |  | 2 | 2 | 4 | 4.82843 | 50 | 50 | 0 | 0
14070028 | 2.NP_SO-101 | 160 mm-125 mm | 2.NP_SO-101 | 5149.67 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0763 | 0763 |  | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0 | 0
14072068 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 3048 | 80 | 80 | 0.0684022 | 80 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.04.0779 | 0779 |  | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0 | 0
14072222 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 3048 | 125 | 125 | 0.0432062 | 125 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.04.0784 | 0784 |  | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | 0
14075731 | 1.NP_SO-101 | 450 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0624991 | 0.0625 | 0.0238587 | 3048 | 3048 | 224.997 | 225 | 0.242207 | 225 | 125 | 0 | 100 | 450-250 | 241.421 | TA03.04.0799 | 0799 |  | 4.00013 | 3.99987 | 8 | 9.65685 | 100.003 | 99.9968 | 0.0032256 | 0
14075932 | 1.NP_SO-101 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.0347222 | 0.00694444 | 0.00306772 | 3048 | 3148 | 125 | 25 | 0.0763562 | 125 | 125 | 0 | 0 | 250-250 | 62.5 | TA03.04.0803 | 0803 |  | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
14079184 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0812 | 0812 |  | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
14079186 | 1.NP_SO-101 | 160 mm-100 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.0222222 | 0.0222222 | 0.000978088 | 3048 | 3048 | 80 | 80 | 0.0285066 | 80 | 50 | 0 | 30 | 160-100 | 72.4264 | TA03.04.0813 | 0813 |  | 1.2 | 1.2 | 2.4 | 2.89706 | 30 | 30 | 0 | 0
14081763 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 0.022043 | 0.0222222 | 0.00364282 | 3047.35 | 3048 | 79.3549 | 80 | 0.0684013 | 80 | 125 | 0 | 45 | 250-160 | 108.636 | TA03.04.0832 | 0832 |  | 1.8258 | 1.7742 | 3.6 | 4.34545 | 45.6451 | 44.3549 | 0.645112 | 0

# IfcDuctFitting: M_Kulatý spoj T:Standardní (13)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý spoj T
Classification: TA06 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: Standardní; Id typu: 1446011; Rodina: M_Kulatý spoj T; Rodina a typ: M_Kulatý spoj T: Standardní
Name (M_Kulatý spoj T:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Poloměr potrubí 1 (mm) | Poloměr potrubí 3 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13503598 | 1.NP_SO-101 | 225 mm-225 mm-160 mm | 1.NP_SO-101 | 3000 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 260 | 162.5 | 0.0114964 | 112.5 | 80 | 225-225-160 | TA06.03.0058 | 0058 | yes
13505209 | 2.NP_SO-101 | 315 mm-315 mm-315 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 415 | 207.5 | 0.0380918 | 157.5 | 157.5 | 315-315-315 | TA06.03.0063 | 0063 | yes
13529262 | 4.NP_SO-101 | 280 mm-280 mm-225 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 325 | 190 | 0.022495 | 140 | 112.5 | 280-280-225 | TA06.03.0104 | 0104 | yes
13533642 | 4.NP_SO-101 | 225 mm-225 mm-225 mm | 4.NP_SO-101 | 4100 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 325 | 162.5 | 0.0155859 | 112.5 | 112.5 | 225-225-225 | TA06.03.0111 | 0111 | yes
13830789 | 2.NP_SO-101 | 315 mm-315 mm-315 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 415 | 207.5 | 0.0380918 | 157.5 | 157.5 | 315-315-315 | TA06.03.0295 | 0295 | yes
13908543 | 3.NP_SO-101 | 315 mm-315 mm-160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.03.0350 | 0350 | yes
13926968 | -1.PP_SO-101 | 250 mm-250 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.03.0387 | 0387 | yes
13932663 | 4.NP_SO-101 | 225 mm-225 mm-160 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 260 | 162.5 | 0.0114964 | 112.5 | 80 | 225-225-160 | TA06.03.0418 | 0418 | yes
13970300 | 1.NP_SO-101 | 250 mm-250 mm-250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 350 | 175 | 0.0205617 | 125 | 125 | 250-250-250 | TA06.03.0491 | 0491 | yes
13999475 | 1.NP_SO-101 | 250 mm-250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 350 | 175 | 0.0205617 | 125 | 125 | 250-250-250 | TA06.03.0516 | 0516 | yes
14055447 | -1.PP_SO-101 | 250 mm-250 mm-160 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.03.0697 | 0697 | yes
14062566 | 4.NP_SO-101 | 280 mm-280 mm-225 mm | 4.NP_SO-101 | 4100 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 325 | 190 | 0.022495 | 140 | 112.5 | 280-280-225 | TA06.03.0721 | 0721
14076542 | 2.NP_SO-101 | 250 mm-250 mm-160 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.03.0806 | 0806

# IfcDuctFitting: M_Kulatý spoj T:Standardní (24)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý spoj T
Classification: TA06 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: Standardní; Id typu: 1446011; Rodina: M_Kulatý spoj T; Rodina a typ: M_Kulatý spoj T: Standardní
Name (M_Kulatý spoj T:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Poloměr potrubí 1 (mm) | Poloměr potrubí 3 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
12987618 | 4.NP_SO-101 | 160 mm-160 mm-160 mm | 4.NP_SO-101 | 2710.13 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0009 | 0009 | no
13322445 | 4.NP_SO-101 | 125 mm-125 mm-125 mm | 4.NP_SO-101 | 3900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 225 | 112.5 | 0.00349063 | 62.5 | 62.5 | 125-125-125 | TA06.03.0014 | 0014 | yes
13462341 | 3.NP_SO-101 | 160 mm-160 mm-160 mm | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0050 | 0050 | yes
13462474 | 3.NP_SO-101 | 160 mm-160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0053 | 0053 | yes
13509377 | 2.NP_SO-101 | 355 mm-355 mm-225 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 325 | 227.5 | 0.0345297 | 177.5 | 112.5 | 355-355-225 | TA06.03.0083 | 0083 | yes
13527868 | 4.NP_SO-101 | 400 mm-400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 500 | 250 | 0.07291 | 200 | 200 | 400-400-400 | TA06.03.0100 | 0100 | yes
13528762 | 4.NP_SO-101 | 180 mm-180 mm-180 mm | 4.NP_SO-101 | 3900.03 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 280 | 140 | 0.00874329 | 90 | 90 | 180-180-180 | TA06.03.0101 | 0101 | yes
13540954 | -1.PP_SO-101 | 160 mm-160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0120 | 0120 | no
13762684 | -1.PP_SO-101 | 160 mm-160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0222 | 0222 | no
13904351 | 2.NP_SO-101 | 200 mm-200 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 260 | 150 | 0.00935046 | 100 | 80 | 200-200-160 | TA06.03.0331 | 0331 | yes
13924581 | -1.PP_SO-101 | 160 mm-160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0379 | 0379 | no
13924806 | -1.PP_SO-101 | 250 mm-250 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 280 | 175 | 0.0152384 | 125 | 90 | 250-250-180 | TA06.03.0381 | 0381 | yes
13930163 | 1.NP_SO-101 | 160 mm-160 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0407 | 0407 | no
13930336 | 1.NP_SO-101 | 180 mm-180 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 260 | 140 | 0.00782455 | 90 | 80 | 180-180-160 | TA06.03.0408 | 0408 | yes
13930740 | 2.NP_SO-101 | 160 mm-160 mm-160 mm | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 8 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0413 | 0413 | yes
13955247 | 1.NP_SO-101 | 200 mm-200 mm-160 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 260 | 150 | 0.00935046 | 100 | 80 | 200-200-160 | TA06.03.0451 | 0451 | yes
13960644 | 1.NP_SO-101 | 450 mm-450 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 350 | 275 | 0.0585599 | 225 | 125 | 450-450-250 | TA06.03.0459 | 0459 | yes
13966762 | -1.PP_SO-101 | 180 mm-160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 280 | 130 | 0.00733146 | 80 | 90 | 180-160-160 | TA06.03.0478 | 0478 | no
13971498 | 1.NP_SO-101 | 225 mm-225 mm-180 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 280 | 162.5 | 0.0126574 | 112.5 | 90 | 225-225-180 | TA06.03.0499 | 0499 | yes
14031023 | -1.PP_SO-101 | 160 mm-160 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0596 | 0596 | yes
14035287 | -1.PP_SO-101 | 160 mm-160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.03.0624 | 0624 | yes
14055136 | 1.NP_SO-101 | 450 mm-450 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 350 | 275 | 0.0585599 | 225 | 125 | 450-450-250 | TA06.03.0693 | 0693 | yes
14055241 | 1.NP_SO-101 | 160 mm-160 mm-125 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 225 | 130 | 0.00521937 | 80 | 62.5 | 160-160-125 | TA06.03.0695 | 0695 | yes
14060591 | 4.NP_SO-101 | 400 mm-400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 500 | 250 | 0.07291 | 200 | 200 | 400-400-400 | TA06.03.0714 | 0714

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (15)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Číslo 4: 1; Typ: 45 stupňů; Číslo 9: 1; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka01 (mm) | Delta 1 (mm) | Delta 2 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka odsazení od základny (mm) | Šířka potrubí (mm) | Velikost | Výška odsazení od základny (mm) | Výška potrubí (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 | Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 4 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Polovina Š0 (mm) | Polovina V0 (mm) | Tlaková ztráta (Pa)
13415165 | 4.NP_SO-101 | 125 mm × 225 mm-160 mm | 4.NP_SO-101 | 2551.54 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 78.4619 | 17.5 | 32.5 | -0.0173611 | 0.03125 | 0.00199375 | 62.5 | 112.5 | 0.0403622 | 80 | 160 | 3048 | 125 | 125 × 225-160 | 3048 | 225 | TA00.05.0017 | 0017 | no | 0 | 0.7 | 3.13848 | 0.7 | 1.4 | 1.68995 | 1.3 | 1.3 | 2.6 | 17.5 | 17.5 | 0 | 32.5 | 32.5 | 78.4619 | 42.2487 | 62.5 | 112.5
13442121 | 4.NP_SO-101 | 125 mm × 225 mm-160 mm | 4.NP_SO-101 | 2641.54 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 78.4619 | 17.5 | 32.5 | -0.0173611 | 0.03125 | 0.00199375 | 62.5 | 112.5 | 0.0403622 | 80 | 160 | 3048 | 125 | 125 × 225-160 | 3048 | 225 | TA00.05.0022 | 0022 | no | 0 | 0.7 | 3.13848 | 0.7 | 1.4 | 1.68995 | 1.3 | 1.3 | 2.6 | 17.5 | 17.5 | 0 | 32.5 | 32.5 | 78.4619 | 42.2487 | 62.5 | 112.5
13614156 | -1.PP_SO-101 | 630 mm × 450 mm-450 mm | -1.PP_SO-101 | 2902.71 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 217.279 | 90 | 0 | -0.0874882 | 0.0625 | 0.0496514 | 314.957 | 225 | 0.340634 | 225 | 450 | 3047.96 | 630 | 630 × 450-450 | 3048 | 450 | TA00.05.0147 | 0147 | yes | 0.0426429 | 3.60171 | 0 | 3.59829 | 7.2 | 8.69117 | 0 | 0 | 0 | 90.0426 | 89.9574 | 0 | 0 | 0 | 0 | 217.279 | 315 | 225
13740119 | -1.PP_SO-101 | 250 mm × 250 mm-250 mm | -1.PP_SO-101 | 2262.59 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 62.5 | 0 | 0 | -0.0347222 | 0.0347222 | 0.00362682 | 125 | 125 | 0.0625 | 125 | 250 | 3048 | 250 | 250 × 250-250 | 3048 | 250 | TA00.05.0211 | 0211 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 125 | 125 | 0
13935474 | 4.NP_SO-101 | 225 mm × 400 mm-225 mm | 4.NP_SO-101 | 1610.11 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 211.244 | 0 | 87.5 | -0.03125 | 0.0555556 | 0.0140881 | 112.5 | 200 | 0.150658 | 112.5 | 225 | 3048 | 225 | 225 × 400-225 | 3048 | 400 | TA00.05.0427 | 0427 | yes | 0 | 0 | 8.44975 | 0 | 0 | 0 | 3.5 | 3.5 | 7 | 0 | 0 | 0 | 87.5 | 87.5 | 211.244 | 0 | 112.5 | 200 | 0
13935481 | 4.NP_SO-101 | 280 mm × 280 mm-225 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 66.3909 | 27.5 | 27.5 | -0.0388889 | 0.0388889 | 0.00400914 | 140 | 140 | 0.0671648 | 112.5 | 225 | 3048 | 280 | 280 × 280-225 | 3048 | 280 | TA00.05.0428 | 0428 | yes | 0 | 1.1 | 2.65563 | 1.1 | 2.2 | 2.65563 | 1.1 | 1.1 | 2.2 | 27.5 | 27.5 | 0 | 27.5 | 27.5 | 66.3909 | 66.3909 | 140 | 140 | 0
13937692 | 4.NP_SO-101 | 280 mm × 280 mm-280 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 70 | 0 | 0 | -0.0388889 | 0.0388889 | 0.00509542 | 140 | 140 | 0.0784 | 140 | 280 | 3048 | 280 | 280 × 280-280 | 3048 | 280 | TA00.05.0438 | 0438 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 140 | 140 | 0
13937693 | 4.NP_SO-101 | 280 mm × 280 mm-280 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 70 | 0 | 0 | -0.0388889 | 0.0388889 | 0.00509542 | 140 | 140 | 0.0784 | 140 | 280 | 3048 | 280 | 280 × 280-280 | 3048 | 280 | TA00.05.0439 | 0439 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 140 | 140 | 0
13937700 | 4.NP_SO-101 | 280 mm × 280 mm-280 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 70 | 0 | 0 | -0.0388889 | 0.0388889 | 0.00509542 | 140 | 140 | 0.0784 | 140 | 280 | 3048 | 280 | 280 × 280-280 | 3048 | 280 | TA00.05.0440 | 0440 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 140 | 140 | 0
13968629 | 2.NP_SO-101 | 300 mm × 600 mm-315 mm | 2.NP_SO-101 | 3257.5 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 285 | 7.5 | 142.5 | -0.0416667 | 0.122917 | 0.0379697 | 150 | 442.5 | 0.293026 | 157.5 | 315 | 3048 | 300 | 300 × 600-315 | 2905.5 | 600 | TA00.05.0484 | 0484 | yes | 0 | 0.3 | 11.4 | 0.3 | 0.6 | 0.724264 | 11.4 | 0 | 11.4 | 7.5 | 7.5 | 142.5 | 285 | 0 | 285 | 18.1066 | 150 | 300 | 0
13968993 | 2.NP_SO-101 | 300 mm × 600 mm-315 mm | 2.NP_SO-101 | 3257.5 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 285 | 7.5 | 142.5 | -0.0416667 | 0.122917 | 0.0379697 | 150 | 442.5 | 0.293026 | 157.5 | 315 | 3048 | 300 | 300 × 600-315 | 2905.5 | 600 | TA00.05.0485 | 0485 | yes | 0 | 0.3 | 11.4 | 0.3 | 0.6 | 0.724264 | 11.4 | 0 | 11.4 | 7.5 | 7.5 | 142.5 | 285 | 0 | 285 | 18.1066 | 150 | 300 | 0
13999280 | 3.NP_SO-101 | 315 mm-315 mm × 158 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 190.119 | 0 | 78.75 | -0.04375 | 0.021875 | 0.012799 | 157.5 | 78.75 | 0.14448 | 157.5 | 315 | 3048 | 315 | 315-315 × 158 | 3048 | 157.5 | TA00.05.0511 | 0511 | yes | 0 | 0 | 7.60477 | 0 | 0 | 0 | 3.15 | 3.15 | 6.3 | 0 | 0 | 0 | 78.75 | 78.75 | 190.119 | 0 | 157.5 | 78.75
14000254 | 4.NP_SO-101 | 250 mm × 250 mm-250 mm | 4.NP_SO-101 | 6975 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 62.5 | 0 | 0 | -0.0347222 | 0.0347222 | 0.00362682 | 125 | 125 | 0.0625 | 125 | 250 | 3048 | 250 | 250 × 250-250 | 3048 | 250 | TA00.05.0523 | 0523 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 125 | 125 | 0
14004620 | -1.PP_SO-101 | 280 mm × 150 mm-225 mm | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 90.533 | 27.5 | 37.5 | -0.0304976 | 0.0208333 | 0.00392719 | 109.791 | 75 | 0.0651833 | 112.5 | 225 | 3017.79 | 280 | 280 × 150-225 | 3048 | 150 | TA00.05.0587 | 0587 | yes | 30.2087 | 2.30835 | 3.62132 | -0.108348 | 2.2 | 2.07974 | 1.5 | 1.5 | 3 | 57.7087 | -2.70871 | 0 | 37.5 | 37.5 | 90.533 | 51.9935 | 140 | 75 | 0
14031544 | 4.NP_SO-101 | 400 mm × 630 mm-400 mm | 4.NP_SO-101 | 1270.11 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 277.635 | 0 | 115 | -0.0555556 | 0.0875 | 0.0540151 | 200 | 315 | 0.361611 | 200 | 400 | 3048 | 400 | 400 × 630-400 | 3048 | 630 | TA00.05.0601 | 0601 | yes | 0 | 0 | 11.1054 | 0 | 0 | 0 | 4.6 | 4.6 | 9.2 | 0 | 0 | 0 | 115 | 115 | 277.635 | 0 | 200 | 315

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (13)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Šířka odsazení od základny: 3048 mm; Výška odsazení od základny: 3048 mm
Jiné - Číslo 4: 1; Délka 3: 0 mm; Typ: 45 stupňů; Číslo 9: 1; Délka 4: 0 mm; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Delta 1 (mm) = Délka 1 (mm) = Délka 2 (mm) | Delta 2 (mm) = Délka 5 (mm) = Délka 6 (mm) | Délka01 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka = Polovina Š0 (mm) | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Páteřní trasa | Délka 7 (mm) | Číslo 1 = Číslo 2 | Číslo 3 | Číslo 5 | Délka 8 (mm) | Číslo 10 | Číslo 6 = Číslo 7 | Číslo 8
13625019 | 1.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0153 | 0153 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13625021 | 1.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0154 | 0154 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13821062 | 1.NP_SO-101 | 600 mm × 500 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 142.5 | 92.5 | 344.025 | -0.0833333 | 0.0694444 | 0.0632068 | 300 | 250 | 0.405959 | 157.5 | 315 | 600 | 600 × 500-315 | 500 | TA00.05.0245 | 0245 | yes | 223.315 | 5.7 | 11.4 | 13.761 | 344.025 | 8.93259 | 3.7 | 7.4
13826683 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 2.NP_SO-101 | 2787.5 | Čerstvý | Přívod vzduchu | ODA 11 | ODA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0250 | 0250 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13827202 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 2.NP_SO-101 | 2500 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0252 | 0252 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13829125 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm |  | 2.NP_SO-101 | 3100 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0262 | 0262 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13927902 | -1.PP_SO-101 | 560 mm × 560 mm-355 mm | 0 | -1.PP_SO-101 | -500 | Čerstvý | Přívod vzduchu | ODA 18 | ODA | 102.5 | 102.5 | 247.457 | -0.0777778 | 0.0777778 | 0.05043 | 280 | 280 | 0.345657 | 177.5 | 355 | 560 | 560 × 560-355 | 560 | TA00.05.0393 | 0393 | no | 247.457 | 4.1 | 8.2 | 9.89828 | 247.457 | 9.89828 | 4.1 | 8.2
13964534 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm |  | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0465 | 0465 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13964535 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm |  | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0466 | 0466 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13969314 | 2.NP_SO-101 | 315 mm × 315 mm-315 mm |  | 2.NP_SO-101 | 3100 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0486 | 0486 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13972597 | 1.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0506 | 0506 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
13972822 | 1.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0508 | 0508 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
14000331 | 4.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 4.NP_SO-101 | 6962.5 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 0 | 0 | 78.75 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0525 | 0525 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (5)
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Šířka odsazení od základny: 3048 mm; Výška odsazení od základny: 3048 mm
Jiné - Páteřní trasa: yes; Číslo 4: 1; Délka 3: 0 mm; Typ: 45 stupňů; Číslo 9: 1; Délka 4: 0 mm; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka01 (mm) = Délka 8 (mm) | Delta 1 (mm) = Délka 1 (mm) = Délka 2 (mm) | Delta 2 (mm) = Délka 5 (mm) = Délka 6 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka = Polovina Š0 (mm) | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Číslo 1 = Číslo 2 | Číslo 10 | Číslo 3 | Číslo 5 | Číslo 6 = Číslo 7 | Číslo 8 | Délka 7 (mm)
13899254 | 1.NP_SO-101 | 315 mm × 315 mm-160 mm | 1.NP_SO-101 | 3155 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 187.102 | 77.5 | 77.5 | -0.04375 | 0.04375 | 0.0105857 | 157.5 | 157.5 | 0.123741 | 80 | 160 | 315 | 315 × 315-160 | 315 | TA00.05.0323 | 0323 | 3.1 | 7.48406 | 6.2 | 7.48406 | 3.1 | 6.2 | 187.102
13904802 | 2.NP_SO-101 | 355 mm × 355 mm-315 mm | 2.NP_SO-101 | 4270.2 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 48.2843 | 20 | 20 | -0.0493056 | 0.0493056 | 0.00508242 | 177.5 | 177.5 | 0.0899957 | 157.5 | 315 | 355 | 355 × 355-315 | 355 | TA00.05.0335 | 0335 | 0.8 | 1.93137 | 1.6 | 1.93137 | 0.8 | 1.6 | 48.2843
13928737 | 1.NP_SO-101 | 315 mm × 315 mm-160 mm | 1.NP_SO-101 | 3155 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 187.102 | 77.5 | 77.5 | -0.04375 | 0.04375 | 0.0105857 | 157.5 | 157.5 | 0.123741 | 80 | 160 | 315 | 315 × 315-160 | 315 | TA00.05.0401 | 0401 | 3.1 | 7.48406 | 6.2 | 7.48406 | 3.1 | 6.2 | 187.102
13929979 | 1.NP_SO-101 | 315 mm × 315 mm-160 mm | 1.NP_SO-101 | 3155.01 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 187.102 | 77.5 | 77.5 | -0.04375 | 0.04375 | 0.0105857 | 157.5 | 157.5 | 0.123741 | 80 | 160 | 315 | 315 × 315-160 | 315 | TA00.05.0402 | 0402 | 3.1 | 7.48406 | 6.2 | 7.48406 | 3.1 | 6.2 | 187.102
14055107 | 3.NP_SO-101 | 250 mm × 355 mm-315 mm | 3.NP_SO-101 | 3151.54 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 78.4619 | 32.5 | 20 | -0.0347222 | 0.0493056 | 0.00685152 | 125 | 177.5 | 0.0968812 | 157.5 | 315 | 250 | 250 × 355-315 | 355 | TA00.05.0691 | 0691 | 1.3 | 1.93137 | 2.6 | 3.13848 | 0.8 | 1.6 | 48.2843

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (43)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Výška odsazení od základny: 3048 mm
Jiné - Číslo 4: 1; Typ: 45 stupňů; Číslo 9: 1; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířka odsazení od základny (mm) | Délka01 (mm) | Delta 1 (mm) | Delta 2 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Délka 4 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 | Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Polovina Š0 (mm)
13442660 | 3.NP_SO-101 | 400 mm-400 mm × 200 mm | 0 | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 3048 | 241.421 | 0 | 100 | -0.0555556 | 0.0277778 | 0.0262074 | 200 | 100 | 0.232973 | 200 | 400 | 400 | 400-400 × 200 | 200 | TA00.05.0029 | 0029 | yes | 0 | 0 | 0 | 9.65685 | 0 | 0 | 0 | 4 | 4 | 8 | 0 | 0 | 100 | 100 | 241.421 | 0 | 200
13442947 | 3.NP_SO-101 | 400 mm-400 mm × 200 mm |  | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 2 | SUP | 3048 | 241.421 | 0 | 100 | -0.0555556 | 0.0277778 | 0.0262074 | 200 | 100 | 0.232973 | 200 | 400 | 400 | 400-400 × 200 | 200 | TA00.05.0031 | 0031 | yes | 0 | 0 | 0 | 9.65685 | 0 | 0 | 0 | 4 | 4 | 8 | 0 | 0 | 100 | 100 | 241.421 | 0 | 200
13505528 | 1.NP_SO-101 | 700 mm × 400 mm-315 mm | 0 | 1.NP_SO-101 | 5702 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 3048 | 464.736 | 192.5 | 42.5 | -0.0972222 | 0.0555556 | 0.0822864 | 350 | 200 | 0.50414 | 157.5 | 315 | 700 | 700 × 400-315 | 400 | TA00.05.0067 | 0067 | yes | 0 | 0 | 7.7 | 4.10416 | 7.7 | 15.4 | 18.5894 | 1.7 | 1.7 | 3.4 | 192.5 | 192.5 | 42.5 | 42.5 | 102.604 | 464.736 | 350
13505574 | 1.NP_SO-101 | 700 mm × 400 mm-315 mm | 0 | 1.NP_SO-101 | 5702 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 3048 | 464.736 | 192.5 | 42.5 | -0.0972222 | 0.0555556 | 0.0822864 | 350 | 200 | 0.50414 | 157.5 | 315 | 700 | 700 × 400-315 | 400 | TA00.05.0069 | 0069 | yes | 0 | 0 | 7.7 | 4.10416 | 7.7 | 15.4 | 18.5894 | 1.7 | 1.7 | 3.4 | 192.5 | 192.5 | 42.5 | 42.5 | 102.604 | 464.736 | 350
13505683 | 1.NP_SO-101 | 700 mm × 400 mm-315 mm | 0 | 1.NP_SO-101 | 5702 | Čerstvý | Přívod vzduchu | ODA 11 | ODA | 3048 | 464.736 | 192.5 | 42.5 | -0.0972222 | 0.0555556 | 0.0822864 | 350 | 200 | 0.50414 | 157.5 | 315 | 700 | 700 × 400-315 | 400 | TA00.05.0071 | 0071 | yes | 0 | 0 | 7.7 | 4.10416 | 7.7 | 15.4 | 18.5894 | 1.7 | 1.7 | 3.4 | 192.5 | 192.5 | 42.5 | 42.5 | 102.604 | 464.736 | 350
13505762 | 1.NP_SO-101 | 700 mm × 400 mm-315 mm | 0 | 1.NP_SO-101 | 5702 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 3048 | 464.736 | 192.5 | 42.5 | -0.0972222 | 0.0555556 | 0.0822864 | 350 | 200 | 0.50414 | 157.5 | 315 | 700 | 700 × 400-315 | 400 | TA00.05.0072 | 0072 | yes | 0 | 0 | 7.7 | 4.10416 | 7.7 | 15.4 | 18.5894 | 1.7 | 1.7 | 3.4 | 192.5 | 192.5 | 42.5 | 42.5 | 102.604 | 464.736 | 350
13538084 | 1.NP_SO-101 | 225 mm × 75 mm-125 mm | 0 | 1.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 120.711 | 50 | 25 | -0.03125 | 0.0104167 | 0.00192722 | 112.5 | 37.5 | 0.0420419 | 62.5 | 125 | 225 | 225 × 75-125 | 75 | TA00.05.0114 | 0114 | no | 0 | 0 | 2 | 2.41421 | 2 | 4 | 4.82843 | 1 | 1 | 2 | 50 | 50 | 25 | 25 | 60.3553 | 120.711 | 112.5
13595663 | -1.PP_SO-101 | 315 mm × 160 mm-180 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 3048 | 162.959 | 67.5 | 10 | -0.04375 | 0.0222222 | 0.00644216 | 157.5 | 80 | 0.0899147 | 90 | 180 | 315 | 315 × 160-180 | 160 | TA00.05.0146 | 0146 | yes | 0 | 0 | 2.7 | 0.965685 | 2.7 | 5.4 | 6.51838 | 0.4 | 0.4 | 0.8 | 67.5 | 67.5 | 10 | 10 | 24.1421 | 162.959 | 157.5
13614571 | -1.PP_SO-101 | 315 mm × 630 mm-450 mm |  | -1.PP_SO-101 | 2895.59 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 217.279 | 67.5 | 90 | -0.04375 | 0.0875 | 0.0412916 | 157.5 | 315 | 0.306867 | 225 | 450 | 315 | 315 × 630-450 | 630 | TA00.05.0148 | 0148 | yes | 0 | 0 | 2.7 | 8.69117 | 2.7 | 5.4 | 6.51838 | 3.6 | 3.6 | 7.2 | 67.5 | 67.5 | 90 | 90 | 217.279 | 162.959 | 157.5
13630570 | -1.PP_SO-101 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0168 | 0168 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13801183 | 1.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0242 | 0242 | yes | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13801240 | -1.PP_SO-101 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0243 | 0243 | yes | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13827792 | 3.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0260 | 0260 | yes | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13829434 | 2.NP_SO-101 | 300 mm × 600 mm-315 mm |  | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 3048 | 344.025 | 7.5 | 142.5 | -0.0416667 | 0.0833333 | 0.0458335 | 150 | 300 | 0.337362 | 157.5 | 315 | 300 | 300 × 600-315 | 600 | TA00.05.0263 | 0263 | yes | 0 | 0 | 0.3 | 13.761 | 0.3 | 0.6 | 0.724264 | 5.7 | 5.7 | 11.4 | 7.5 | 7.5 | 142.5 | 142.5 | 344.025 | 18.1066 | 150
13842127 | -1.PP_SO-101 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-101 | 2519.88 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0307 | 0307 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
