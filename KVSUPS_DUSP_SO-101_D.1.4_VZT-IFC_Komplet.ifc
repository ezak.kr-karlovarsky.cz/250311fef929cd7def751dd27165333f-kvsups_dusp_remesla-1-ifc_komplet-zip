Properties of the parts of a building model (IFC4), part 20 of 21

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (298)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému = Group | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13452380 | -1.PP_SO-101 | 380 | 0.0201032 | 0.191009 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0085 | 0085 | no
13452391 | -1.PP_SO-101 | 5440 | 0.0201032 | 2.73444 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0086 | 0086 | no
13455602 | 3.NP_SO-101 | 4422.26 | 0.0254431 | 2.50073 | 180 mm | 0 | 180 mm | 0.257944 | 0.0166667 | 7789.98 | 0.654959 | 0.0513604 | 0.0494547 | 3.NP_SO-101 | 0 | 3140 | 3050 | 3050 | 2960 | 180 | Zpětný vzduch | 0.199115 | ETA 19 | 221 | Odváděný | ETA | PO02.02.0094 | 0094 | no
13455923 | 3.NP_SO-101 | 2278.81 | 0.0201032 | 1.14546 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 246 | Přívodní | SUP | PO02.02.0095 | 0095 | yes
13455938 | 3.NP_SO-101 | 3214.38 | 0.0201032 | 1.61572 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 246 | Přívodní | SUP | PO02.02.0096 | 0096 | yes
13455949 | 3.NP_SO-101 | 4803.67 | 0.0201032 | 2.41459 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 248 | Přívodní | SUP | PO02.02.0097 | 0097 | yes
13456603 | 3.NP_SO-101 | 4720 | 0.0201032 | 2.37253 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 256 | Přívodní | SUP | PO02.02.0103 | 0103 | yes
13462036 | 4.NP_SO-101 | 4720 | 0.0201032 | 2.37253 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 4050 | 4050 | -670 | -670 | 160 | Zpětný vzduch | 0 | ETA 19 | 257 | Odváděný | ETA | PO02.02.0114 | 0114 | yes | Identifikační data - Komentáře: VEDENO DO 4.NP
13462179 | 3.NP_SO-101 | 550.594 | 0.0201032 | 0.276759 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0479769 | 0.0871367 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0.116117 | ETA 19 | 294 | Odváděný | ETA | PO02.02.0115 | 0115 | yes
13462362 | 3.NP_SO-101 | 559.15 | 0.0201032 | 0.28106 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0 | ETA 19 | 189 | Odváděný | ETA | PO02.02.0116 | 0116 | yes
13462475 | 3.NP_SO-101 | 779.048 | 0.0201032 | 0.391592 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 246 | Přívodní | SUP | PO02.02.0117 | 0117 | yes
13462613 | 4.NP_SO-101 | 542.348 | 0.0201032 | 0.272614 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4210 | 4210 | 4130 | 160 | Zpětný vzduch | 0 | ETA 19 | 257 | Odváděný | ETA | PO02.02.0118 | 0118 | yes
13462626 | 4.NP_SO-101 | 7158.46 | 0.0201032 | 3.59823 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4210 | 4210 | 4130 | 160 | Zpětný vzduch | 0 | ETA 19 | 257 | Odváděný | ETA | PO02.02.0119 | 0119 | yes | Identifikační data - Komentáře: POTRUBÍ VEDENO NAD SEBOU
13462652 | 4.NP_SO-101 | 548.894 | 0.0201032 | 0.275904 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3780 | 3700 | 3700 | 3620 | 160 | Přívod vzduchu | 0 | SUP 43 | 225 | Přívodní | SUP | PO02.02.0120 | 0120 | yes | Identifikační data - Komentáře: VZT3
13462661 | 4.NP_SO-101 | 4230 | 0.0201032 | 2.12623 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3540 | 3540 | -690 | -690 | 160 | Přívod vzduchu | 0 | SUP 43 | 225 | Přívodní | SUP | PO02.02.0121 | 0121 | yes
13462665 | 4.NP_SO-101 | 7328.46 | 0.0201032 | 3.68369 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3780 | 3700 | 3700 | 3620 | 160 | Přívod vzduchu | 0 | SUP 43 | 225 | Přívodní | SUP | PO02.02.0122 | 0122 | yes
13508729 | 2.NP_SO-101 | 1868.9 | 0.0201032 | 0.939412 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0484429 | 0.0259205 | 2.NP_SO-101 |  | 6029.67 | 6029.67 | 4160.76 | 4160.76 | 160 | Zpětný vzduch | 0.46898 | ETA 19 | 228 | Odváděný | ETA | PO02.02.0153 | 0153 | yes
13511644 | 3.NP_SO-101 | 1416.57 | 0.0201032 | 0.712046 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0284237 | 0.0259205 | 3.NP_SO-101 | 0 | 3130 | 3050 | 3050 | 2970 | 160 | Zpětný vzduch | 0.275172 | ETA 19 | 3 | Odváděný | ETA | PO02.02.0161 | 0161 | no
13512014 | 4.NP_SO-101 | 3309.36 | 0.0201032 | 1.66346 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3780 | 3700 | 3700 | 3620 | 160 | Přívod vzduchu | 0 | SUP 43 | 225 | Přívodní | SUP | PO02.02.0162 | 0162 | yes
13522108 | 4.NP_SO-101 | 299.874 | 0.0201032 | 0.150733 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3140 | 2840.13 | 3140 | 2840.13 | 160 | Zpětný vzduch | 0 | ETA 29 | 279 | Odváděný | ETA | PO02.02.0173 | 0173 | no
13528763 | 4.NP_SO-101 | 1541.9 | 0.01227 | 0.605502 | 125 mm | 0 | 125 mm | 1.10911 | 0.0166667 | 11217.6 | 1.35812 | 0.44382 | 0.28784 | 4.NP_SO-101 | 0 | 3962.53 | 3900.03 | 3900 | 3837.5 | 125 | Zpětný vzduch | 0.400158 | ETA 19 | 253 | Odváděný | ETA | PO02.02.0178 | 0178 | yes
13533567 | 4.NP_SO-101 | 2020 | 0.0201032 | 1.01536 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4180 | 4100 | 4100 | 4020 | 160 | Přívod vzduchu | 0 | SUP 43 | 279 | Přívodní | SUP | PO02.02.0186 | 0186 | yes
13533643 | 4.NP_SO-101 | 282.953 | 0.0397548 | 0.200008 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4212.5 | 4100 | 4100 | 3987.5 | 225 | Přívod vzduchu | 0 | SUP 43 | 172 | Přívodní | SUP | PO02.02.0188 | 0188 | yes
13540429 | -1.PP_SO-101 | 2453.47 | 0.0201032 | 1.23325 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0599593 | 0.0259205 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.580471 | ETA 30 | 180 | Odváděný | ETA | PO02.02.0196 | 0196 | no
13540602 | -1.PP_SO-101 | 19.7761 | 0.0254431 | 0.0111831 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.00697989 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.00300663 | ETA 30 | 197 | Odváděný | ETA | PO02.02.0197 | 0197 | no
13540609 | -1.PP_SO-101 | 2068.33 | 0.0254431 | 1.16961 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.23824 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.102624 | ETA 30 | 197 | Odváděný | ETA | PO02.02.0198 | 0198 | no
13540962 | -1.PP_SO-101 | 1216.53 | 0.0201032 | 0.611493 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0268661 | 0.0259205 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.260093 | ETA 30 | 254 | Odváděný | ETA | PO02.02.0199 | 0199 | no
13542111 | -1.PP_SO-101 | 9.24284 | 0.0254431 | 0.0052267 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.00326222 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.00140522 | ETA 30 | 189 | Odváděný | ETA | PO02.02.0200 | 0200 | yes
13542129 | -1.PP_SO-101 | 482.156 | 0.04908 | 0.378685 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2645 | 2520 | 2520 | 2395 | 250 | Zpětný vzduch | 0 | ETA 30 | 438 | Odváděný | ETA | PO02.02.0201 | 0201 | yes
13544748 | -1.PP_SO-101 | 24.9563 | 0.0254431 | 0.0141125 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.00880822 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.0037942 | ETA 30 | 267 | Odváděný | ETA | PO02.02.0202 | 0202 | yes
13546859 | -1.PP_SO-101 | 91.3655 | 0.0254431 | 0.051666 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 221 | Odváděný | ETA | PO02.02.0203 | 0203 | yes
13546862 | -1.PP_SO-101 | 109.616 | 0.0254431 | 0.0619864 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 3 | Odváděný | ETA | PO02.02.0204 | 0204 | yes
13546869 | -1.PP_SO-101 | 520 | 0.0254431 | 0.294053 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 5 | Odváděný | ETA | PO02.02.0205 | 0205 | no
13546875 | -1.PP_SO-101 | 3732.41 | 0.0254431 | 2.11063 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 5 | Odváděný | ETA | PO02.02.0206 | 0206 | no
13546879 | -1.PP_SO-101 | 3587.41 | 0.0201032 | 1.80323 | 160 mm | 0 | 160 mm | 0.929647 | 0.025 | 13145.6 | 1.2434 | 0.0283 | 0.179304 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Zpětný vzduch | 0.0304417 | ETA 35 | 10 | Odváděný | ETA | PO02.02.0207 | 0207 | no
13546887 | -1.PP_SO-101 | 900 | 0.0254431 | 0.508938 | 180 mm | 0 | 180 mm | 0.064486 | 0.00833333 | 3894.99 | 0.327479 | 0.00919842 | 0.0148045 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0.142642 | ETA 35 | 6 | Odváděný | ETA | PO02.02.0208 | 0208 | no
13547028 | -1.PP_SO-101 | 640 | 0.0254431 | 0.361911 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 219 | Odváděný | ETA | PO02.02.0209 | 0209 | yes
13547031 | -1.PP_SO-101 | 109.616 | 0.0254431 | 0.0619864 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 18 | Odváděný | ETA | PO02.02.0210 | 0210 | yes
13547040 | -1.PP_SO-101 | 3582.73 | 0.0201032 | 1.80088 | 160 mm | 0 | 160 mm | 0.929647 | 0.025 | 13145.6 | 1.2434 | 0.0183766 | 0.179304 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Zpětný vzduch | 0.0197673 | ETA 35 | 21 | Odváděný | ETA | PO02.02.0211 | 0211 | no
13547042 | -1.PP_SO-101 | 1778.63 | 0.0254431 | 1.00579 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 20 | Odváděný | ETA | PO02.02.0212 | 0212 | no
13547044 | -1.PP_SO-101 | 61.3242 | 0.0254431 | 0.034678 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 20 | Odváděný | ETA | PO02.02.0213 | 0213 | no
13547052 | -1.PP_SO-101 | 446 | 0.0254431 | 0.252207 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 20 | Odváděný | ETA | PO02.02.0214 | 0214 | no
13547789 | -1.PP_SO-101 | 1830.4 | 0.0201032 | 0.920057 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0887216 | 0.0871367 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.214731 | ETA 30 | 270 | Odváděný | ETA | PO02.02.0216 | 0216 | no
13548147 | -1.PP_SO-101 | 3149.04 | 0.0254431 | 1.78074 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 1.11144 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.47876 | ETA 30 | 282 | Odváděný | ETA | PO02.02.0217 | 0217 | yes
13548163 | -1.PP_SO-101 | 1798.02 | 0.04908 | 1.41216 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2645 | 2520 | 2520 | 2395 | 250 | Zpětný vzduch | 0 | ETA 30 | 438 | Odváděný | ETA | PO02.02.0218 | 0218 | yes | Identifikační data - Komentáře: VZT5/6
13577643 | -1.PP_SO-101 | 633.726 | 0.0201032 | 0.318545 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0219 | 0219 | yes | Identifikační data - Komentáře: VZT9
13577840 | -1.PP_SO-101 | 1757.87 | 0.0201032 | 0.883601 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0220 | 0220 | no
13617975 | 1.NP_SO-101 | 190.614 | 0.0201032 | 0.0958132 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Odváděný vzduch | 0 | EHA 10 | 3 | Znehodnocený | EHA | PO02.02.0229 | 0229 | yes
13618001 | 1.NP_SO-101 | 269.044 | 0.0779194 | 0.266246 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Přívod vzduchu | 0 | ODA 10 | 1 | Čerstvý | ODA | PO02.02.0230 | 0230 | yes
13618071 | 1.NP_SO-101 | 1980.33 | 0.0779194 | 1.95974 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Přívod vzduchu | 0 | ODA 10 | 1 | Čerstvý | ODA | PO02.02.0231 | 0231 | yes
13620731 | -1.PP_SO-101 | 14691 | 0.0201032 | 7.3845 | 160 mm | 0 | 160 mm | 3.31689 | 0.0472222 | 24830.6 | 2.34864 | 8.3329 | 0.567211 | -1.PP_SO-101 | 0 | 2580 | 2500 | 2500 | 2420 | 160 | Přívod vzduchu | 2.51226 | SUP 27 | 311 | Přívodní | SUP | PO02.02.0233 | 0233 | no
13622267 | -1.PP_SO-101 | 17285.7 | 0.0201032 | 8.68875 | 160 mm | 0 | 160 mm | 8.99807 | 0.0777778 | 40897.4 | 3.86835 | 0.583174 | 1.42537 | -1.PP_SO-101 | 0 | 2720 | 2640 | 2640 | 2560 | 160 | Zpětný vzduch | 0.064811 | ETA 30 | 379 | Odváděný | ETA | PO02.02.0234 | 0234 | no
13624768 | 1.NP_SO-101 | 450.36 | 0.0779194 | 0.445677 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Přívod vzduchu | 0 | ODA 10 | 3 | Čerstvý | ODA | PO02.02.0237 | 0237 | yes
13625017 | 1.NP_SO-101 | 170.34 | 0.0779194 | 0.168569 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Přívod vzduchu | 0 | ODA 10 | 1 | Čerstvý | ODA | PO02.02.0238 | 0238 | yes
13625053 | 1.NP_SO-101 | 470 | 0.0779194 | 0.465113 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Odváděný vzduch | 0 | EHA 10 | 1 | Znehodnocený | EHA | PO02.02.0239 | 0239 | yes
13625865 | 1.NP_SO-101 | 38.817 | 0.0201032 | 0.0195115 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Odváděný vzduch | 0 | EHA 10 | 3 | Znehodnocený | EHA | PO02.02.0240 | 0240 | yes
13625906 | 2.NP_SO-101 | 4453.1 | 0.0201032 | 2.23837 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | 3768.1 | 3768.1 | -685 | -685 | 160 | Odváděný vzduch | 0 | EHA 10 | 3 | Znehodnocený | EHA | PO02.02.0241 | 0241 | yes | Identifikační data - Komentáře: VZT 4
13626503 | 2.NP_SO-101 | 131.868 | 0.0779194 | 0.130497 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 4427.7 | 4270.2 | 4270.2 | 4112.7 | 315 | Odváděný vzduch | 0 | EHA 10 | 4 | Znehodnocený | EHA | PO02.02.0243 | 0243 | yes | Identifikační data - Komentáře: VZT4
13630220 | -1.PP_SO-101 | 105.436 | 0.0254431 | 0.0596226 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.0372131 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.0160298 | ETA 30 | 261 | Odváděný | ETA | PO02.02.0246 | 0246 | yes
13630244 | -1.PP_SO-101 | 25.4359 | 0.0254431 | 0.0143837 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.00897749 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.00386712 | ETA 30 | 265 | Odváděný | ETA | PO02.02.0247 | 0247 | yes
13630322 | -1.PP_SO-101 | 87.1098 | 0.0254431 | 0.0492594 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 22 | Odváděný | ETA | PO02.02.0248 | 0248 | yes
13630348 | -1.PP_SO-101 | 87.1098 | 0.0254431 | 0.0492594 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 212 | Odváděný | ETA | PO02.02.0249 | 0249 | yes
13632089 | 1.NP_SO-101 | 886.96 | 0.0201032 | 0.445835 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 9 | Odváděný | ETA | PO02.02.0250 | 0250 | yes
13632092 | 1.NP_SO-101 | 200.976 | 0.0201032 | 0.101022 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 3 | Odváděný | ETA | PO02.02.0251 | 0251 | yes
13632102 | 1.NP_SO-101 | 287.11 | 0.0201032 | 0.144317 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 7 | Odváděný | ETA | PO02.02.0252 | 0252 | yes
13632218 | 1.NP_SO-101 | 170.396 | 0.0201032 | 0.0856503 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 5 | Odváděný | ETA | PO02.02.0253 | 0253 | yes
13632245 | 1.NP_SO-101 | 1056.49 | 0.0201032 | 0.531052 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 9 | Odváděný | ETA | PO02.02.0254 | 0254 | yes
13632449 | 1.NP_SO-101 | 615.858 | 0.0201032 | 0.309564 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 22 | 9 | Odváděný | ETA | PO02.02.0255 | 0255 | yes
13704476 | 3.NP_SO-101 | 2265.76 | 0.0201032 | 1.1389 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Přívod vzduchu | 0 | SUP 43 | 178 | Přívodní | SUP | PO02.02.0256 | 0256 | no | Identifikační data - Komentáře: VEDENO DO 2.NP
13704504 | 3.NP_SO-101 | 49.4821 | 0.0201032 | 0.0248724 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Přívod vzduchu | 0 | SUP 43 | 178 | Přívodní | SUP | PO02.02.0257 | 0257 | no | Identifikační data - Komentáře: VEDENO DO 2.NP
13704518 | 3.NP_SO-101 | 2362.95 | 0.0254431 | 1.33622 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Přívod vzduchu | 0 | SUP 43 | 182 | Přívodní | SUP | PO02.02.0258 | 0258 | no
13704628 | 3.NP_SO-101 | 2077.39 | 0.0314112 | 1.30526 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Přívod vzduchu | 0 | SUP 43 | 184 | Přívodní | SUP | PO02.02.0259 | 0259 | no
13704686 | 3.NP_SO-101 | 2040.99 | 0.04908 | 1.60299 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3425 | 3300 | 3300 | 3175 | 250 | Přívod vzduchu | 0 | SUP 43 | 186 | Přívodní | SUP | PO02.02.0260 | 0260 | no
13704738 | 3.NP_SO-101 | 2251.81 | 0.0201032 | 1.13188 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.082271 | 0.0871367 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Zpětný vzduch | 0.199118 | ETA 29 | 171 | Odváděný | ETA | PO02.02.0261 | 0261 | no
13704785 | 3.NP_SO-101 | 147.836 | 0.0201032 | 0.0743104 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0128819 | 0.0871367 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Zpětný vzduch | 0.0311778 | ETA 29 | 171 | Odváděný | ETA | PO02.02.0262 | 0262 | no
13704799 | 3.NP_SO-101 | 2271.19 | 0.0254431 | 1.28433 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.0959453 | 0.10133 | 3.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Zpětný vzduch | 0.165316 | ETA 29 | 271 | Odváděný | ETA | PO02.02.0263 | 0263 | no
13704819 | 3.NP_SO-101 | 2255.22 | 0.0314112 | 1.417 | 200 mm | 0 | 200 mm | 0.676948 | 0.0333333 | 14022 | 1.06103 | 0.105045 | 0.101665 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Zpětný vzduch | 0.155174 | ETA 29 | 274 | Odváděný | ETA | PO02.02.0264 | 0264 | no
13704887 | 3.NP_SO-101 | 2236.47 | 0.0314112 | 1.40521 | 200 mm | 0 | 200 mm | 1.05773 | 0.0416667 | 17527.4 | 1.32629 | 0.138518 | 0.151683 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Zpětný vzduch | 0.130958 | ETA 29 | 277 | Odváděný | ETA | PO02.02.0265 | 0265 | no
13705172 | 3.NP_SO-101 | 2060.84 | 0.0254431 | 1.16538 | 180 mm | 0 | 180 mm | 0.064486 | 0.00833333 | 3894.99 | 0.327479 | 0.0154832 | 0.0148045 | 3.NP_SO-101 | 0 | 3140 | 3050 | 3050 | 2960 | 180 | Zpětný vzduch | 0.240102 | ETA 19 | 213 | Odváděný | ETA | PO02.02.0269 | 0269 | yes | Identifikační data - Komentáře: VEDENO DO 2.NP
13705274 | 3.NP_SO-101 | 2600.8 | 0.0254431 | 1.47072 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3140 | 3050 | 3050 | 2960 | 180 | Zpětný vzduch | 0 | ETA 19 | 193 | Odváděný | ETA | PO02.02.0270 | 0270 | yes | Identifikační data - Komentáře: VEDENO DO 2.NP
13715968 | 1.NP_SO-101 | 947.616 | 0.0201032 | 0.476324 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 310 | Odváděný | ETA | PO02.02.0274 | 0274 | no
13716070 | 1.NP_SO-101 | 347.756 | 0.0201032 | 0.174801 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 353 | Odváděný | ETA | PO02.02.0275 | 0275 | yes
13716117 | 1.NP_SO-101 | 2031.24 | 0.0201032 | 1.02101 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 310 | Odváděný | ETA | PO02.02.0276 | 0276 | no
13716284 | 2.NP_SO-101 | 2059.91 | 0.0201032 | 1.03542 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0226558 | 0.0871367 | 2.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0.0548334 | ETA 4 | 342 | Odváděný | ETA | PO02.02.0277 | 0277 | no
13716291 | 2.NP_SO-101 | 1136.8 | 0.0201032 | 0.571416 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0182584 | 0.0259205 | 2.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0.176761 | ETA 4 | 343 | Odváděný | ETA | PO02.02.0278 | 0278 | no
13716651 | 2.NP_SO-101 | 908.094 | 0.0201032 | 0.456458 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00538309 | 0.0259205 | 2.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0.0521142 | ETA 4 | 235 | Odváděný | ETA | PO02.02.0280 | 0280 | no
13716851 | 3.NP_SO-101 | 881.329 | 0.0201032 | 0.443004 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 160 | Zpětný vzduch | 0 | ETA 4 | 390 | Odváděný | ETA | PO02.02.0281 | 0281 | no
13716871 | 3.NP_SO-101 | 2179.9 | 0.0201032 | 1.09574 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0175316 | 0.0871367 | 3.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 160 | Zpětný vzduch | 0.0424313 | ETA 4 | 390 | Odváděný | ETA | PO02.02.0283 | 0283 | no
13716875 | 3.NP_SO-101 | 2905.45 | 0.0201032 | 1.46044 | 160 mm | 0 | 160 mm | 0.929647 | 0.025 | 13145.6 | 1.2434 | 0.0261679 | 0.179304 | 3.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 160 | Zpětný vzduch | 0.0281482 | ETA 4 | 243 | Odváděný | ETA | PO02.02.0284 | 0284 | no
13741310 | -1.PP_SO-101 | 2892.32 | 0.0254431 | 1.63557 | 180 mm | 0 | 180 mm | 4.1271 | 0.0666667 | 31159.9 | 2.61983 | 0.564193 | 0.597513 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.136704 | ETA 30 | 170 | Odváděný | ETA | PO02.02.0303 | 0303 | no
13761733 | -1.PP_SO-101 | 2899.86 | 0.0254431 | 1.63983 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 1.02349 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.440877 | ETA 30 | 283 | Odváděný | ETA | PO02.02.0308 | 0308 | yes
13762387 | -1.PP_SO-101 | 3.98715 | 0.0201032 | 0.00200416 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 245 | Odváděný | ETA | PO02.02.0309 | 0309 | yes
13762550 | -1.PP_SO-101 | 1341.73 | 0.0201032 | 0.674428 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.102413 | 0.398018 | -1.PP_SO-101 | 0 | 2480 | 2400 | 2400 | 2320 | 160 | Zpětný vzduch | 0.0455267 | ETA 4 | 249 | Odváděný | ETA | PO02.02.0310 | 0310 | no
13762697 | -1.PP_SO-101 | 670 | 0.0201032 | 0.336779 | 160 mm | 0 | 160 mm | 8.99807 | 0.0777778 | 40897.4 | 3.86835 | 0.693628 | 1.42537 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.0770863 | ETA 4 | 260 | Odváděný | ETA | PO02.02.0311 | 0311 | no
13762705 | -1.PP_SO-101 | 267.028 | 0.0201032 | 0.134223 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.106282 | 0.398018 | -1.PP_SO-101 | 0 | 2599.88 | 2519.88 | 2519.88 | 2439.88 | 160 | Zpětný vzduch | 0.0472466 | ETA 4 | 253 | Odváděný | ETA | PO02.02.0312 | 0312 | no
13763054 | 4.NP_SO-101 | 63.8627 | 0.0254431 | 0.0361135 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Zpětný vzduch | 0 | ETA 29 | 377 | Odváděný | ETA | PO02.02.0313 | 0313 | no
13763062 | 4.NP_SO-101 | 785.442 | 0.0254431 | 0.444157 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Zpětný vzduch | 0 | ETA 29 | 377 | Odváděný | ETA | PO02.02.0314 | 0314 | yes
13763298 | 4.NP_SO-101 | 824.265 | 0.0254431 | 0.466111 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2932.53 | 2932.53 | 2108.27 | 2108.27 | 180 | Zpětný vzduch | 0 | ETA 29 | 377 | Odváděný | ETA | PO02.02.0315 | 0315 | yes
13763476 | -1.PP_SO-101 | 544.461 | 0.0201032 | 0.273676 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.216705 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.0963342 | ETA 31 | 8 | Odváděný | ETA | PO02.02.0316 | 0316 | yes
13763479 | -1.PP_SO-101 | 309.616 | 0.0201032 | 0.15563 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.123233 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.0547819 | ETA 31 | 3 | Odváděný | ETA | PO02.02.0317 | 0317 | yes
13763483 | -1.PP_SO-101 | 287.11 | 0.0201032 | 0.144317 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.114275 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.0507998 | ETA 31 | 10 | Odváděný | ETA | PO02.02.0318 | 0318 | yes
13763495 | -1.PP_SO-101 | 171.36 | 0.0201032 | 0.0861351 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.0682046 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.0303197 | ETA 31 | 5 | Odváděný | ETA | PO02.02.0319 | 0319 | yes
13763758 | -1.PP_SO-101 | 5536.63 | 0.0201032 | 2.78301 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 2.20368 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.979624 | ETA 31 | 5 | Odváděný | ETA | PO02.02.0320 | 0320 | yes | Identifikační data - Komentáře: VZT16
13763857 | 2.NP_SO-101 | 182.272 | 0.0201032 | 0.0916199 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 1 | 2 | Odváděný | ETA | PO02.02.0321 | 0321 | yes | Identifikační data - Komentáře: VZT14
13764198 | 3.NP_SO-101 | 3680 | 0.0201032 | 1.84977 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 |  | 2990 | 2990 | -690 | -690 | 160 | Zpětný vzduch | 0 | ETA 1 | 2 | Odváděný | ETA | PO02.02.0322 | 0322 | yes
13764308 | 3.NP_SO-101 | 996.221 | 0.0201032 | 0.500755 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 1 | 2 | Odváděný | ETA | PO02.02.0323 | 0323 | yes | Identifikační data - Komentáře: VZT 14
13764382 | 4.NP_SO-101 | 7805 | 0.0201032 | 3.92322 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 7115 | 7115 | -690 | -690 | 160 | Zpětný vzduch | 0 | ETA 1 | 2 | Odváděný | ETA | PO02.02.0324 | 0324 | yes | Identifikační data - Komentáře: VZT 14
13765152 | 2.NP_SO-101 | 275.858 | 0.0201032 | 0.138661 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.109796 | 0.398018 | 2.NP_SO-101 | 0 | 4350.2 | 4270.2 | 4270.2 | 4190.2 | 160 | Zpětný vzduch | 0.0488089 | ETA 31 | 5 | Odváděný | ETA | PO02.02.0330 | 0330 | yes | Identifikační data - Komentáře: VZT16
13790051 | 4.NP_SO-101 | 762.328 | 0.0201032 | 0.383188 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 1105.23 | 1105.23 | 342.906 | 342.906 | 160 | Zpětný vzduch | 0 | ETA 29 | 286 | Odváděný | ETA | PO02.02.0331 | 0331 | yes
13790345 | 4.NP_SO-101 | 1037.57 | 0.0201032 | 0.521538 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2440 | 2440 | 1402.43 | 1402.43 | 160 | Zpětný vzduch | 0 | ETA 29 | 2 | Odváděný | ETA | PO02.02.0332 | 0332 | yes
13790352 | 4.NP_SO-101 | 8.20928 | 0.0201032 | 0.00412643 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 351.115 | 351.115 | 342.906 | 342.906 | 160 | Zpětný vzduch | 0 | ETA 29 | 289 | Odváděný | ETA | PO02.02.0333 | 0333 | yes
13790407 | 4.NP_SO-101 | 422.278 | 0.0201032 | 0.21226 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 262.906 | 182.906 | 182.906 | 102.906 | 160 | Zpětný vzduch | 0 | ETA 29 | 289 | Odváděný | ETA | PO02.02.0334 | 0334 | yes
13790671 | 4.NP_SO-101 | 99.2784 | 0.0201032 | 0.0499027 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 262.906 | 182.906 | 182.906 | 102.906 | 160 | Zpětný vzduch | 0 | ETA 29 | 286 | Odváděný | ETA | PO02.02.0335 | 0335 | yes
13790849 | 4.NP_SO-101 | 768.778 | 0.0201032 | 0.38643 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2680 | 2600 | 2600 | 2520 | 160 | Zpětný vzduch | 0 | ETA 29 | 2 | Odváděný | ETA | PO02.02.0336 | 0336 | yes
13790901 | 4.NP_SO-101 | 655 | 0.0201032 | 0.329239 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3415 | 3415 | 2760 | 2760 | 160 | Zpětný vzduch | 0 | ETA 29 | 2 | Odváděný | ETA | PO02.02.0337 | 0337 | yes
13801547 | 3.NP_SO-101 | 4989.16 | 0.0201032 | 2.50782 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.265414 | 0.0871367 | 3.NP_SO-101 | 0 | 3130 | 3050 | 3050 | 2970 | 160 | Zpětný vzduch | 0.642374 | ETA 19 | 222 | Odváděný | ETA | PO02.02.0339 | 0339 | no
13827909 | 3.NP_SO-101 | 2014 | 0.0201032 | 1.01235 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 256 | Přívodní | SUP | PO02.02.0349 | 0349 | yes
13828009 | 3.NP_SO-101 | 535.026 | 0.0201032 | 0.268933 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00899566 | 0.0259205 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0.0870879 | ETA 19 | 153 | Odváděný | ETA | PO02.02.0350 | 0350 | yes
13831340 | 1.NP_SO-101 | 1999.25 | 0.0201032 | 1.00493 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 40 | Odváděný | ETA | PO02.02.0365 | 0365 | yes
13831354 | 1.NP_SO-101 | 97.6002 | 0.0201032 | 0.0490592 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 16 | Odváděný | ETA | PO02.02.0366 | 0366 | yes
13831422 | 1.NP_SO-101 | 219.376 | 0.0201032 | 0.11027 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 3 | Odváděný | ETA | PO02.02.0367 | 0367 | yes
13831594 | 2.NP_SO-101 | 315.858 | 0.0201032 | 0.158767 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 4350.2 | 4270.2 | 4270.2 | 4190.2 | 160 | Zpětný vzduch | 0 | ETA 2 | 14 | Odváděný | ETA | PO02.02.0368 | 0368 | yes | Identifikační data - Komentáře: VZT15a/b
13831772 | 1.NP_SO-101 | 60 | 0.0201032 | 0.0301593 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 345 | Odváděný | ETA | PO02.02.0369 | 0369 | yes
13832057 | -1.PP_SO-101 | 1805.96 | 0.0201032 | 0.907776 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Zpětný vzduch | 0 | ETA 2 | 11 | Odváděný | ETA | PO02.02.0370 | 0370 | no
13832355 | 1.NP_SO-101 | 15.3482 | 0.0201032 | 0.00771486 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Přívod vzduchu | 0 | SUP 43 | 275 | Přívodní | SUP | PO02.02.0371 | 0371 | yes
13835070 | 3.NP_SO-101 | 134.616 | 0.0254431 | 0.0761235 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3140 | 3050 | 3050 | 2960 | 180 | Zpětný vzduch | 0 | ETA 19 | 207 | Odváděný | ETA | PO02.02.0375 | 0375 | yes
13835587 | 4.NP_SO-101 | 155.88 | 0.0254431 | 0.0881483 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Zpětný vzduch | 0 | ETA 29 | 377 | Odváděný | ETA | PO02.02.0377 | 0377 | no
13844039 | 3.NP_SO-101 | 231.695 | 0.0201032 | 0.116463 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 |  | 2845.86 | 2614.16 | 2845.86 | 2614.16 | 160 | Zpětný vzduch | 0 | ETA 19 | 202 | Odváděný | ETA | PO02.02.0392 | 0392 | yes
13845169 | 3.NP_SO-101 | 2032.97 | 0.0201032 | 1.02188 | 160 mm | 15 | 190 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0 | ETA 19 | 158 | Odváděný | ETA | PO02.02.0394 | 0394 | yes | Izolace - Typ izolace: Protipožární
13845211 | 3.NP_SO-101 | 855.331 | 0.0201032 | 0.429936 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00472059 | 0.0259205 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0.0457005 | ETA 19 | 158 | Odváděný | ETA | PO02.02.0395 | 0395 | yes
13849732 | 3.NP_SO-101 | 2024.08 | 0.0201032 | 1.01741 | 160 mm | 15 | 190 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 256 | Přívodní | SUP | PO02.02.0399 | 0399 | yes | Izolace - Typ izolace: Protipožární
13849869 | 3.NP_SO-101 | 696.961 | 0.0201032 | 0.350331 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3260 | 3180 | 3180 | 3100 | 160 | Přívod vzduchu | 0 | SUP 43 | 256 | Přívodní | SUP | PO02.02.0400 | 0400 | yes
13903274 | 2.NP_SO-101 | 148.726 | 0.0201032 | 0.0747578 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | -1521.94 | -1670.67 | -1521.94 | -1670.67 | 160 | Zpětný vzduch | 0 | ETA 6 | 246 | Odváděný | ETA | PO02.02.0401 | 0401 | yes
13903393 | 2.NP_SO-101 | 150.074 | 0.0201032 | 0.0754353 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | -1139 | -1195.57 | -1301.69 | -1358.26 | 160 | Zpětný vzduch | 0 | ETA 5 | 237 | Odváděný | ETA | PO02.02.0402 | 0402 | yes
13903489 | 2.NP_SO-101 | 528.726 | 0.0201032 | 0.265767 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | -1068.71 | -1148.71 | -1148.71 | -1228.71 | 160 | Zpětný vzduch | 0 | ETA 5 | 237 | Odváděný | ETA | PO02.02.0403 | 0403 | yes
13904129 | 2.NP_SO-101 | 70.0738 | 0.0201032 | 0.0352229 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | -1139 | -1195.57 | -1245.12 | -1301.69 | 160 | Zpětný vzduch | 0 | ETA 5 | 222 | Odváděný | ETA | PO02.02.0404 | 0404 | yes
13904133 | 2.NP_SO-101 | 5.69913 | 0.0201032 | 0.0028647 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | -1068.71 | -1148.71 | -1148.71 | -1228.71 | 160 | Zpětný vzduch | 0 | ETA 5 | 222 | Odváděný | ETA | PO02.02.0405 | 0405 | yes
13904138 | 2.NP_SO-101 | 89.9767 | 0.0201032 | 0.0452272 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | -1365.33 | -1421.9 | -1485.52 | -1542.09 | 160 | Zpětný vzduch | 0 | ETA 5 | 222 | Odváděný | ETA | PO02.02.0406 | 0406 | no
13904152 | 2.NP_SO-101 | 50.0738 | 0.0201032 | 0.0251699 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | -1139 | -1195.57 | -1230.98 | -1287.55 | 160 | Zpětný vzduch | 0 | ETA 16 | 254 | Odváděný | ETA | PO02.02.0407 | 0407 | yes
13904161 | 2.NP_SO-101 | 109.977 | 0.0201032 | 0.0552803 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | -1351.19 | -1407.76 | -1485.52 | -1542.09 | 160 | Zpětný vzduch | 0 | ETA 16 | 254 | Odváděný | ETA | PO02.02.0408 | 0408 | no
13904227 | 1.NP_SO-101 | 705.157 | 0.0314112 | 0.443063 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2951.29 | 2851.29 | 2851.29 | 2751.29 | 200 | Zpětný vzduch | 0 | ETA 5 | 238 | Odváděný | ETA | PO02.02.0409 | 0409 | yes
13904254 | 1.NP_SO-101 | 1596.96 | 0.0201032 | 0.802721 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2931.29 | 2851.29 | 2851.29 | 2771.29 | 160 | Zpětný vzduch | 0 | ETA 5 | 224 | Odváděný | ETA | PO02.02.0410 | 0410 | yes
13904352 | 1.NP_SO-101 | 46.3298 | 0.0314112 | 0.0291099 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2951.29 | 2851.29 | 2851.29 | 2751.29 | 200 | Zpětný vzduch | 0 | ETA 5 | 229 | Odváděný | ETA | PO02.02.0411 | 0411 | yes
13904583 | 1.NP_SO-101 | 547.005 | 0.0201032 | 0.274955 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 2 | Odváděný | ETA | PO02.02.0412 | 0412 | yes
13904586 | 1.NP_SO-101 | 1071.78 | 0.0201032 | 0.538733 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 2 | Odváděný | ETA | PO02.02.0413 | 0413 | yes
13904590 | 1.NP_SO-101 | 950.858 | 0.0201032 | 0.477953 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 2 | Odváděný | ETA | PO02.02.0414 | 0414 | yes
13905359 | 1.NP_SO-101 | 484.396 | 0.0201032 | 0.243484 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 7 | Odváděný | ETA | PO02.02.0415 | 0415 | yes
13905375 | 1.NP_SO-101 | 266.053 | 0.0201032 | 0.133733 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 7 | Odváděný | ETA | PO02.02.0416 | 0416 | yes
13905385 | 1.NP_SO-101 | 719.386 | 0.0201032 | 0.361603 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 7 | Odváděný | ETA | PO02.02.0417 | 0417 | yes
13905393 | 1.NP_SO-101 | 777.619 | 0.0201032 | 0.390874 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 7 | Odváděný | ETA | PO02.02.0418 | 0418 | yes | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13905433 | 1.NP_SO-101 | 1220 | 0.0201032 | 0.613239 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 |  | 2990 | 1770 | 2990 | 1770 | 160 | Zpětný vzduch | 0 | ETA 7 | 7 | Odváděný | ETA | PO02.02.0419 | 0419 | yes
13905582 | 1.NP_SO-101 | 269.981 | 0.0201032 | 0.135707 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 7 | 4 | Odváděný | ETA | PO02.02.0420 | 0420 | yes
13907902 | 2.NP_SO-101 | 170.616 | 0.0201032 | 0.0857608 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 8 | 241 | Odváděný | ETA | PO02.02.0424 | 0424 | yes
13911193 | 2.NP_SO-101 | 364.213 | 0.0201032 | 0.183073 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 287 | Odváděný | ETA | PO02.02.0427 | 0427 | yes
13911360 | 2.NP_SO-101 | 4.30736 | 0.0201032 | 0.00216511 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 267 | Odváděný | ETA | PO02.02.0428 | 0428 | no
13919659 | 1.NP_SO-101 | 4.95045 | 0.0314112 | 0.00311046 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2951.29 | 2851.29 | 2851.29 | 2751.29 | 200 | Zpětný vzduch | 0 | ETA 5 | 253 | Odváděný | ETA | PO02.02.0435 | 0435 | yes
13920080 | -1.PP_SO-101 | 198.934 | 0.0254431 | 0.112495 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 2 | 6 | Odváděný | ETA | PO02.02.0437 | 0437 | yes
13920140 | -1.PP_SO-101 | 2606.79 | 0.0201032 | 1.31032 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Zpětný vzduch | 0 | ETA 2 | 24 | Odváděný | ETA | PO02.02.0438 | 0438 | no
13920242 | -1.PP_SO-101 | 1537.72 | 0.0254431 | 0.869558 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 2 | 22 | Odváděný | ETA | PO02.02.0439 | 0439 | no
13920409 | -1.PP_SO-101 | 645.934 | 0.0254431 | 0.365267 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 2 | 17 | Odváděný | ETA | PO02.02.0440 | 0440 | yes
13920503 | -1.PP_SO-101 | 270.899 | 0.0254431 | 0.15319 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 2 | 348 | Odváděný | ETA | PO02.02.0441 | 0441 | yes | Identifikační data - Komentáře: VZT15a
13923160 | -1.PP_SO-101 | 680 | 0.0201032 | 0.341805 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.017626 | 0.0259205 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.170639 | ETA 30 | 429 | Odváděný | ETA | PO02.02.0442 | 0442 | no
13923557 | -1.PP_SO-101 | 2340 | 0.0201032 | 1.17621 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0749376 | 0.0871367 | -1.PP_SO-101 | 0 | 1780 | 1700 | 1700 | 1620 | 160 | Zpětný vzduch | 0.181369 | ETA 30 | 345 | Odváděný | ETA | PO02.02.0443 | 0443 | no
13923973 | -1.PP_SO-101 | 630 | 0.0201032 | 0.316673 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0548961 | 0.0871367 | -1.PP_SO-101 |  | 2490 | 2490 | 1860 | 1860 | 160 | Zpětný vzduch | 0.132864 | ETA 30 | 345 | Odváděný | ETA | PO02.02.0444 | 0444 | no
13923986 | -1.PP_SO-101 | 639.604 | 0.0201032 | 0.3215 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.055733 | 0.0871367 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.134889 | ETA 30 | 345 | Odváděný | ETA | PO02.02.0445 | 0445 | no
13924003 | -1.PP_SO-101 | 597.257 | 0.0201032 | 0.300214 | 160 mm | 0 | 160 mm | 1.65271 | 0.0333333 | 17527.4 | 1.65786 | 0.179743 | 0.300947 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.108757 | ETA 30 | 386 | Odváděný | ETA | PO02.02.0446 | 0446 | no
13924325 | -1.PP_SO-101 | 3259.37 | 0.0201032 | 1.63834 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0596912 | 0.0871367 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.144469 | ETA 30 | 340 | Odváděný | ETA | PO02.02.0447 | 0447 | no
13924479 | -1.PP_SO-101 | 180 | 0.0201032 | 0.0904779 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00466569 | 0.0259205 | -1.PP_SO-101 | 0 | 2180 | 2100 | 2100 | 2020 | 160 | Zpětný vzduch | 0.045169 | ETA 30 | 429 | Odváděný | ETA | PO02.02.0448 | 0448 | no
13924544 | -1.PP_SO-101 | 230 | 0.0201032 | 0.115611 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00596172 | 0.0259205 | -1.PP_SO-101 |  | 2490 | 2490 | 2260 | 2260 | 160 | Zpětný vzduch | 0.057716 | ETA 30 | 429 | Odváděný | ETA | PO02.02.0449 | 0449 | no
13924794 | -1.PP_SO-101 | 97.9282 | 0.0254431 | 0.0553771 | 180 mm | 0 | 180 mm | 2.3215 | 0.05 | 23369.9 | 1.96488 | 0.0345633 | 0.352946 | -1.PP_SO-101 | 0 | 2610 | 2520 | 2520 | 2430 | 180 | Zpětný vzduch | 0.0148884 | ETA 30 | 282 | Odváděný | ETA | PO02.02.0450 | 0450 | yes
13924807 | -1.PP_SO-101 | 24.6837 | 0.04908 | 0.0193865 | 250 mm | 0 | 250 mm | 0.623876 | 0.05 | 16826.4 | 1.01859 | 0.00175881 | 0.0712539 | -1.PP_SO-101 | 0 | 2645 | 2520 | 2520 | 2395 | 250 | Zpětný vzduch | 0.00281916 | ETA 30 | 275 | Odváděný | ETA | PO02.02.0451 | 0451 | yes
13927078 | -1.PP_SO-101 | 418.995 | 0.0201032 | 0.21061 | 160 mm | 0 | 160 mm | 3.31689 | 0.0472222 | 24830.6 | 2.34864 | 0.237658 | 0.567211 | -1.PP_SO-101 | 100 | 2509.71 | 2156.86 | 2453.14 | 2100.29 | 160 | Přívod vzduchu | 0.071651 | SUP 27 | 311 | Přívodní | SUP | PO02.02.0462 | 0462 | yes
13927097 | -1.PP_SO-101 | 779.737 | 0.0201032 | 0.391939 | 160 mm | 0 | 160 mm | 3.31689 | 0.0472222 | 24830.6 | 2.34864 | 0.442275 | 0.567211 | -1.PP_SO-101 | 0 | 2190 | 2110 | 2110 | 2030 | 160 | Přívod vzduchu | 0.13334 | SUP 27 | 311 | Přívodní | SUP | PO02.02.0463 | 0463 | yes
13927108 | -1.PP_SO-101 | 50 | 0.0201032 | 0.0251328 | 160 mm | 0 | 160 mm | 3.31689 | 0.0472222 | 24830.6 | 2.34864 | 0.0283606 | 0.567211 | -1.PP_SO-101 |  | 2320 | 2320 | 2270 | 2270 | 160 | Přívod vzduchu | 0.00855035 | SUP 27 | 311 | Přívodní | SUP | PO02.02.0464 | 0464 | yes
13927202 | -1.PP_SO-101 | 613.593 | 0.0201032 | 0.308425 | 160 mm | 0 | 160 mm | 8.99807 | 0.0777778 | 40897.4 | 3.86835 | 0.874598 | 1.42537 | -1.PP_SO-101 | 100 | 2649.71 | 2159.26 | 2593.14 | 2102.69 | 160 | Zpětný vzduch | 0.0971985 | ETA 30 | 379 | Odváděný | ETA | PO02.02.0465 | 0465 | yes
13927215 | -1.PP_SO-101 | 470.847 | 0.0201032 | 0.236674 | 160 mm | 0 | 160 mm | 8.99807 | 0.0777778 | 40897.4 | 3.86835 | 0.671132 | 1.42537 | -1.PP_SO-101 | 0 | 2192.4 | 2112.4 | 2112.4 | 2032.4 | 160 | Zpětný vzduch | 0.0745863 | ETA 30 | 379 | Odváděný | ETA | PO02.02.0466 | 0466 | yes
13927226 | -1.PP_SO-101 | 47.6015 | 0.0201032 | 0.0239271 | 160 mm | 0 | 160 mm | 8.99807 | 0.0777778 | 40897.4 | 3.86835 | 0.0678498 | 1.42537 | -1.PP_SO-101 | 96674 | 2320.08 | 2320 | 2272.4 | 2272.32 | 160 | Zpětný vzduch | 0.00754049 | ETA 30 | 379 | Odváděný | ETA | PO02.02.0467 | 0467 | yes
13928486 | -1.PP_SO-101 | 5176.06 | 0.0254431 | 2.92699 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | 11236.1 | 11236.1 | 6060 | 6060 | 180 | Zpětný vzduch | 0 | ETA 2 | 5 | Odváděný | ETA | PO02.02.0470 | 0470 | yes | Identifikační data - Komentáře: VZT15a/b
13929969 | 1.NP_SO-101 | 564.737 | 0.0201032 | 0.283868 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0146383 | 0.0259205 | 1.NP_SO-101 | 0 | 3235.01 | 3155 | 3155.01 | 3075 | 160 | Zpětný vzduch | 0.141715 | ETA 29 | 344 | Odváděný | ETA | PO02.02.0471 | 0471 | yes
13929981 | 1.NP_SO-101 | 305.327 | 0.0201032 | 0.153474 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00791424 | 0.0259205 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Zpětný vzduch | 0.0766185 | ETA 29 | 344 | Odváděný | ETA | PO02.02.0472 | 0472 | yes
13930130 | 1.NP_SO-101 | 1790.92 | 0.0201032 | 0.900216 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 346 | Odváděný | ETA | PO02.02.0473 | 0473 | no
13930140 | 1.NP_SO-101 | 380 | 0.0201032 | 0.191009 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 346 | Odváděný | ETA | PO02.02.0474 | 0474 | no | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13930155 | 1.NP_SO-101 | 410 | 0.0201032 | 0.206088 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 347 | Odváděný | ETA | PO02.02.0475 | 0475 | no | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13930164 | 1.NP_SO-101 | 1518.01 | 0.0201032 | 0.763036 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2860 | 2780 | 2780 | 2700 | 160 | Zpětný vzduch | 0 | ETA 2 | 345 | Odváděný | ETA | PO02.02.0476 | 0476 | no
13930337 | -1.PP_SO-101 | 3170 | 0.0254431 | 1.79259 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | 5800 | 5800 | 2630 | 2630 | 180 | Zpětný vzduch | 0 | ETA 2 | 348 | Odváděný | ETA | PO02.02.0477 | 0477 | yes
13930346 | 1.NP_SO-101 | 438.839 | 0.04908 | 0.344664 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2905 | 2780 | 2780 | 2655 | 250 | Zpětný vzduch | 0 | ETA 2 | 341 | Odváděný | ETA | PO02.02.0478 | 0478 | yes
13930398 | 1.NP_SO-101 | 50 | 0.0201032 | 0.0251327 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 |  | 2620 | 2570 | 2620 | 2570 | 160 | Zpětný vzduch | 0 | ETA 2 | 347 | Odváděný | ETA | PO02.02.0479 | 0479 | no
13930434 | 1.NP_SO-101 | 50 | 0.0201032 | 0.0251327 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 |  | 2620 | 2570 | 2620 | 2570 | 160 | Zpětný vzduch | 0 | ETA 2 | 346 | Odváděný | ETA | PO02.02.0480 | 0480 | no
13930714 | 2.NP_SO-101 | 370.696 | 0.0201032 | 0.186332 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00507366 | 0.0259205 | 2.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0.0491186 | ETA 8 | 240 | Odváděný | ETA | PO02.02.0481 | 0481 | yes
13930754 | 2.NP_SO-101 | 889.304 | 0.0201032 | 0.447013 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00425773 | 0.0259205 | 2.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0.0412195 | ETA 8 | 242 | Odváděný | ETA | PO02.02.0482 | 0482 | yes
13932562 | 4.NP_SO-101 | 12060.4 | 0.0254431 | 6.81997 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2970 | 2880 | 2880 | 2790 | 180 | Přívod vzduchu | 0 | SUP 43 | 8 | Přívodní | SUP | PO02.02.0484 | 0484 | no
13932655 | 4.NP_SO-101 | 651.238 | 0.0201032 | 0.327348 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2960 | 2880 | 2880 | 2800 | 160 | Přívod vzduchu | 0 | SUP 43 | 189 | Přívodní | SUP | PO02.02.0485 | 0485 | no
13932672 | 4.NP_SO-101 | 1287.02 | 0.0201032 | 0.646928 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2960 | 2880 | 2880 | 2800 | 160 | Přívod vzduchu | 0 | SUP 43 | 189 | Přívodní | SUP | PO02.02.0487 | 0487 | no
13933717 | 1.NP_SO-101 | 2760 | 0.0201032 | 1.38733 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 277 | Odváděný | ETA | PO02.02.0488 | 0488 | no
13934247 | 1.NP_SO-101 | 374.538 | 0.0201032 | 0.188263 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 353 | Odváděný | ETA | PO02.02.0490 | 0490 | yes
13934721 | 3.NP_SO-101 | 403.145 | 0.0201032 | 0.202643 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3525 | 3445 | 3445 | 3365 | 160 | Zpětný vzduch | 0 | ETA 4 | 317 | Odváděný | ETA | PO02.02.0491 | 0491 | yes
13935053 | 3.NP_SO-101 | 518.103 | 0.0201032 | 0.260427 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3525 | 3445 | 3445 | 3365 | 160 | Zpětný vzduch | 0 | ETA 4 | 316 | Odváděný | ETA | PO02.02.0492 | 0492 | yes
13938213 | -1.PP_SO-101 | 8450.2 | 0.0201032 | 4.24754 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 3.36334 | 0.398018 | -1.PP_SO-101 |  | 11260.2 | 11260.2 | 2810 | 2810 | 160 | Zpětný vzduch | 1.49514 | ETA 31 | 5 | Odváděný | ETA | PO02.02.0508 | 0508 | yes | Identifikační data - Komentáře: VZT16
13955232 | 1.NP_SO-101 | 285.674 | 0.0201032 | 0.143595 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2931.29 | 2851.29 | 2851.29 | 2771.29 | 160 | Zpětný vzduch | 0 | ETA 5 | 237 | Odváděný | ETA | PO02.02.0513 | 0513 | yes
13955248 | 1.NP_SO-101 | 456.444 | 0.0314112 | 0.286792 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2951.29 | 2851.29 | 2851.29 | 2751.29 | 200 | Zpětný vzduch | 0 | ETA 5 | 234 | Odváděný | ETA | PO02.02.0514 | 0514 | yes
13958447 | -1.PP_SO-101 | 3300 | 0.0201032 | 1.65876 | 160 mm | 15 | 190 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 1.31346 | 0.398018 | -1.PP_SO-101 | 0 | 2730 | 2650 | 2650 | 2570 | 160 | Zpětný vzduch | 0.583886 | ETA 31 | 5 | Odváděný | ETA | PO02.02.0515 | 0515 | yes | Identifikační data - Komentáře: VZT16; Izolace - Typ izolace: Protipožární
13960308 | 1.NP_SO-101 | 319.564 | 0.159008 | 0.451773 | 450 mm | 0 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3105 | 2880 | 2880 | 2655 | 450 | Přívod vzduchu | 0 | SUP 27 | 368 | Přívodní | SUP | PO02.02.0519 | 0519 | yes | Identifikační data - Komentáře: VZT1
13960345 | 1.NP_SO-101 | 1416.59 | 0.04908 | 1.11259 | 250 mm | 0 | 250 mm | 0.155969 | 0.025 | 8413.18 | 0.509296 | 0.00469086 | 0.0208741 | 1.NP_SO-101 | 0 | 3375 | 3250 | 3250 | 3125 | 250 | Zpětný vzduch | 0.0300756 | ETA 30 | 401 | Odváděný | ETA | PO02.02.0520 | 0520 | yes
13960610 | 1.NP_SO-101 | 60 | 0.04908 | 0.0471239 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3275 | 3150 | 3150 | 3025 | 250 | Zpětný vzduch | 0 | ETA 30 | 368 | Odváděný | ETA | PO02.02.0522 | 0522 | yes
13960645 | 1.NP_SO-101 | 6.2733 | 0.159008 | 0.00886867 | 450 mm | 0 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3375 | 3150 | 3150 | 2925 | 450 | Zpětný vzduch | 0 | ETA 30 | 367 | Odváděný | ETA | PO02.02.0523 | 0523 | yes
13965927 | -1.PP_SO-101 | 107.948 | 0.0201032 | 0.0542604 | 160 mm | 0 | 160 mm | 20.2456 | 0.116667 | 61346.1 | 5.80252 | 0.329175 | 3.0494 | -1.PP_SO-101 | 100 | 2332.78 | 2276.21 | 2199.88 | 2143.31 | 160 | Zpětný vzduch | 0.0162591 | ETA 30 | 354 | Odváděný | ETA | PO02.02.0535 | 0535 | yes
13966846 | -1.PP_SO-101 | 51.2994 | 0.0201032 | 0.0257859 | 160 mm | 0 | 160 mm | 1.65271 | 0.0333333 | 17527.4 | 1.65786 | 0.0154384 | 0.300947 | -1.PP_SO-101 | 100 | 2659.71 | 2566.86 | 2603.14 | 2510.29 | 160 | Zpětný vzduch | 0.00934129 | ETA 30 | 386 | Odváděný | ETA | PO02.02.0536 | 0536 | no
13966939 | -1.PP_SO-101 | 75.5913 | 0.0201032 | 0.0379963 | 160 mm | 0 | 160 mm | 1.65271 | 0.0333333 | 17527.4 | 1.65786 | 0.022749 | 0.300947 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.0137647 | ETA 30 | 386 | Odváděný | ETA | PO02.02.0537 | 0537 | no
13970327 | 1.NP_SO-101 | 68.1843 | 0.04908 | 0.0535518 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3005 | 2880 | 2880 | 2755 | 250 | Přívod vzduchu | 0 | SUP 27 | 338 | Přívodní | SUP | PO02.02.0548 | 0548 | yes
13971499 | 1.NP_SO-101 | 590.633 | 0.0397548 | 0.417494 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 225 | Zpětný vzduch | 0 | ETA 30 | 123 | Odváděný | ETA | PO02.02.0553 | 0553 | yes | Identifikační data - Komentáře: OSAZENY REGULÁTORY PRŮTOKU NA STOUPAČCE
13972389 | 1.NP_SO-101 | 114.255 | 0.0201032 | 0.0574306 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Přívod vzduchu | 0 | SUP 43 | 275 | Přívodní | SUP | PO02.02.0554 | 0554 | yes
13972406 | 1.NP_SO-101 | 18.2363 | 0.0201032 | 0.00916656 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3235 | 3155 | 3155 | 3075 | 160 | Přívod vzduchu | 0 | SUP 43 | 275 | Přívodní | SUP | PO02.02.0555 | 0555 | yes
13972497 | 1.NP_SO-101 | 210.03 | 0.0779194 | 0.207846 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Přívod vzduchu | 0 | SUP 43 | 260 | Přívodní | SUP | PO02.02.0556 | 0556 | yes
13972620 | 1.NP_SO-101 | 210 | 0.0779194 | 0.207816 | 315 mm | 0 | 315 mm | 0.00687564 | 0.00833333 | 2225.71 | 0.106932 | 0.000221329 | 0.00105395 | 1.NP_SO-101 | 0 | 3312.5 | 3155 | 3155 | 2997.5 | 315 | Zpětný vzduch | 0.0321904 | ETA 29 | 300 | Odváděný | ETA | PO02.02.0557 | 0557 | yes
13998852 | 4.NP_SO-101 | 3319.96 | 0.0201032 | 1.66879 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4210 | 4210 | 4130 | 160 | Zpětný vzduch | 0 | ETA 19 | 257 | Odváděný | ETA | PO02.02.0558 | 0558 | yes
14002589 | -1.PP_SO-101 | 1141.29 | 0.0201032 | 0.573677 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 327 | Odváděný | ETA | PO02.02.0564 | 0564 | no
14002590 | -1.PP_SO-101 | 37.1569 | 0.0201032 | 0.0186771 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2529.71 | 2446.86 | 2473.14 | 2390.29 | 160 | Zpětný vzduch | 0 | ETA 4 | 327 | Odváděný | ETA | PO02.02.0565 | 0565 | no
14002715 | -1.PP_SO-101 | 367.452 | 0.0201032 | 0.184701 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0566 | 0566 | no
14002796 | -1.PP_SO-101 | 668.165 | 0.0201032 | 0.335856 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0567 | 0567 | no
14030164 | 4.NP_SO-101 | 50 | 0.0201032 | 0.0251327 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3940 | 3890 | 3940 | 3890 | 160 | Přívod vzduchu | 0 | SUP 43 | 279 | Přívodní | SUP | PO02.02.0580 | 0580 | yes
14030179 | 4.NP_SO-101 | 429.822 | 0.0201032 | 0.216052 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3810 | 3730 | 3730 | 3650 | 160 | Přívod vzduchu | 0 | SUP 43 | 279 | Přívodní | SUP | PO02.02.0581 | 0581 | yes
14030843 | 1.NP_SO-101 | 242.595 | 0.01227 | 0.0952667 | 125 mm | 0 | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 100 | 3207.58 | 2991.85 | 3163.39 | 2947.65 | 125 | Zpětný vzduch | 0 | ETA 30 | 423 | Odváděný | ETA | PO02.02.0583 | 0583 | yes
14035640 | 4.NP_SO-101 | 134.039 | 0.04908 | 0.105274 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 593.794 | 459.754 | 593.794 | 459.754 | 250 | Zpětný vzduch | 0 | ETA 29 | 3 | Odváděný | ETA | PO02.02.0598 | 0598 | yes
14042179 | -1.PP_SO-101 | 11.206 | 0.0201032 | 0.00563275 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0599 | 0599 | yes
14042228 | -1.PP_SO-101 | 27.4517 | 0.0201032 | 0.0137987 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2642.84 | 2586.27 | 2566.86 | 2510.29 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0600 | 0600 | yes
14042247 | -1.PP_SO-101 | 203.908 | 0.0201032 | 0.102495 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2713.14 | 2633.14 | 2633.14 | 2553.14 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0601 | 0601 | yes
14042299 | -1.PP_SO-101 | 27.4517 | 0.0201032 | 0.0137987 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2642.84 | 2566.86 | 2586.27 | 2510.29 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0602 | 0602 | yes
14042576 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2559.71 | 2396.86 | 2503.14 | 2340.29 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0603 | 0603 | no
14042634 | -1.PP_SO-101 | 445.166 | 0.0201032 | 0.223765 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2430 | 2350 | 2350 | 2270 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0604 | 0604 | no
14042646 | -1.PP_SO-101 | 8.87302 | 0.0201032 | 0.00446006 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2459.71 | 2403.14 | 2396.86 | 2340.29 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0605 | 0605 | no
