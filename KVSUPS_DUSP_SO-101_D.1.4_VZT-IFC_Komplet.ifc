Properties of the parts of a building model (IFC4), part 15 of 21

# IfcDuctFitting: M_Kulaté koleno:1 D (306)
Name (M_Kulaté koleno:1 D:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka1 (mm) | Objem (m3) | Poloměr potrubí (mm) | Střední poloměr (mm) | Úhel (deg) | Velikost | Kód prvku | Označení | Páteřní trasa | Tlaková ztráta (Pa)
14064724 | 4.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 4.NP_SO-101 | 3900.02 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 74.5584 | 0.00359731 | 90 | 180 | 45 | 180-180 | TA00.02.0738 | 0738 |  | -58036.8
14065628 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 3840.01 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 75.0258 | 0.00902697 | 140 | 280 | 30 | 280-280 | TA00.02.0741 | 0741
14065645 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 3840 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 75.0258 | 0.00902697 | 140 | 280 | 30 | 280-280 | TA00.02.0742 | 0742
14066467 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 3840 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 75.0273 | 0.00902714 | 140 | 280 | 30.0006 | 280-280 | TA00.02.0743 | 0743
14066545 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 3875 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 75.0258 | 0.00902697 | 140 | 280 | 30 | 280-280 | TA00.02.0744 | 0744 |  | -53965.4
14066550 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 3875 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 115.98 | 0.0135405 | 140 | 280 | 45 | 280-280 | TA00.02.0745 | 0745 |  | -53965.4
14067680 | 3.NP_SO-101 | 200 mm-200 mm | 0 | 200 mm-200 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 26.3305 | 0.00164485 | 100 | 200 | 15 | 200-200 | TA00.02.0749 | 0749 |  | 0
14067696 | 3.NP_SO-101 | 200 mm-200 mm | 0 | 200 mm-200 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 26.3305 | 0.00164485 | 100 | 200 | 15 | 200-200 | TA00.02.0750 | 0750 |  | 0
14069851 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3965.58 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 21.0784 | 0.00084272 | 80 | 160 | 15.0099 | 160-160 | TA00.02.0759 | 0759 |  | 0
14069853 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3400 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0760 | 0760 |  | -10329.3
14069993 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 4139.7 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 21.0644 | 0.000842165 | 80 | 160 | 15 | 160-160 | TA00.02.0761 | 0761 |  | 0
14070024 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0762 | 0762 |  | 0
14070264 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0764 | 0764 |  | -42261.1
14070266 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0765 | 0765 |  | -42261.1
14070381 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0767 | 0767
14070394 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0768 | 0768
14070572 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 52.661 | 0.0131585 | 200 | 400 | 15 | 400-400 | TA00.02.0769 | 0769
14070664 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 52.661 | 0.0131585 | 200 | 400 | 15 | 400-400 | TA00.02.0770 | 0770
14070746 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3550 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 52.661 | 0.0131585 | 200 | 400 | 15 | 400-400 | TA00.02.0771 | 0771
14070853 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3550 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 52.661 | 0.0131585 | 200 | 400 | 15 | 400-400 | TA00.02.0772 | 0772
14071572 | 1.NP_SO-101 | 200 mm-200 mm | 0 | 200 mm-200 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 200 | 0.00986929 | 100 | 200 | 90 | 200-200 | TA00.02.0773 | 0773 |  | 0
14072121 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0780 | 0780 |  | -62386.9
14072140 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0781 | 0781 |  | -62386.9
14072181 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3320 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0782 | 0782 |  | -62386.9
14072197 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0783 | 0783 |  | -62386.9
14074929 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0791 | 0791 |  | 0
14075347 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0792 | 0792
14075366 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963781 | 125 | 250 | 44.9998 | 250-250 | TA00.02.0794 | 0794
14075547 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3320 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0795 | 0795 |  | -62386.9
14075575 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3320 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0796 | 0796 |  | -62386.9
14075588 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0797 | 0797 |  | -62386.9
14075729 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0798 | 0798 |  | -62386.9
14075929 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0802 | 0802 |  | 0
14076180 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3320 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0804 | 0804 |  | -62386.9
14076196 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0805 | 0805 |  | 0
14076550 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0807 | 0807 |  | 0
14076673 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0808 | 0808 |  | 0
14076701 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 66.9873 | 0.00642522 | 125 | 250 | 30 | 250-250 | TA00.02.0809 | 0809 |  | 0
14079059 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0811 | 0811 |  | 0
14080887 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0823 | 0823 |  | 0
14081368 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3280 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0828 | 0828
14081586 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3280 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 160.096 | 0.00505501 | 80 | 160 | 90.0344 | 160-160 | TA00.02.0829 | 0829 |  | 0
14081704 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3280 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 66.2742 | 0.00252651 | 80 | 160 | 45 | 160-160 | TA00.02.0830 | 0830 |  | 0
14081761 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0831 | 0831 |  | 0
14081886 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0834 | 0834 |  | 0

# IfcDuctFitting: M_Kulaté křížení:Standardní, M_Kulaté křížení:Standardní:14054881
In: 3.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 15; Popis: Redukce; Popis sestavy: Tvarovka potrubí (VZT)
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté křížení
Classification: TA Uniformat (Uniformat); Group: ETA 19
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 180 mm-180 mm-180 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 180 mm-180 mm-180 mm-160 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 3.NP_SO-101; Výška od podlaží: 3050 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí 1: 165 mm; Délka potrubí 3: 165 mm; Objem: 0.0123629 m3; Poloměr potrubí 1: 90 mm; Poloměr potrubí 3: 80 mm; Poloměr potrubí 4: 90 mm; Průměr potrubí 1: 180 mm; Průměr potrubí 3: 160 mm; Průměr potrubí 4: 180 mm; Rameno: 75 mm; Velikost: 180-180-180-160
Identifikační data - Kód prvku: TA.15.0689; Označení: 0689
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1451166; Rodina: M_Kulaté křížení; Rodina a typ: M_Kulaté křížení: Standardní

# IfcDuctFitting: M_Kulaté odbočení:Standardní, M_Kulaté odbočení:Standardní:14033536
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 08; Popis: Spojení; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté odbočení
Classification: TA04 Uniformat (Uniformat); Group: SUP 20
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 2942.5 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka odbočení: 101.6; Objem: 0.0197159 m3; Pevná délka odbočení: 101.6; Poloměr potrubí: 157.5 mm; Projekce délky odbočení: 151.404; Průměr vedení: 315 mm; Velikost: 315-315
Identifikační data - Kód prvku: TA04.08.0612; Označení: 0612
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1449384; Rodina: M_Kulaté odbočení; Rodina a typ: M_Kulaté odbočení: Standardní

# IfcDuctFitting: M_Kulaté odbočení:Standardní (3)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 08; Popis: Spojení; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Pevná délka odbočení: 101.6
Jiné - Typ: Standardní; Id typu: 1449384; Rodina: M_Kulaté odbočení; Rodina a typ: M_Kulaté odbočení: Standardní
Name (M_Kulaté odbočení:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka odbočení | Objem (m3) | Poloměr potrubí (mm) | Projekce délky odbočení | Průměr vedení (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13538087 | 1.NP_SO-101 | 125 mm-125 mm | 1.NP_SO-101 | 3300 | ETA 30 | 115.895 | 0.00149697 | 62.5 | 6.096 | 125 | 125-125 | TA04.08.0115 | 0115 | no
13999403 | 2.NP_SO-101 | 160 mm-160 mm | 2.NP_SO-101 | 3225 | ETA 28 | 101.6 | 0.00274736 | 80 | 35.0491 | 160 | 160-160 | TA04.08.0515 | 0515 | no
14073366 | -1.PP_SO-101 | 250 mm-250 mm | -1.PP_SO-101 | 2400 | ETA 30 | 101.6 | 0.00528625 | 125 | 6.096 | 250 | 250-250 | TA04.08.0785 | 0785

# IfcDuctFitting: M_Kulaté spojení:Standardní, M_Kulaté spojení:Standardní:13931936
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 10; Popis: Spojení; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté spojení
Classification: TA06 Uniformat (Uniformat); Group: SUP 20
Qto_DuctFittingBaseQuantities - Length: 6 mm; GrossCrossSectionArea: 0.0779207 m2; NetCrossSectionArea: 0.0779207 m2; OuterSurfaceArea: 0.00593761 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 3400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm; Objem: 0.000467565 m3; Poloměr potrubí: 157.5 mm; Velikost: 315-315
Identifikační data - Kód prvku: TA06.10.0415; Označení: 0415
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1448456; Rodina: M_Kulaté spojení; Rodina a typ: M_Kulaté spojení: Standardní

# IfcDuctFitting: M_Kulaté spojení:Standardní (5)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 10; Popis: Spojení; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté spojení
Classification: TA06 Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 6 mm; GrossCrossSectionArea: 0.0201035 m2; NetCrossSectionArea: 0.0201035 m2; OuterSurfaceArea: 0.00301593 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Celková velikost: 190 mm-190 mm; Tloušťka izolace: 15 mm; Typ izolace: Protipožární
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm; Objem: 0.000120631 m3; Poloměr potrubí: 80 mm; Velikost: 160-160
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1448456; Rodina: M_Kulaté spojení; Rodina a typ: M_Kulaté spojení: Standardní
Name (M_Kulaté spojení:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Tlaková ztráta (Pa)
13845172 | 3.NP_SO-101 | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | TA06.10.0317 | 0317
13845214 | 3.NP_SO-101 | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | TA06.10.0318 | 0318
13849735 | 3.NP_SO-101 | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TA06.10.0321 | 0321 | 0
13849872 | 3.NP_SO-101 | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TA06.10.0322 | 0322 | 0
13958450 | -1.PP_SO-101 | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | TA06.10.0453 | 0453 | 0

# IfcDuctFitting: M_Kulaté zakončení:Standardní (2)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka potrubí: 25 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 14; Popis: Zakončení; Popis sestavy: Tvarovka potrubí (VZT)
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté zakončení
Classification: TA Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 25 mm; GrossCrossSectionArea: 0.0397548 m2; NetCrossSectionArea: 0.0397548 m2; OuterSurfaceArea: 0.0176715 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.00099397 m3; Poloměr potrubí: 112.5 mm; Velikost: 225
Jiné - Typ: Standardní; Páteřní trasa: no; Id typu: 1447762; Rodina: M_Kulaté zakončení; Rodina a typ: M_Kulaté zakončení: Standardní
Name (M_Kulaté zakončení:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
14000761 | 1.NP_SO-101 | 1.NP_SO-101 | 3000 | Přívodní | Přívod vzduchu | SUP 27 | SUP | TA.14.0534 | 0534
14000839 | 2.NP_SO-101 | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | TA.14.0545 | 0545

# IfcDuctFitting: M_Kulaté zakončení:Standardní (38)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka potrubí: 25 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 14; Popis: Zakončení; Popis sestavy: Tvarovka potrubí (VZT)
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté zakončení
Classification: TA Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 25 mm
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: Standardní; Id typu: 1447762; Rodina: M_Kulaté zakončení; Rodina a typ: M_Kulaté zakončení: Standardní
Name (M_Kulaté zakončení:Standardní:...) | In | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Objem (m3) | Poloměr potrubí (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13999563 | 4.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.00050263 | 80 | 160 | TA.14.0518 | 0518 | no
13999580 | 4.NP_SO-101 | 0.01227 | 0.00981748 | 125 mm | 0 | 125 mm | 4.NP_SO-101 | 3900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.000306781 | 62.5 | 125 | TA.14.0519 | 0519 | yes
13999583 | 4.NP_SO-101 | 0.01227 | 0.00981748 | 125 mm | 0 | 125 mm | 4.NP_SO-101 | 3900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.000306781 | 62.5 | 125 | TA.14.0520 | 0520 | yes
13999585 | 4.NP_SO-101 | 0.01227 | 0.00981748 | 125 mm | 0 | 125 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.000306781 | 62.5 | 125 | TA.14.0521 | 0521 | yes
13999627 | 4.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 4.NP_SO-101 | 3730 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0522 | 0522 | yes
14000749 | 1.NP_SO-101 | 0.0254431 | 0.0141372 | 180 mm | 0 | 180 mm | 1.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.000636141 | 90 | 180 | TA.14.0529 | 0529 | no
14000752 | 1.NP_SO-101 | 0.01227 | 0.00981748 | 125 mm | 0 | 125 mm | 1.NP_SO-101 | 3450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0.000306781 | 62.5 | 125 | TA.14.0530 | 0530 | no
14000754 | 1.NP_SO-101 | 0.0254431 | 0.0141372 | 180 mm | 0 | 180 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0.000636141 | 90 | 180 | TA.14.0531 | 0531 | no
14000756 | 1.NP_SO-101 | 0.04908 | 0.019635 | 250 mm | 0 | 250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00122712 | 125 | 250 | TA.14.0532 | 0532 | no
14000759 | 1.NP_SO-101 | 0.04908 | 0.019635 | 250 mm | 0 | 250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0.00122712 | 125 | 250 | TA.14.0533 | 0533 | no
14000764 | 1.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0535 | 0535 | no
14000821 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 2640.02 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0.00050263 | 80 | 160 | TA.14.0536 | 0536 | yes
14000823 | 2.NP_SO-101 | 0.04908 | 0.019635 | 250 mm | 0 | 250 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.00122712 | 125 | 250 | TA.14.0537 | 0537 | no
14000825 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3270 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.00050263 | 80 | 160 | TA.14.0538 | 0538 | no
14000827 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0539 | 0539 | yes
14000829 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0540 | 0540 | no
14000831 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3400 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.00050263 | 80 | 160 | TA.14.0541 | 0541 | no
14000833 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.00050263 | 80 | 160 | TA.14.0542 | 0542 | no
14000835 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0.00050263 | 80 | 160 | TA.14.0543 | 0543 | no
14000837 | 2.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0.00050263 | 80 | 160 | TA.14.0544 | 0544 | yes
14000841 | 2.NP_SO-101 | 0.04908 | 0.019635 | 250 mm | 15 | 280 mm | 2.NP_SO-101 | 3100 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.00122712 | 125 | 250 | TA.14.0546 | 0546 | yes | Izolace - Typ izolace: Protipožární
14000873 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.00050263 | 80 | 160 | TA.14.0547 | 0547 | yes
14000875 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0.00050263 | 80 | 160 | TA.14.0548 | 0548 | no
14000877 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0549 | 0549 | no
14000879 | 3.NP_SO-101 | 0.0254431 | 0.0141372 | 180 mm | 0 | 180 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.000636141 | 90 | 180 | TA.14.0550 | 0550 | no
14000881 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0551 | 0551 | yes
14000883 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.00050263 | 80 | 160 | TA.14.0552 | 0552 | no
14000885 | 3.NP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00050263 | 80 | 160 | TA.14.0553 | 0553 | no
14000904 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2500 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0.00050263 | 80 | 160 | TA.14.0554 | 0554 | no
14000906 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 1700 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0555 | 0555 | no
14000908 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0.00050263 | 80 | 160 | TA.14.0556 | 0556 | no
14000910 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2550 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0557 | 0557 | no
14000912 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0558 | 0558 | no
14000914 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0559 | 0559 | no
14000916 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 35 | ETA | 0.00050263 | 80 | 160 | TA.14.0560 | 0560 | no
14000918 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 35 | ETA | 0.00050263 | 80 | 160 | TA.14.0561 | 0561 | no
14000920 | -1.PP_SO-101 | 0.0201032 | 0.0125664 | 160 mm | 0 | 160 mm | -1.PP_SO-101 | 2640 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0.00050263 | 80 | 160 | TA.14.0562 | 0562 | no
14000922 | -1.PP_SO-101 | 0.0254431 | 0.0141372 | 180 mm | 0 | 180 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 0.000636141 | 90 | 180 | TA.14.0563 | 0563 | no

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (92)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 04; Popis: Redukce; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Odsazení šířky od základny: 3048 mm; Odsazení výšky od základny: 3048 mm
Jiné - Číslo 4: 1; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Rozdíl odsazení (mm) = Délka 3 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška = Poloměr potrubí 1 (mm) | Plocha (m2) | Poloměr potrubí 2 (mm) | Rozdíl poloměrů (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Číslo 1 | Číslo 2 | Číslo 3 | Číslo 5 | Délka 1 (mm) | Délka 2 (mm) | Tlaková ztráta (Pa)
13415122 | 4.NP_SO-101 | 180 mm-160 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0015 | 0015 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13442117 | 4.NP_SO-101 | 180 mm-160 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0020 | 0020 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13443030 | 3.NP_SO-101 | 250 mm-200 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0033 | 0033 | no | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13443459 | 4.NP_SO-101 | 225 mm-180 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.00175647 | 90 | 90 | 0.0436621 | 112.5 | 22.5 | 225-180 | 54.3198 | TA03.04.0034 | 0034 | no | 0.9 | 0.9 | 1.8 | 2.17279 | 22.5 | 22.5
13503737 | 1.NP_SO-101 | 250 mm-125 mm | 1.NP_SO-101 | 3450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00431999 | 125 | 125 | 0.0784454 | 62.5 | 62.5 | 250-125 | 150.888 | TA03.04.0060 | 0060 | no | 2.5 | 2.5 | 5 | 6.03553 | 62.5 | 62.5 | 0
13505277 | 2.NP_SO-101 | 315 mm-250 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.04375 | 0.04375 | 0.00493938 | 157.5 | 157.5 | 0.0865885 | 125 | 32.5 | 315-250 | 78.4619 | TA03.04.0064 | 0064 | yes | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
13509157 | 2.NP_SO-101 | 315 mm-225 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.04375 | 0.04375 | 0.00627741 | 157.5 | 157.5 | 0.0985447 | 112.5 | 45 | 315-225 | 108.64 | TA03.04.0079 | 0079 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13509276 | 2.NP_SO-101 | 225 mm-160 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.03125 | 0.03125 | 0.002305 | 112.5 | 112.5 | 0.0505085 | 80 | 32.5 | 225-160 | 78.4619 | TA03.04.0080 | 0080 | no | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
13528872 | 4.NP_SO-101 | 400 mm-160 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0222222 | 0.0222222 | 0.0189296 | 80 | 80 | 0.215319 | 200 | 120 | 400-160 | 289.706 | TA03.04.0103 | 0103 | yes | 4.8 | 4.8 | 9.6 | 11.5882 | 120 | 120 | 0
13529268 | 4.NP_SO-101 | 225 mm-180 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.00175647 | 90 | 90 | 0.0436621 | 112.5 | 22.5 | 225-180 | 54.3198 | TA03.04.0105 | 0105 | no | 0.9 | 0.9 | 1.8 | 2.17279 | 22.5 | 22.5
13625468 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.00338228 | 0.0250009 | 0.025 | 0.000548535 | 90.0034 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0155 | 0155 | no | 0.400135 | 0.399865 | 0.8 | 0.965685 | 10.0034 | 9.99662 | 0
13704522 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0176 | 0176 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13704524 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0177 | 0177 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13704632 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0178 | 0178 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13704634 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0179 | 0179 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13704690 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0180 | 0180 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13704692 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0181 | 0181 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13704801 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0182 | 0182 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13704803 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0183 | 0183 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13704821 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0184 | 0184 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13704823 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0185 | 0185 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13704889 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0186 | 0186 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13704891 | 3.NP_SO-101 | 200 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0187 | 0187 | no | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13705174 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0188 | 0188 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13705176 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0189 | 0189 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13705276 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0190 | 0190 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13705278 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0191 | 0191 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13829774 | -1.PP_SO-101 | 225 mm-200 mm | -1.PP_SO-101 | 4023.37 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00107139 | 100 | 100 | 0.0360101 | 112.5 | 12.5 | 225-200 | 30.1777 | TA03.04.0264 | 0264 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13829776 | -1.PP_SO-101 | 225 mm-200 mm | -1.PP_SO-101 | 4523.37 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00107139 | 100 | 100 | 0.0360101 | 112.5 | 12.5 | 225-200 | 30.1777 | TA03.04.0265 | 0265 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13829788 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0266 | 0266 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13829792 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0267 | 0267 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13829860 | 2.NP_SO-101 | 250 mm-200 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0268 | 0268 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13829862 | 2.NP_SO-101 | 250 mm-200 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0269 | 0269 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13829900 | 2.NP_SO-101 | 250 mm-200 mm | 2.NP_SO-101 | 3225 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0270 | 0270 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13829902 | 2.NP_SO-101 | 250 mm-200 mm | 2.NP_SO-101 | 3275 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0271 | 0271 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25
13830017 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0272 | 0272 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830019 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0273 | 0273 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830021 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0274 | 0274 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830023 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0275 | 0275 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830027 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0276 | 0276 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830049 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0277 | 0277 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830051 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0278 | 0278 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830053 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0279 | 0279 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830055 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0280 | 0280 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830057 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0281 | 0281 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830063 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 8 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0282 | 0282 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13830067 | 4.NP_SO-101 | 250 mm-160 mm | 4.NP_SO-101 | 1213.87 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0283 | 0283 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830069 | 4.NP_SO-101 | 250 mm-160 mm | 4.NP_SO-101 | 1293.79 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0284 | 0284 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13830347 | 2.NP_SO-101 | 225 mm-160 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.03125 | 0.03125 | 0.002305 | 112.5 | 112.5 | 0.0505085 | 80 | 32.5 | 225-160 | 78.4619 | TA03.04.0285 | 0285 | no | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
13830584 | 2.NP_SO-101 | 250 mm-225 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0290 | 0290 | no | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13830586 | 2.NP_SO-101 | 250 mm-225 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0291 | 0291 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13830662 | 2.NP_SO-101 | 250 mm-225 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0292 | 0292 | no | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13830664 | 2.NP_SO-101 | 250 mm-225 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0293 | 0293 | no | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13834341 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0302 | 0302 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13842801 | 1.NP_SO-101 | 225 mm-180 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.03125 | 0.03125 | 0.00175646 | 112.5 | 112.5 | 0.0436621 | 90 | 22.5 | 225-180 | 54.3198 | TA03.04.0308 | 0308 | no | 0.9 | 0.9 | 1.8 | 2.17279 | 22.5 | 22.5 | 0
13842813 | 1.NP_SO-101 | 250 mm-225 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00133803 | 125 | 125 | 0.0432062 | 112.5 | 12.5 | 250-225 | 30.1777 | TA03.04.0309 | 0309 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13843136 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0310 | 0310 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13904596 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0334 | 0334 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13905373 | 1.NP_SO-101 | 250 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0340 | 0340 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13907185 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0347 | 0347 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13908654 | 3.NP_SO-101 | 315 mm-250 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.04375 | 0.04375 | 0.00493938 | 157.5 | 157.5 | 0.0865885 | 125 | 32.5 | 315-250 | 78.4619 | TA03.04.0351 | 0351 | no | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
13919618 | 1.NP_SO-101 | 200 mm-160 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00123356 | 100 | 100 | 0.0344984 | 80 | 20 | 200-160 | 48.2843 | TA03.04.0364 | 0364 | yes | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20
13920851 | -1.PP_SO-101 | 180 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 80 | 10 | 180-160 | 24.1421 | TA03.04.0370 | 0370 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13925608 | 2.NP_SO-101 | 315 mm-225 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 0 | 0.04375 | 0.04375 | 0.00627741 | 157.5 | 157.5 | 0.0985447 | 112.5 | 45 | 315-225 | 108.64 | TA03.04.0383 | 0383 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13926856 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0385 | 0385 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13926918 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 125 | 12.5 | 250-225 | 30.1777 | TA03.04.0386 | 0386 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13927011 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00133803 | 125 | 125 | 0.0432062 | 112.5 | 12.5 | 250-225 | 30.1777 | TA03.04.0388 | 0388 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13928410 | -1.PP_SO-101 | 250 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0398 | 0398 | no | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13930692 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 8 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0412 | 0412 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13935144 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0423 | 0423 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13937514 | 4.NP_SO-101 | 315 mm-280 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0388889 | 0.0388889 | 0.00294016 | 140 | 140 | 0.0705798 | 157.5 | 17.5 | 315-280 | 42.2487 | TA03.04.0437 | 0437 | yes | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0
13937701 | 4.NP_SO-101 | 315 mm-280 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0388889 | 0.0388889 | 0.00294016 | 140 | 140 | 0.0705798 | 157.5 | 17.5 | 315-280 | 42.2487 | TA03.04.0441 | 0441 | yes | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0
13959472 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0455 | 0455 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13961128 | 3.NP_SO-101 | 400 mm-250 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0555556 | 0.0555556 | 0.0152867 | 200 | 200 | 0.178166 | 125 | 75 | 400-250 | 181.066 | TA03.04.0461 | 0461 | yes | 3 | 3 | 6 | 7.24264 | 75 | 75 | 0
13970265 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0488 | 0488 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13970286 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0277778 | 0.0277778 | 0.00240942 | 100 | 100 | 0.0539038 | 125 | 25 | 250-200 | 60.3553 | TA03.04.0489 | 0489 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13970510 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0493 | 0493 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13970512 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0494 | 0494 | yes | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
13971213 | 1.NP_SO-101 | 225 mm-160 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.03125 | 0.03125 | 0.002305 | 112.5 | 112.5 | 0.0505085 | 80 | 32.5 | 225-160 | 78.4619 | TA03.04.0497 | 0497 | yes | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5
14001218 | 4.NP_SO-101 | 280 mm-225 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.0388889 | 0.0388889 | 0.00333753 | 140 | 140 | 0.0671648 | 112.5 | 27.5 | 280-225 | 66.3909 | TA03.04.0564 | 0564 | yes | 1.1 | 1.1 | 2.2 | 2.65563 | 27.5 | 27.5
14001937 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00133803 | 125 | 125 | 0.0432062 | 112.5 | 12.5 | 250-225 | 30.1777 | TA03.04.0565 | 0565 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
14002091 | -1.PP_SO-101 | 250 mm-225 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00133803 | 125 | 125 | 0.0432062 | 112.5 | 12.5 | 250-225 | 30.1777 | TA03.04.0566 | 0566 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
14003421 | 2.NP_SO-101 | 250 mm-160 mm | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0577 | 0577 | yes | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
14030156 | 4.NP_SO-101 | 225 mm-160 mm | 4.NP_SO-101 | 4100 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0 | 0.03125 | 0.03125 | 0.002305 | 112.5 | 112.5 | 0.0505085 | 80 | 32.5 | 225-160 | 78.4619 | TA03.04.0592 | 0592 | yes | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
14033196 | -1.PP_SO-101 | 225 mm-200 mm | -1.PP_SO-101 | 4023.37 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00107139 | 100 | 100 | 0.0360101 | 112.5 | 12.5 | 225-200 | 30.1777 | TA03.04.0607 | 0607 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
14033206 | -1.PP_SO-101 | 225 mm-200 mm | -1.PP_SO-101 | 4523.37 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0277778 | 0.0277778 | 0.00107139 | 100 | 100 | 0.0360101 | 112.5 | 12.5 | 225-200 | 30.1777 | TA03.04.0609 | 0609 | yes | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
14033273 | 2.NP_SO-101 | 315 mm-250 mm | 2.NP_SO-101 | 3100 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0 | 0.0347222 | 0.0347222 | 0.00493936 | 125 | 125 | 0.0865885 | 157.5 | 32.5 | 315-250 | 78.4619 | TA03.04.0611 | 0611 | yes | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
14062497 | 4.NP_SO-101 | 225 mm-180 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0 | 0.025 | 0.025 | 0.00175647 | 90 | 90 | 0.0436621 | 112.5 | 22.5 | 225-180 | 54.3198 | TA03.04.0720 | 0720 |  | 0.9 | 0.9 | 1.8 | 2.17279 | 22.5 | 22.5 | 0
14075349 | 1.NP_SO-101 | 450 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 0 | 0.0625 | 0.0625 | 0.0238587 | 225 | 225 | 0.242207 | 125 | 100 | 450-250 | 241.421 | TA03.04.0793 | 0793 |  | 4 | 4 | 8 | 9.65685 | 100 | 100
14075752 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0800 | 0800 |  | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
14075754 | 1.NP_SO-101 | 250 mm-200 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00240941 | 125 | 125 | 0.0539038 | 100 | 25 | 250-200 | 60.3553 | TA03.04.0801 | 0801 |  | 1 | 1 | 2 | 2.41421 | 25 | 25 | 0
14081884 | 3.NP_SO-101 | 250 mm-160 mm | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 80 | 45 | 250-160 | 108.64 | TA03.04.0833 | 0833 |  | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů, M_Kulatý přechod, úhel:45 stupňů:13928233
In: -1.PP_SO-101
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 04; Popis: Redukce; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat); Group: ODA 18
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 355 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 355 mm-315 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: -500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 18; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Kóty - Odsazení šířky od základny: 3048 mm; Odsazení výšky od základny: 3048 mm; Rozdíl odsazení: 0 mm; Dočas. šířka odsazení: 0.0493056; Dočas. výška odsazení: 0.0493056; Objem: 0.00426067 m3; Odskok – šířka: 177.5; Odskok – výška: 177.5; Plocha: 0.0899957 m2; Poloměr potrubí 1: 177.5 mm; Poloměr potrubí 2: 157.5 mm; Rozdíl poloměrů: 20 mm; Velikost: 355-315; Vypočítaná délka: 48.2843 mm
Identifikační data - Kód prvku: TA03.04.0395; Označení: 0395
Jiné - Páteřní trasa: no; Číslo 4: 1; Délka 3: 0 mm; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů; Číslo 1: 0.8; Číslo 2: 0.8; Číslo 3: 1.6; Číslo 5: 1.93137; Délka 1: 20 mm; Délka 2: 20 mm

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů, M_Kulatý přechod, úhel:45 stupňů:13899255
In: 2.NP_SO-101
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 04; Popis: Redukce; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat); Group: EHA 10
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-160 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 3955.2 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 10; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes
Kóty - Odsazení šířky od základny: 3048 mm; Odsazení výšky od základny: 3048 mm; Rozdíl odsazení: 0 mm; Dočas. šířka odsazení: 0.04375; Dočas. výška odsazení: 0.04375; Objem: 0.00858237 m3; Odskok – šířka: 157.5; Odskok – výška: 157.5; Plocha: 0.123741 m2; Poloměr potrubí 1: 157.5 mm; Poloměr potrubí 2: 80 mm; Rozdíl poloměrů: 77.5 mm; Velikost: 315-160; Vypočítaná délka: 187.102 mm
Identifikační data - Kód prvku: TA03.04.0324; Označení: 0324
Jiné - Páteřní trasa: yes; Číslo 4: 1; Délka 3: 0 mm; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů; Číslo 1: 3.1; Číslo 2: 3.1; Číslo 3: 6.2; Číslo 5: 7.48406; Délka 1: 77.5 mm; Délka 2: 77.5 mm

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (96)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 04; Popis: Redukce; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Číslo 4: 1; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odsazení šířky od základny (mm) | Odsazení výšky od základny (mm) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí 1 (mm) | Poloměr potrubí 2 (mm) | Rozdíl odsazení (mm) | Rozdíl poloměrů (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Číslo 1 | Číslo 2 | Číslo 3 | Číslo 5 | Délka 1 (mm) | Délka 2 (mm) | Délka 3 (mm) | Tlaková ztráta (Pa)
12987640 | 4.NP_SO-101 | 160 mm-125 mm | 4.NP_SO-101 | 2580.13 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 3048 | 80 | 80 | 0.0228432 | 80 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.04.0011 | 0011 | no | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5 | 0
13442274 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0026 | 0026 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13442569 | 3.NP_SO-101 | 200 mm-180 mm | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 0.025 | 0.025 | 0.000685056 | 3048 | 3048 | 90 | 90 | 0.0276519 | 90 | 100 | 0 | 10 | 200-180 | 24.1421 | TA03.04.0027 | 0027 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13443027 | 3.NP_SO-101 | 200 mm-180 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 0.025 | 0.025 | 0.000685056 | 3048 | 3048 | 90 | 90 | 0.0276519 | 90 | 100 | 0 | 10 | 200-180 | 24.1421 | TA03.04.0032 | 0032 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13443579 | 4.NP_SO-101 | 180 mm-160 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0035 | 0035 | no | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0 | 0
13509594 | 3.NP_SO-101 | 180 mm-160 mm | 3.NP_SO-101 | 2845.86 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 3048 | 80 | 80 | 0.0230465 | 80 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.04.0086 | 0086 | yes | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13528790 | 4.NP_SO-101 | 180 mm-125 mm | 4.NP_SO-101 | 3900.03 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 0.025 | 0.025 | 0.0012256 | 3048 | 3048 | 90 | 90 | 0.0330897 | 90 | 62.5 | 0 | 27.5 | 180-125 | 66.3909 | TA03.04.0102 | 0102 | yes | 1.1 | 1.1 | 2.2 | 2.65563 | 27.5 | 27.5 | 0 | 0
