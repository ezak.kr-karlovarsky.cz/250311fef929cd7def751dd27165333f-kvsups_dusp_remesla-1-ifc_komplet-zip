Properties of the parts of a building model (IFC4), part 9 of 21

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x300x1000, Tlumič hluku hranatý kulisový.LH:600x300x1000:13827054
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.09 m2; NetVolume: 0.182275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 300 mm-600 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 300 mm-600 mm × 300 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 2750 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 8; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.182275 m3; Plocha: 1.545 m2; Velikost: 600 × 300-600 × 300
Identifikační data - Kód prvku: TC03.15.0073; Označení: 0073
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13826915; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x300x1000; Typ: 600x300x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x300x500, Tlumič hluku hranatý kulisový.LH:600x300x500:13825869
In: 2.NP_SO-101
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 300 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 300 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 300 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x300x500; Označení typu: 13; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 11
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.19 m2; NetVolume: 0.092275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 300 mm-600 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 300 mm-600 mm × 300 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 3100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 11; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.092275 m3; Plocha: 1.095 m2; Velikost: 600 × 300-600 × 300
Identifikační data - Kód prvku: TC03.13.0071; Označení: 0071
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13826049; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x300x500; Typ: 600x300x500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x355x1250, Tlumič hluku hranatý kulisový.LH:600x355x1250:13739198
In: -1.PP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1250 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 355 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 355 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 355 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x355x1250; Označení typu: 10; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: SUP 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.8876 m2; NetVolume: 0.268883 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 355 mm-600 mm × 355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 355 mm-600 mm × 355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 1900.01 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 1; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.268883 m3; Plocha: 1.9438 m2; Velikost: 600 × 355-600 × 355
Identifikační data - Kód prvku: TC03.10.0061; Označení: 0061
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13739836; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x355x1250; Typ: 600x355x1250

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x500x1000, Tlumič hluku hranatý kulisový.LH:600x500x1000:14063357
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 500 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x500x1000; Označení typu: 37; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.254 m2; NetVolume: 0.303575 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 500 mm-600 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 500 mm-600 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 3256.24 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.303575 m3; Plocha: 2.127 m2; Velikost: 600 × 500-600 × 500
Identifikační data - Kód prvku: TC03.37.0158; Označení: 0158
Jiné - Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13917387; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x500x1000; Typ: 600x500x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x600x1250, Tlumič hluku hranatý kulisový.LH:600x600x1250:13760526
In: -1.PP_SO-101
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1250 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x600x1250; Označení typu: 12; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.436 m2; NetVolume: 0.454225 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 600 mm-600 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 600 mm-600 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 3; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.454225 m3; Plocha: 2.718 m2; Velikost: 600 × 600-600 × 600
Identifikační data - Kód prvku: TC03.12.0063; Označení: 0063
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13617289; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x600x1250; Typ: 600x600x1250

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:630x355x1000, Tlumič hluku hranatý kulisový.LH:630x355x1000:13737796
In: -1.PP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 355 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 355 mm; Průtočná mezera: 100 mm; Šířka: 630 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 355 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 630x355x1000; Označení typu: 08; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 30
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.5406 m2; NetVolume: 0.226404 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 355 mm-630 mm × 355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 355 mm-630 mm × 355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 30; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.226404 m3; Plocha: 1.7703 m2; Velikost: 630 × 355-630 × 355
Identifikační data - Kód prvku: TC03.08.0058; Označení: 0058
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13737759; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 630x355x1000; Typ: 630x355x1000

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:125x600 (25)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 600 mm; Hrubá délka: 700 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 125x600; Označení typu: 06; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.12699 m2; NetVolume: 0.0626325 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0626325 m3; Velikost: 250-250
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13622816; Rodina a typ: Tlumič hluku kruhový.LH: 125x600; Typ: 125x600
Name (Tlumič hluku kruhový.LH:125x600:...) | In | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13632098 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | TC02.06.0039 | 0039 | yes
13632101 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | TC02.06.0040 | 0040 | yes
13715973 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | TC02.06.0056 | 0056 | yes
13716849 | 3.NP_SO-101 | 0 | 0 | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | TC02.06.0057 | 0057 | yes
13763481 | -1.PP_SO-101 | 0.0388889 | -37740.2 | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | TC02.06.0065 | 0065 | yes
13763482 | -1.PP_SO-101 | 0.0388889 | -37740.2 | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | TC02.06.0066 | 0066 | yes
13763850 | 2.NP_SO-101 | 0 | 0 | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 1 | ETA | TC02.06.0067 | 0067 | yes
13763997 | 2.NP_SO-101 | 0 |  | 2.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 8 | ETA | TC02.06.0068 | 0068 | yes
13790054 | 4.NP_SO-101 | 0 | 0 | 4.NP_SO-101 | 1563.87 | Odváděný | Odváděný vzduch | ETA 29 | ETA | TC02.06.0069 | 0069 | yes
13790347 | 4.NP_SO-101 | 0 | 0 | 4.NP_SO-101 | 943.794 | Odváděný | Odváděný vzduch | ETA 29 | ETA | TC02.06.0070 | 0070 | yes
13830105 | 2.NP_SO-101 | 0 | 0 | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | TC02.06.0081 | 0081 | yes
13830141 | 2.NP_SO-101 | 0.0416667 | -43324.3 | 2.NP_SO-101 | 3225 | Odváděný | Zpětný vzduch | ETA 28 | ETA | TC02.06.0082 | 0082 | yes
13830568 | 2.NP_SO-101 | 0 | 0 | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | TC02.06.0085 | 0085 | yes
13830642 | 2.NP_SO-101 | 0.05 | 0.118536 | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | TC02.06.0086 | 0086
13842508 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | TC02.06.0103 | 0103 | yes
13842530 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | TC02.06.0104 | 0104 | yes
13843170 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | TC02.06.0106 | 0106 | yes
13843838 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | TC02.06.0107 | 0107 | yes
13904585 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | TC02.06.0118 | 0118 | yes
13907423 | 1.NP_SO-101 | 0.0166667 | 0.0131707 | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | TC02.06.0119 | 0119 | yes
13911320 | 2.NP_SO-101 | 0 | 0 | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | TC02.06.0120 | 0120 | yes
13926838 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | TC02.06.0133 | 0133 | yes
13926878 | -1.PP_SO-101 | 0.05 | 0.118536 | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | TC02.06.0134 | 0134 | yes
13934703 | 3.NP_SO-101 | 0 | 0 | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | TC02.06.0136 | 0136 | yes
14075615 | 1.NP_SO-101 | 0.05 | 0.118536 | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | TC02.06.0160 | 0160

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:160x1000 (10)
In: 3.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 130 mm; Hrubý průměr: 260 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Poloměr: 80 mm; Průměr: 160 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 160x1000; Označení typu: 07; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.05367 m2; NetVolume: 0.0551009 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 3.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0551009 m3; Velikost: 160-160
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13704437; Rodina a typ: Tlumič hluku kruhový.LH: 160x1000; Typ: 160x1000
Name (Tlumič hluku kruhový.LH:160x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13704474 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0041 | 0041 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704502 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0042 | 0042 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704516 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0043 | 0043 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704626 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0044 | 0044 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704684 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0045 | 0045 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704986 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0051 | 0051 | Jiné - Páteřní trasa: yes
13705000 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0052 | 0052 | Jiné - Páteřní trasa: yes
13705096 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC02.07.0053 | 0053 | Jiné - Páteřní trasa: yes
13705154 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | TC02.07.0054 | 0054 | Jiné - Páteřní trasa: yes
13705256 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | TC02.07.0055 | 0055 | Jiné - Páteřní trasa: yes

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:160x1000 (5)
In: 3.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 130 mm; Hrubý průměr: 260 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Poloměr: 80 mm; Průměr: 160 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 160x1000; Označení typu: 07; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 29
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.05367 m2; NetVolume: 0.0551009 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 3.NP_SO-101; Výška od podlaží: 3300 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 29; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0551009 m3; Velikost: 160-160
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13704437; Rodina a typ: Tlumič hluku kruhový.LH: 160x1000; Typ: 160x1000
Name (Tlumič hluku kruhový.LH:160x1000:...) | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Kód prvku | Označení
13704736 | 0.00833333 | -10329.3 | TC02.07.0046 | 0046
13704783 | 0.0166667 | -41317.2 | TC02.07.0047 | 0047
13704797 | 0.025 | -92963.8 | TC02.07.0048 | 0048
13704817 | 0.0333333 | -165269 | TC02.07.0049 | 0049
13704885 | 0.0416667 | -258233 | TC02.07.0050 | 0050 | Jiné - Páteřní trasa: no

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:160x600, Tlumič hluku kruhový.LH:160x600:13841067
In: -1.PP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 600 mm; Hrubá délka: 700 mm; Hrubý poloměr: 130 mm; Hrubý průměr: 260 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Poloměr: 80 mm; Průměr: 160 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 160x600; Označení typu: 20; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: SUP 27
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.72694 m2; NetVolume: 0.0338648 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.0472222 m3/s; Tlaková ztráta: 0.630209 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 27; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0338648 m3; Velikost: 160-160
Identifikační data - Kód prvku: TC02.20.0101; Označení: 0101
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13934023; Rodina a typ: Tlumič hluku kruhový.LH: 160x600; Typ: 160x600

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:160x600 (2)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 600 mm; Hrubá délka: 700 mm; Hrubý poloměr: 130 mm; Hrubý průměr: 260 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Poloměr: 80 mm; Průměr: 160 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 160x600; Označení typu: 20; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.72694 m2; NetVolume: 0.0338648 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0338648 m3; Velikost: 160-160
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13934023; Rodina a typ: Tlumič hluku kruhový.LH: 160x600; Typ: 160x600
Name (Tlumič hluku kruhový.LH:160x600:...) | In | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13841121 | -1.PP_SO-101 | 0.116667 | -2024544 | -1.PP_SO-101 | 2450 | ETA 30 | TC02.20.0102 | 0102
13933797 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 3350 | ETA 4 | TC02.20.0135 | 0135

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:225x1000, Tlumič hluku kruhový.LH:225x1000:13925643
In: 2.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 162.5 mm; Hrubý průměr: 325 mm; Jmenovitá velikost vstupu: 225 mm; Jmenovitá velikost výstupu: 225 mm; Poloměr: 112.5 mm; Průměr: 225 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 225x1000; Označení typu: 31; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 28
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.41662 m2; NetVolume: 0.0869296 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm-225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.025 m3/s; Tlaková ztráta: 0.045167 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 2900 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 28; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0869296 m3; Velikost: 225-225
Identifikační data - Kód prvku: TC02.31.0130; Označení: 0130
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13868587; Rodina a typ: Tlumič hluku kruhový.LH: 225x1000; Typ: 225x1000

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:250x1000 (3)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 250x1000; Označení typu: 09; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56682 m2; NetVolume: 0.101115 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.101115 m3; Velikost: 250-250
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13738742; Rodina a typ: Tlumič hluku kruhový.LH: 250x1000; Typ: 250x1000
Name (Tlumič hluku kruhový.LH:250x1000:...) | In | Tloušťka izolace (mm) | Celková velikost | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení | Typ izolace
13738863 | -1.PP_SO-101 | 0 | 250 mm-250 mm | 0 | 0 | -1.PP_SO-101 | 2262.59 | SUP 27 | TC02.09.0059 | 0059
13925404 | 2.NP_SO-101 | 15 | 280 mm-280 mm | -0.0166667 | 0.0131707 | 2.NP_SO-101 | 3100 | SUP 20 | TC02.09.0128 | 0128 | Protipožární
14033378 | 2.NP_SO-101 | 15 | 280 mm-280 mm | -0.0166667 | 0.0131707 | 2.NP_SO-101 | 3100 | SUP 20 | TC02.09.0156 | 0156 | Protipožární

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:250x1000, Tlumič hluku kruhový.LH:250x1000:13738931
In: -1.PP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 250x1000; Označení typu: 09; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 30
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56682 m2; NetVolume: 0.101115 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.166667 m3/s; Tlaková ztráta: -693188 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 30; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.101115 m3; Velikost: 250-250
Identifikační data - Kód prvku: TC02.09.0060; Označení: 0060
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13738742; Rodina a typ: Tlumič hluku kruhový.LH: 250x1000; Typ: 250x1000

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:315x1000, Tlumič hluku kruhový.LH:315x1000:13937442
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 207.5 mm; Hrubý průměr: 415 mm; Jmenovitá velikost vstupu: 315 mm; Jmenovitá velikost výstupu: 315 mm; Poloměr: 157.5 mm; Průměr: 315 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 315x1000; Označení typu: 34; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: SUP 43
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.98492 m2; NetVolume: 0.143053 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 2790 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.143053 m3; Velikost: 315-315
Identifikační data - Kód prvku: TC02.34.0140; Označení: 0140
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13917062; Rodina a typ: Tlumič hluku kruhový.LH: 315x1000; Typ: 315x1000

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:315x900, Tlumič hluku kruhový.LH:315x900:13917144
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 900 mm; Hrubá délka: 1000 mm; Hrubý poloměr: 207.5 mm; Hrubý průměr: 415 mm; Jmenovitá velikost vstupu: 315 mm; Jmenovitá velikost výstupu: 315 mm; Poloměr: 157.5 mm; Průměr: 315 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 315x900; Označení typu: 26; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.85455 m2; NetVolume: 0.129527 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.0583333 m3/s; Tlaková ztráta: 0.0640122 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 3720 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.129527 m3; Velikost: 315-315
Identifikační data - Kód prvku: TC02.26.0122; Označení: 0122
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 14067479; Rodina a typ: Tlumič hluku kruhový.LH: 315x900; Typ: 315x900

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:Průměr × Délka (13)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: Průměr × Délka; Označení typu: 03; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56682 m2; NetVolume: 0.101115 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.101115 m3; Velikost: 250-250
Jiné - Páteřní trasa: yes; Typ: Průměr × Délka; Id typu: 13544592; Rodina: Tlumič hluku kruhový.LH; Rodina a typ: Tlumič hluku kruhový.LH: Průměr × Délka
Name (Tlumič hluku kruhový.LH:Průměr × Délka:...) | In | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13544720 | -1.PP_SO-101 | 0.05 | -62386.9 | -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | TC02.03.0027 | 0027
13544746 | -1.PP_SO-101 | 0.05 | 0.118536 | -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | TC02.03.0028 | 0028
13546868 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | TC02.03.0029 | 0029
13547037 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | TC02.03.0030 | 0030
13630218 | -1.PP_SO-101 | 0.05 | -62386.9 | -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | TC02.03.0035 | 0035
13630242 | -1.PP_SO-101 | 0.05 | 0.118536 | -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | TC02.03.0036 | 0036
13630320 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | TC02.03.0037 | 0037
13630346 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | TC02.03.0038 | 0038
13762373 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2520 | Zpětný vzduch | ETA 4 | TC02.03.0064 | 0064
13831353 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 2780 | Odváděný vzduch | ETA 2 | TC02.03.0087 | 0087
13831420 | 1.NP_SO-101 | 0 | 0 | 1.NP_SO-101 | 2780 | Odváděný vzduch | ETA 2 | TC02.03.0088 | 0088
13920046 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 2 | TC02.03.0125 | 0125
13920485 | -1.PP_SO-101 | 0 | 0 | -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 2 | TC02.03.0126 | 0126

# IfcBuildingElementProxy: Uzavírací klapka kruhová.LH:Průměr × Délka (3)
In: 2.NP_SO-101
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Průměr: 160 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: Průměr × Délka; Označení typu: 24; Popis: Uzavírací klapka kruhová; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; délka: 148.408 mm; Název rodiny: Uzavírací klapka kruhová.LH; úhel: 32.6192 deg
Classification: LV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.165871 m2; NetVolume: 0.00502631 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.00502631 m3; Plocha: 0.112135 m2; Velikost: 160-160
Jiné - Typ: Průměr × Délka; Id typu: 13813939; Rodina: Uzavírací klapka kruhová.LH; Rodina a typ: Uzavírací klapka kruhová.LH: Průměr × Délka
Name (Uzavírací klapka kruhová.LH:Průměr × Délka:...) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13904013 | -1390.08 | ETA 5 | LV02.24.0115 | 0115
13904137 | -1333.51 | ETA 5 | LV02.24.0116 | 0116
13904160 | -1319.37 | ETA 16 | LV02.24.0117 | 0117

# IfcCovering: Izolace potrubí:Protipožární (18)
PredefinedType: INSULATION; Classification: IZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: J; CCI Komponenta: FMH; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Tloušťka izolace: 15 mm
Jiné - Id typu: 8918325; Kategorie: Izolace potrubí; Rodina: Izolace potrubí; Rodina a typ: Izolace potrubí: Protipožární; Typ: Protipožární
Požární ochrana(Type) - Požární odolnost: A1
Identifikační data(Type) - ID kategorie: IZP; Kód sestavy: IZ03; Název typu: Protipožární; Označení typu: 01; Popis: POŽÁRNÍ IZOLACE; Popis sestavy: Protipožární
Jiné(Type) - Kategorie: Izolace potrubí; MJ: m2; Název rodiny: Izolace potrubí
Name (Izolace potrubí:Protipožární:...) | In | Material | GrossArea (m2) | Typ systému | Klasifikace systému | Název systému | Zkratka systému | Velikost potrubí | Kód prvku | Označení
13832182 | -1.PP_SO-101 | 255-0-0 | 0.0283486 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 160 | IZ03.01.0001 | 0001 | Mechanické - Objem: 0.0295467 m3; Plocha: 1.96978 m2; Kóty - Délka: 3300 mm
13845176 | 3.NP_SO-101 | 255-0-0 | 0.0283486 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160-160 | IZ03.01.0002 | 0002
13845213 | 3.NP_SO-101 | 255-0-0 | 0.0283486 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | IZ03.01.0003 | 0003 | Mechanické - Objem: 0.0182023 m3; Plocha: 1.21349 m2; Kóty - Délka: 2032.97 mm
13845217 | 3.NP_SO-101 | 255-0-0 | 0.0283486 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160-160 | IZ03.01.0004 | 0004
13849738 | 3.NP_SO-101 | 0-0-255 | 0.0283486 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160-160 | IZ03.01.0005 | 0005
13849871 | 3.NP_SO-101 | 0-0-255 | 0.0283486 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | IZ03.01.0006 | 0006 | Mechanické - Objem: 0.0181227 m3; Plocha: 1.20818 m2; Kóty - Délka: 2024.08 mm
13849875 | 3.NP_SO-101 | 0-0-255 | 0.0283486 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160-160 | IZ03.01.0007 | 0007
13922222 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0008 | 0008 | Mechanické - Objem: 0.0016799 m3; Plocha: 0.111993 m2; Kóty - Délka: 127.316 mm
13922223 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0009 | 0009 | Mechanické - Objem: 0.0023842 m3; Plocha: 0.158947 m2; Kóty - Délka: 180.694 mm
13922224 | 2.NP_SO-101 | 0-0-255 |  | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250-250 | IZ03.01.0010 | 0010
13922226 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0011 | 0011 | Mechanické - Objem: 0.106637 m3; Plocha: 7.1091 m2; Kóty - Délka: 8081.78 mm
13925205 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0012 | 0012 | Mechanické - Objem: 0.00184726 m3; Plocha: 0.12315 m2; Kóty - Délka: 140 mm
13925208 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250-250 | IZ03.01.0013 | 0013
13925425 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250-250 | IZ03.01.0014 | 0014
13958453 | -1.PP_SO-101 | 255-0-0 | 0.0283486 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 160-160 | IZ03.01.0015 | 0015
14000843 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0016 | 0016
14033436 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | IZ03.01.0017 | 0017 | Mechanické - Objem: 0.00175815 m3; Plocha: 0.11721 m2; Kóty - Délka: 133.247 mm
14033439 | 2.NP_SO-101 | 0-0-255 | 0.061566 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250-250 | IZ03.01.0018 | 0018

# IfcDistributionPort (3839)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_13898206_3 | SINK | DUCT | VENTILATION | ODA 1
OutPort_12979067_0 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_12979067_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068418_1 | SOURCE | DUCT | VENTILATION | ODA 1
Port_12980876_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519190_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12980876_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519202_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981055_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519190_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981055_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981197_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981196_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981197_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12981196_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13518843_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_12987202_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987259_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987202_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987273_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
InPort_12987202_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13912393_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_12987255_0 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987640_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987255_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_13912820_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987259_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_13912820_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987265_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987273_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987265_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987283_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987277_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987283_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987277_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
InPort_12987277_4 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13522385_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12987277_5 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13522462_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12987277_6 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13522486_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12987390_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13763089_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13522108_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_12987390_2 | SOURCE | DUCT | EXHAUST | ETA 29
Port_12987448_0 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987626_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987448_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987618_3 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987496_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987513_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987496_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987525_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
InPort_12987496_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13912727_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_12987509_0 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987626_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987509_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987513_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987519_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987525_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987519_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987539_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987529_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987539_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
Port_12987529_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 29
InPort_12987529_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13522730_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12987529_3 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13522766_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12987618_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13522108_1 | SOURCE | DUCT | EXHAUST | ETA 29
Port_12987618_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
Port_12987640_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 29
InPort_13322445_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12987657_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12987657_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13999580_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12987657_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13912172_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13322445_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12988176_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988176_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12988200_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988200_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12988186_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988186_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13999583_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988186_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13912057_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13932505_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12988259_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988259_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13999585_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12988259_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13513909_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_12990711_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_13764678_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_12990711_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047359_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
InPort_12995197_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12995168_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12995168_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14000873_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12995168_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13505055_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_12995168_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13505091_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13462179_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12995197_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_12995566_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529268_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995566_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529262_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995566_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442092_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995566_4 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13937292_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995967_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13415122_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995967_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529268_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995967_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13525869_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12995967_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13525893_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12996019_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13415122_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12996019_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13415163_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13704736_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_12996436_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12996436_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14000875_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12996436_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458261_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_12996920_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13528762_3 | SOURCE | DUCT | VENTILATION | ETA 19
