Properties of the parts of a building model (IFC4), part 12 of 21

# IfcDistributionPort (3839)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13835601_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13835601_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14063008_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13835695_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14069022_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_13835695_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
InPort_13840889_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13840855_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13841067_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13840889_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13840963_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13840979_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13965701_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13840963_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13840979_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13841121_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13841099_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13841067_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14031023_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13841099_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13841514_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13841099_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13841121_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13841135_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13841135_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14035287_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13841135_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965540_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13842127_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13842118_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13842518_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842508_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842532_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842530_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842813_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842532_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842605_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842676_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842676_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842813_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842801_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842730_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842875_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907468_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13907470_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13842875_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13843130_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843136_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13907185_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843130_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13843132_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907185_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13999491_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843132_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13843136_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843172_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13843172_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843170_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13843838_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13843866_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13844019_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14070028_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13844023_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13844019_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13844021_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13844023_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13844037_1 | SINK | DUCT | VENTILATION | ETA 10
OutPort_13844037_2 | SOURCE | DUCT | VENTILATION | ETA 10
Port_13844039_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13844041_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13844041_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
OutPort_13844043_2 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13844719_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844722_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844719_3 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844724_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844721_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844722_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13845169_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845214_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845169_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845172_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845211_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14031643_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845211_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845214_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13849403_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13909443_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849403_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031321_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849405_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13909443_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849405_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13999279_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13849435_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14047905_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14047786_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13849435_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13849437_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14054625_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14047905_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13849437_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13849509_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849551_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849509_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849553_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849553_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14028670_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13849732_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13849872_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13849735_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13849732_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13849872_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13849869_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14028864_0 | SINK | DUCT | VENTILATION | ODA 1
OutPort_13898206_1 | SOURCE | DUCT | VENTILATION | ODA 1
Port_13903274_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 6
Port_13903464_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 6
Port_13903274_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 6
InPort_13904013_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13903393_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13903393_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13955227_1 | SOURCE | DUCT | VENTILATION | ETA 5
Port_13903464_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 6
InPort_13955227_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13903489_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13903489_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13955255_2 | SOURCE | DUCT | VENTILATION | ETA 5
OutPort_13904013_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904137_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904129_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904129_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904135_1 | SOURCE | DUCT | VENTILATION | ETA 5
OutPort_13904131_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904131_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904138_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904135_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904133_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904133_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904351_3 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904138_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13904137_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13904160_2 | SINK | DUCT | VENTILATION | ETA 16
OutPort_13904152_0 | SOURCE | DUCT | VENTILATION | ETA 16
InPort_13904152_1 | SINK | DUCT | VENTILATION | ETA 16
OutPort_13904158_1 | SOURCE | DUCT | VENTILATION | ETA 16
OutPort_13904154_1 | SOURCE | DUCT | VENTILATION | ETA 16
InPort_13904154_2 | SINK | DUCT | VENTILATION | ETA 16
OutPort_13904161_0 | SOURCE | DUCT | VENTILATION | ETA 16
InPort_13904158_2 | SINK | DUCT | VENTILATION | ETA 16
InPort_13904161_1 | SINK | DUCT | VENTILATION | ETA 16
OutPort_13904160_1 | SOURCE | DUCT | VENTILATION | ETA 16
Port_13904227_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13955247_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904227_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904351_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904254_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904262_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904254_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13919618_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904262_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904351_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904352_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13904352_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
Port_13919618_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 5
InPort_13904583_0 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904596_2 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904588_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904583_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904596_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904585_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904585_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905373_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904586_0 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904588_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904592_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904586_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904590_0 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904592_2 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905276_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13904590_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13904786_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13904802_0 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13904832_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13904835_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13904848_1 | SINK | DUCT | EXHAUST | ETA 31
OutPort_13904850_0 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13905274_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905276_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905300_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13905302_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13905302_0 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13905300_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13905586_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905359_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905359_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905383_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905373_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905582_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905383_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905375_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905375_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905391_2 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905391_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905385_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905385_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905401_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905401_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905393_0 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905393_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905435_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905435_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905433_0 | SOURCE | DUCT | VENTILATION | ETA 7
InPort_13905433_1 | SINK | DUCT | VENTILATION | ETA 7
InPort_13905580_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905586_2 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905584_2 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905580_2 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13905582_1 | SINK | DUCT | EXHAUST | ETA 7
OutPort_13905584_1 | SOURCE | DUCT | EXHAUST | ETA 7
InPort_13933717_4 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13906663_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13933717_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13906780_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13933717_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13906951_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13907423_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907116_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13907116_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907470_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13907188_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13999491_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13999475_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907188_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13907425_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907423_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13970512_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13907425_0 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13907902_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930692_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13907902_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930740_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13908543_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13937879_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13908654_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908543_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13908814_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908775_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000841_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13910289_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13910289_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13925404_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13910289_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13910699_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13910289_3 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13910848_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13911153_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080167_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911195_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911153_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911364_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911193_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911193_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911195_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911289_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911360_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911320_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911364_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911362_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911320_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911360_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911362_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13916454_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14069022_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_13916454_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065628_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
InPort_13916764_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13916742_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13916742_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917228_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058303_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13916764_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13917144_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917231_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14067495_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917144_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13917228_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14067495_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13917231_0 | SINK | DUCT | VENTILATION | ETA 19
InPort_13917464_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917462_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13917464_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13937010_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14059104_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917985_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13918316_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13999348_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13918316_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13918431_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13918316_4 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13999403_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13918669_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13918679_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13918889_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13918669_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13918887_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13918889_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13999400_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13919130_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13921895_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13919659_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13919659_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071572_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13919906_0 | SINK | DUCT | EXHAUST | ETA 5
OutPort_14000453_2 | SOURCE | DUCT | EXHAUST | ETA 5
InPort_14000469_1 | SINK | DUCT | EXHAUST | ETA 5
OutPort_13919906_1 | SOURCE | DUCT | EXHAUST | ETA 5
InPort_13920046_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13928410_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920301_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920046_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920415_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920080_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920080_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920301_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920140_0 | SINK | DUCT | VENTILATION | ETA 2
OutPort_13920851_2 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13928412_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920140_1 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13920140_2 | SINK | DUCT | VENTILATION | ETA 2
OutPort_13920775_1 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13920242_0 | SINK | DUCT | VENTILATION | ETA 2
OutPort_14000922_1 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13920851_1 | SINK | DUCT | VENTILATION | ETA 2
OutPort_13920242_1 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13920242_2 | SINK | DUCT | VENTILATION | ETA 2
OutPort_13920737_1 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_13920363_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920415_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920413_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920363_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920507_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920409_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920409_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920413_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920485_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920507_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920505_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920485_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13928496_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920503_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13920503_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13920505_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13921888_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13921895_2 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13921892_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13921888_2 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13955248_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13921892_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13924585_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923160_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923160_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924556_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923557_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923565_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923981_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923557_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923557_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923717_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923973_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923981_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924010_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923973_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924581_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13923986_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923986_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924010_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924003_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924581_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966854_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924003_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924524_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924106_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924325_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924585_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924581_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924325_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924325_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14043019_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924479_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924524_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924546_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924479_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924544_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924546_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924556_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13924544_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13924794_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13924806_3 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13924815_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13924794_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13924806_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13924807_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13925193_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13925203_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13925422_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13925193_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13925203_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033378_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13925404_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13925422_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13925506_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13925667_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13925530_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13925506_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13925608_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13925530_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13925667_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13925643_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13926734_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926230_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926230_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927013_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926269_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926545_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926459_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926269_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926545_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926595_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926595_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926918_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926752_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926734_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926856_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926752_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926838_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926856_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14001937_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926838_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926918_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926878_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926878_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002091_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002091_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926914_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13926914_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002272_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13927011_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926968_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13926968_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13964887_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927001_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927011_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927013_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927001_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927092_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927078_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927078_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002162_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927097_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14031027_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002162_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927097_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14031027_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927108_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927108_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14031023_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927202_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13927210_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13927221_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13927202_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13927215_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13927221_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14035293_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13927215_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13927226_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14035293_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14035287_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13927226_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13927902_0 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13927823_1 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928145_2 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928248_0 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928236_0 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928244_2 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928258_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928236_1 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928248_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928258_2 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928486_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930336_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13938317_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13928486_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13930337_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13928496_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13929979_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13929969_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13929969_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13929996_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13929981_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13929989_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13929996_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13929981_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_13930130_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930163_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930130_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930146_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
InPort_13930164_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930138_2 | SOURCE | DUCT | EXHAUST | ETA 2
Port_13930140_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930146_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930140_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930442_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930155_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930163_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930155_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930406_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
InPort_13930163_2 | SINK | DUCT | VENTILATION | ETA 2
OutPort_13930164_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13930336_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930337_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13930346_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930348_1 | SOURCE | DUCT | EXHAUST | ETA 2
Port_13930398_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930406_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930398_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930434_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930442_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930434_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 2
Port_13930714_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930740_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930714_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
InPort_13930714_2 | SINK | DUCT | VENTILATION | ETA 8
OutPort_13931088_1 | SOURCE | DUCT | VENTILATION | ETA 8
Port_13930740_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930754_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930754_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
InPort_13930754_2 | SINK | DUCT | VENTILATION | ETA 8
OutPort_13931182_1 | SOURCE | DUCT | VENTILATION | ETA 8
InPort_13931934_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13931936_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13932655_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932663_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13932678_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932655_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13932663_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932664_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13932672_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932678_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13932949_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932672_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13932942_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932949_0 | SOURCE | DUCT | VENTILATION | SUP 43
OutPort_13933717_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13934247_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13933797_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13933797_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079474_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079669_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13933895_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13933895_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079671_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079059_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13934247_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080764_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13934703_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13934703_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13935144_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13935144_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13934721_0 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13934721_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13935146_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13935050_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13935178_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13935146_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13935050_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13935178_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13935053_0 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13935053_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081886_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13937693_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935328_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13935328_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935481_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13935330_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937514_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13935468_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935474_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13935482_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935468_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13935470_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13935471_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13935470_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13968215_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13935474_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935470_3 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13935471_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031544_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13935974_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13935973_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13935973_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13935975_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936991_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13935974_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13935975_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13939334_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936059_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936046_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936046_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064295_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936057_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936056_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936056_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936059_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936186_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064294_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14064295_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936186_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936214_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936265_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14064294_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936214_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936227_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936226_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936226_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14047940_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936229_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936227_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936267_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936229_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936265_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936267_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13936810_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936991_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13937010_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936810_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13937291_1 | SINK | DUCT | VENTILATION | SUP 43
Port_13937292_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13937514_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937442_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937442_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937701_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937506_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937700_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937701_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937506_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937700_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937598_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937598_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937692_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937692_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937624_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13937624_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13937693_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13937879_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13999280_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13938213_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13938247_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13938251_2 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13938213_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13938315_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13938317_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13939056_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939121_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13939056_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13939294_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939056_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13939064_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939065_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13939067_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939064_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13939123_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939067_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13939121_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13939123_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13939334_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13939323_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13939323_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13998998_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13939323_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13939390_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13955232_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13955247_3 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13955255_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13955232_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13955247_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13955248_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13958450_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13958447_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13960345_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13958858_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13959596_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959121_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13959121_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959600_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13959134_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959132_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13959132_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959596_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13959472_2 | SINK | DUCT | VENTILATION | SUP 27
InPort_13999475_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13959873_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13959873_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13959885_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13959885_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13960345_0 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13960308_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14055136_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13960308_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14056035_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_13960345_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13970607_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13960493_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13999475_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14074929_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13960493_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13960644_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13960610_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13960610_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075932_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13960645_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13960644_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075731_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13960645_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13961126_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13961128_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13961128_1 | SINK | DUCT | VENTILATION | SUP 43
InPort_13961186_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075547_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072181_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13961186_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072125_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13961317_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13961317_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072185_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13961469_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14049136_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071558_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_13961469_2 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_13964191_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13964159_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14033545_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13964191_1 | SOURCE | DUCT | VENTILATION | SUP 20
Port_13964597_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964613_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964597_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964640_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964606_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964608_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964606_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964613_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964619_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964636_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964619_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964640_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964630_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964632_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964630_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964636_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13964887_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13964905_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13964898_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13964900_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13964905_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13964898_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13965913_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965701_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13965903_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965913_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13965923_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965903_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13965917_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965923_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14055457_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965917_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13965927_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14055457_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14055447_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13965927_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966762_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13966939_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966846_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13966854_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966951_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13966846_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966939_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13966951_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13967105_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081960_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14000566_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13967105_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13967178_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14000329_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14000341_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13967178_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13967224_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_14000254_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_14000269_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13967224_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_14000254_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13967230_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13967283_0 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14000406_0 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14000422_1 | SINK | DUCT | EXHAUST | ETA 1
OutPort_13967283_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14000406_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13967293_2 | SOURCE | DUCT | VENTILATION | ETA 1
Port_13967695_1 | SOURCEANDSINK | DUCT
Port_13967695_2 | SOURCEANDSINK | DUCT
Port_13968053_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13968215_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13968629_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13968504_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13968655_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13968993_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13968993_1 | SINK | DUCT | VENTILATION | SUP 20
Port_13969263_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13969314_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13969263_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
InPort_13970295_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970301_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970301_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970300_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970300_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970306_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970306_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970338_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14055146_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970327_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970327_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14055136_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970328_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14055146_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970338_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970328_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970488_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13970512_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13970510_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13970488_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13970607_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13970508_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13970508_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13970510_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13971192_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13971213_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13971213_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14055242_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13971331_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971343_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13971510_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971331_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13971507_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971486_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13971486_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971510_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13971499_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971498_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13971498_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971507_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14033208_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13971499_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13972389_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972403_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972445_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972389_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972406_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972445_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972447_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972406_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972597_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972497_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972620_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13972703_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_13998852_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14030094_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13998852_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14030096_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13999279_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13999280_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14000329_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14000331_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14000453_1 | SINK | DUCT | EXHAUST | ETA 5
OutPort_14069676_0 | SOURCE | DUCT | EXHAUST | ETA 5
InPort_14000700_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790913_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14001944_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14001937_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002223_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14001944_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002210_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002227_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004441_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002210_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002221_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002223_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002227_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002221_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002276_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002259_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002259_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004350_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002272_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002270_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002270_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002276_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_14002589_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002593_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002590_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002593_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002590_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002598_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_14002715_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002739_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042792_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14002715_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002817_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002796_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14002796_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042584_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004616_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004122_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004122_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004620_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004196_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14033198_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004573_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004196_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004350_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004335_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004335_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004395_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004395_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004390_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004390_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004409_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004397_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004573_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004409_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14004397_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14004434_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004441_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004493_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004434_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004486_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004493_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004501_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004486_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004494_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004501_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14004620_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004494_1 | SOURCE | DUCT | VENTILATION | SUP 27
OutPort_14028261_1 | SOURCE | DUCT | VENTILATION
InPort_14028261_2 | SINK | DUCT | VENTILATION
InPort_14028261_3 | SINK | DUCT | VENTILATION | ETA 14
OutPort_14032738_0 | SOURCE | DUCT | VENTILATION | ETA 14
OutPort_14028261_4 | SOURCE | DUCT | EXHAUST
InPort_14032738_1 | SINK | DUCT | VENTILATION | ETA 14
OutPort_14028662_2 | SOURCE | DUCT | VENTILATION | ETA 14
InPort_14028816_0 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068416_2 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14068418_2 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14028816_1 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14068509_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14028864_1 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14029041_0 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068507_1 | SOURCE | DUCT | VENTILATION | ODA 1
OutPort_14029041_1 | SOURCE | DUCT | VENTILATION | ODA 1
Port_14029262_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14065040_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14029262_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14065041_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
InPort_14030164_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030174_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14030232_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030164_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14030179_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030232_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14030236_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030179_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_14030721_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14030721_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14055251_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14030843_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14055251_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14030843_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14055241_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_14031024_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14031023_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044624_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14031024_1 | SOURCE | DUCT | VENTILATION | SUP 27
Port_14031321_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031465_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031456_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031465_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031456_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031473_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031473_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031542_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031544_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14031929_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14035581_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14034908_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14031929_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032282_2 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032075_0 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032075_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032285_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032193_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14034914_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032209_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032193_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032204_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032209_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14032285_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032204_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14033378_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033434_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14033536_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033532_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14033532_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033545_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14034824_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14033967_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14034823_0 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14034826_2 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14034834_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14034823_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14034826_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14034824_2 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14034907_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14034910_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14034915_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14034907_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14034910_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14034908_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14035287_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044457_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14035523_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14035580_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14035581_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14035523_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14035648_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14035640_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14039446_2 | SINK | DUCT | VENTILATION | SUP 43
InPort_14039448_2 | SINK | DUCT | VENTILATION | SUP 43
InPort_14042179_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042345_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042347_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042179_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042242_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042228_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042228_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042253_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042253_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042247_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042247_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042309_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042309_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042299_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042299_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042347_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042584_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042576_0 | SOURCE | DUCT | VENTILATION | SUP 27
