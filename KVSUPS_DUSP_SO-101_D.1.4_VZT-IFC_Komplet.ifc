Properties of the parts of a building model (IFC4), part 4 of 21

# IfcSpace: Umývárna - Ž A320.1:13895285, A320.1
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00167681 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 13.4183 m3; Plocha: 4.32847 m2
Identifikační data - Číslo: A320.1; Číslo místnosti: Neobsazené; ID systému: 12; Název: Umývárna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Umývárna - Ž A410.1:13895050, A410.1
In: 4.NP_SO-101
LongName: Umývárna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 4.97145 m3; NetVolume: 4.97145 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0756525; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 23.2662 W; Specifikované výkonové zatížení: 30.2461 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.000837345 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 4.97145 m3; Plocha: 2.1615 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A410.1; Číslo místnosti: Neobsazené; ID systému: 13; Název: Umývárna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Umývárna A0105.1:13899656, A0105.1
In: -1.PP_SO-101
LongName: Umývárna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 3.72479 m3; NetVolume: 3.72479 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.070469; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 21.672 W; Specifikované výkonové zatížení: 28.1737 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0416667 m3/s; Tok venkovního vzduchu: 0.000779972 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 3.72479 m3; Plocha: 2.0134 m2
Identifikační data - Číslo: A0105.1; Číslo místnosti: Neobsazené; ID systému: 5; Název: Umývárna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Umývárna A0109.1:13899634, A0109.1
In: -1.PP_SO-101
LongName: Umývárna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 8.27975 m3; NetVolume: 8.27975 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.125996; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 38.7489 W; Specifikované výkonové zatížení: 50.3736 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0166667 m3/s; Tok venkovního vzduchu: 0.00139456 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 8.27975 m3; Plocha: 3.59989 m2
Identifikační data - Číslo: A0109.1; Číslo místnosti: Neobsazené; ID systému: 6; Název: Umývárna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Umývárna A0112.1:13899616, A0112.1
In: -1.PP_SO-101
LongName: Umývárna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2879.83 mm; GrossVolume: 6.42916 m3; NetVolume: 6.42916 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0978351; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 30.0882 W; Specifikované výkonové zatížení: 39.1147 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00108287 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2879.83 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 2879.83 mm; Objem: 6.42916 m3; Plocha: 2.79529 m2
Identifikační data - Číslo: A0112.1; Číslo místnosti: Neobsazené; ID systému: 5; Název: Umývárna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VZT strojovna A0122:13900583, A0122
In: -1.PP_SO-101
LongName: VZT strojovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3600 mm; NetVolume: 79.9966 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.874303; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 268.883 W; Specifikované výkonové zatížení: 349.548 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00967705 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Horní limit: -1.PP_SO-101; Dolní odsazení: -300 mm; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3600 mm; Objem: 79.9966 m3; Plocha: 24.9801 m2
Identifikační data - Číslo: A0122; Číslo místnosti: Neobsazené; Název: VZT strojovna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VZT strojovna A408:13895046, A408
In: 4.NP_SO-101
LongName: VZT strojovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 425.967 m3
Energetická analýza - Celkový přírůstek tepla na osobu: 131.882 W; Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Obsaditelné: yes; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 3.90389; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení: 0 W; Skutečné výkonové zatížení na plochu: 0; Specifikované světelné zatížení: 1200.6 W; Specifikované výkonové zatížení: 1560.79 W; Typ podmínky: Vytápěno a chlazeno; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Zóna: Výchozí
Mechanické – tok - Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0.0361111 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0361111 m3/s; Tok venkovního vzduchu: 0.0432095 m3/s; Zpětný tok vzduchu: Stanovený
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 4000 mm; Objem: 425.967 m3; Obvod: 0 mm; Plocha: 111.54 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A408; Číslo místnosti: Neobsazené; ID systému: 3; Název: VZT strojovna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vstup A104:13895436, A104
In: 1.NP_SO-101
LongName: Vstup; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 37.2826 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.500239; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 153.844 W; Specifikované výkonové zatížení: 199.997 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0055368 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 37.2826 m3; Plocha: 14.2925 m2
Identifikační data - Číslo: A104; Číslo místnosti: Neobsazené; Název: Vstup; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Váhovna A202:13895388, A202
In: 2.NP_SO-101
LongName: Váhovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 78.7024 m3; NetVolume: 78.7024 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Počet dospělých: 1; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Dávka žák: 0.00555556 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.73652; Počet žáků: 7; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 226.509 W; Specifikované výkonové zatížení: 294.462 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.0166667 m3/s; Specifikovaný přívod vzduchu: 0.0416667 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0555556 m3/s; Tok venkovního vzduchu: 0.00815203 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 78.7024 m3; Plocha: 21.0434 m2
Identifikační data - Číslo: A202; Číslo místnosti: Neobsazené; ID systému: 2; Název: Váhovna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Váhovna A212:13895377, A212
In: 2.NP_SO-101
LongName: Váhovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 87.4185 m3; NetVolume: 87.4185 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Dávka žák: 0.00555556 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet dospělých: 6; Počet osob: 0.818088; Počet žáků: 1; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 251.595 W; Specifikované výkonové zatížení: 327.073 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0.0333333 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0472222 m3/s; Tok venkovního vzduchu: 0.00905485 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 87.4185 m3; Plocha: 23.3739 m2
Identifikační data - Číslo: A212; Číslo místnosti: Neobsazené; ID systému: 2; Název: Váhovna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výchovný poradce A315:13895250, A315
In: 3.NP_SO-101
LongName: Výchovný poradce; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 87.5092 m3; NetVolume: 87.5092 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet dospělých: 4; Počet osob: 0.818936; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 251.856 W; Specifikované výkonové zatížení: 327.413 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0.0555556 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0555556 m3/s; Tok venkovního vzduchu: 0.00906424 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 87.5092 m3; Plocha: 23.3982 m2
Identifikační data - Číslo: A315; Číslo místnosti: Neobsazené; ID systému: 3; Název: Výchovný poradce; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah A118:13895437, A118
In: 1.NP_SO-101
LongName: Výtah; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.667 m3; NetVolume: 14.667 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.128336; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 39.4685 W; Specifikované výkonové zatížení: 51.3091 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00142046 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.667 m3; Plocha: 3.66675 m2
Identifikační data - Číslo: A118; Číslo místnosti: Neobsazené; Název: Výtah; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah A215:13895406, A215
In: 2.NP_SO-101
LongName: Výtah; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 14.9028 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.130543; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 40.1471 W; Specifikované výkonové zatížení: 52.1912 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00144489 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.9028 m3; Plocha: 3.72979 m2
Identifikační data - Číslo: A215; Číslo místnosti: Neobsazené; Název: Výtah; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah A318:13895293, A318
In: 3.NP_SO-101
LongName: Výtah; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 16.8598 m3; NetVolume: 16.8598 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.147523; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 45.3692 W; Specifikované výkonové zatížení: 58.98 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00163283 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 16.8598 m3; Plocha: 4.21494 m2
Identifikační data - Číslo: A318; Číslo místnosti: Neobsazené; Název: Výtah; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah A405:13901237, A405
In: 4.NP_SO-101
LongName: Výtah; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 12.3083 m3; NetVolume: 12.3083 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.130543; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 40.1472 W; Specifikované výkonové zatížení: 52.1914 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00144489 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 3300 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 3300 mm; Objem: 12.3083 m3; Plocha: 3.7298 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A405; Číslo místnosti: Neobsazené; Název: Výtah; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah os./nákl. A0123:13900590, A0123
In: -1.PP_SO-101
LongName: Výtah os./nákl.; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 11.6498 m3; NetVolume: 11.6498 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.123558; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 37.9991 W; Specifikované výkonové zatížení: 49.3989 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00136758 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 11.6498 m3; Plocha: 3.53023 m2
Identifikační data - Číslo: A0123; Číslo místnosti: Neobsazené; Název: Výtah os./nákl.; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VĚTRÁNO PŘIROZENĚ A0101:13900559, A0101
In: -1.PP_SO-101
LongName: VĚTRÁNO PŘIROZENĚ; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 155.934 m3; NetVolume: 155.934 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.88847; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 580.781 W; Specifikované výkonové zatížení: 755.015 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0209022 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 155.934 m3; Plocha: 53.9563 m2
Identifikační data - Číslo: A0101; Číslo místnosti: Neobsazené; Název: VĚTRÁNO PŘIROZENĚ; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VĚTRÁNO PŘIROZENĚ A0102:13900566, A0102
In: -1.PP_SO-101
LongName: VĚTRÁNO PŘIROZENĚ; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 102.75 m3; NetVolume: 102.75 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.24438; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 382.697 W; Specifikované výkonové zatížení: 497.507 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0137732 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 102.75 m3; Obvod: 23852.1 mm; Plocha: 35.5538 m2
Identifikační data - Číslo: A0102; Číslo místnosti: Neobsazené; Název: VĚTRÁNO PŘIROZENĚ; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VĚTRÁNO PŘIROZENĚ A0116:13895490, A0116
In: -1.PP_SO-101
LongName: VĚTRÁNO PŘIROZENĚ; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 358.921 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 4.3558; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 1339.59 W; Specifikované výkonové zatížení: 1741.46 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0555556 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0482114 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 358.921 m3; Plocha: 124.452 m2
Identifikační data - Číslo: A0116; Číslo místnosti: Neobsazené; ID systému: 1; Název: VĚTRÁNO PŘIROZENĚ; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VĚTRÁNO PŘIROZENĚ A0120:13895489, A0120
In: -1.PP_SO-101
LongName: VĚTRÁNO PŘIROZENĚ; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 124.789 m3; NetVolume: 124.789 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.51129; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 464.782 W; Specifikované výkonové zatížení: 604.217 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0167274 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 124.789 m3; Plocha: 43.1797 m2
Identifikační data - Číslo: A0120; Číslo místnosti: Neobsazené; Název: VĚTRÁNO PŘIROZENĚ; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: VĚTRÁNO PŘIROZENĚ A0121:13900539, A0121
In: -1.PP_SO-101
LongName: VĚTRÁNO PŘIROZENĚ; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 115.268 m3; NetVolume: 115.268 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.39598; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 429.321 W; Specifikované výkonové zatížení: 558.117 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0154512 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 115.268 m3; Obvod: 18881.9 mm; Plocha: 39.8852 m2
Identifikační data - Číslo: A0121; Číslo místnosti: Neobsazené; Název: VĚTRÁNO PŘIROZENĚ; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC A0105.2:13899659, A0105.2
In: -1.PP_SO-101
LongName: WC; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3765 mm; GrossVolume: 4.66102 m3; NetVolume: 4.66102 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.070469; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 21.672 W; Specifikované výkonové zatížení: 28.1737 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000779972 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Horní limit: -1.PP_SO-101; Dolní odsazení: -465 mm; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3765 mm; Objem: 4.66102 m3; Plocha: 2.0134 m2
Identifikační data - Číslo: A0105.2; Číslo místnosti: Neobsazené; ID systému: 5; Název: WC; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC A0109.2:13899637, A0109.2
In: -1.PP_SO-101
LongName: WC; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 4.13987 m3; NetVolume: 4.13987 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0629981; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 19.3745 W; Specifikované výkonové zatížení: 25.1868 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000697282 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 4.13987 m3; Plocha: 1.79995 m2
Identifikační data - Číslo: A0109.2; Číslo místnosti: Neobsazené; ID systému: 6; Název: WC; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC A0109.3:13899640, A0109.3
In: -1.PP_SO-101
LongName: WC; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 3.0015 m3; NetVolume: 3.0015 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.045675; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 14.0469 W; Specifikované výkonové zatížení: 18.261 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000505545 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 3.0015 m3; Plocha: 1.305 m2
Identifikační data - Číslo: A0109.3; Číslo místnosti: Neobsazené; ID systému: 6; Název: WC; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC A01112.3:13899613, A01112.3
In: -1.PP_SO-101
LongName: WC; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2879.83 mm; GrossVolume: 6.12884 m3; NetVolume: 6.12884 m3
