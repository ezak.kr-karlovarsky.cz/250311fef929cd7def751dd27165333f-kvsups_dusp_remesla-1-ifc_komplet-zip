Properties of the parts of a building model (IFC4), part 11 of 21

# IfcDistributionPort (3839)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_13829792_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13622267_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13539979_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540954_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540429_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540429_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000912_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13544752_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13540602_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13540602_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13540623_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13540609_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540621_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540623_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13540609_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540609_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540816_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540609_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540907_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540621_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540619_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13741310_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540674_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13741310_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540762_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540954_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540962_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540962_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000914_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540962_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13541001_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13547789_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13541126_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13542109_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542116_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542113_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542109_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544726_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542111_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542111_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542113_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542116_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630220_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542127_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542133_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544686_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542127_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542129_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13924806_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13548004_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13542129_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13542133_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544748_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630244_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544686_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544720_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544726_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544724_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544720_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13741310_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13544724_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544746_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544752_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544750_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544746_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13544748_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13544750_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630352_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546859_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546859_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13595663_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546861_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546866_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546864_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546861_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546871_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546862_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546862_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546864_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546866_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630348_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546868_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546871_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546873_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546868_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546869_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546873_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546877_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546869_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546875_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546877_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546881_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13546875_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546879_0 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546889_2 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546879_1 | SINK | DUCT | VENTILATION | ETA 35
OutPort_14000916_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546879_2 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546883_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546879_3 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546884_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546879_4 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546885_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546887_0 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546881_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13546887_2 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546886_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13546889_1 | SINK | DUCT | VENTILATION | ETA 35
OutPort_13546887_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13547028_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630326_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14055554_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547028_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547030_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547035_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547033_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547030_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547038_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547031_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547031_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547033_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630322_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547035_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547035_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547030_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547037_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547038_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547050_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547037_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547040_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547054_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547040_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14000918_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13547040_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630474_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13547040_3 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630506_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13547040_4 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630534_1 | SOURCE | DUCT | VENTILATION | ETA 35
InPort_13547046_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547042_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547042_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547048_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547048_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547044_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547044_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547050_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547052_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547046_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547054_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547052_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547198_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764546_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764559_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13547198_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13547847_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13547789_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13547789_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13630570_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13548163_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13548004_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630226_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13548147_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13548147_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13924815_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_14035123_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13548163_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13577643_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13577663_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080887_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13577643_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042878_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13577840_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13577840_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042880_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13595310_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055549_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764546_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13595310_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13595663_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055550_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13972497_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13611350_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13611350_2 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13618001_1 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13611350_3 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13972620_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13625053_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13611350_4 | SOURCE | DUCT | EXHAUST | EHA 10
Port_13612709_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739175_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13612709_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13614156_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13613016_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614571_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13613016_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614597_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13613386_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739851_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13613386_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739406_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13613662_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614596_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13613662_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737676_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13613742_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614596_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13613742_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614597_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614336_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614571_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_14032391_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13615030_0 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13615030_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13803672_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13617975_0 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13899254_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13625875_2 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13617975_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13618001_0 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13972166_1 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13972166_2 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13618071_0 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13618071_1 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13624780_2 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13619416_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13624514_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13738965_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13619416_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13620385_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13759590_3 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14035580_2 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13620385_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13841268_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13620731_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13620731_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13927092_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13927210_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13622267_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13622267_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000920_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13622267_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13842390_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13624514_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13624511_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13624511_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14055448_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13624534_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13738879_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13624536_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13624534_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13964900_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13624536_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13625021_1 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13624768_0 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13624768_1 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13821062_1 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13624780_1 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13625017_0 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13625019_0 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13625015_1 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13625015_3 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13625021_0 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13625017_1 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13625019_1 | SOURCE | DUCT | VENTILATION | ODA 10
InPort_13625051_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13972822_0 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13899254_0 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625051_3 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13972822_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625053_0 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13625392_1 | SINK | DUCT | VENTILATION
InPort_13625468_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704518_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704504_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13625468_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13625865_0 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625875_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13625914_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625865_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13625906_0 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625914_2 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13899255_2 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13625906_1 | SOURCE | DUCT | EXHAUST | EHA 10
Port_13626266_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13626278_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13626266_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
InPort_13626503_0 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13820875_2 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13904802_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13626503_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13626638_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13630955_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13929989_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13626638_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13630884_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13626733_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13626733_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972447_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13630218_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630226_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630224_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630218_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630220_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630224_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630248_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630242_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630242_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630246_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630246_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630244_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13761733_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13630248_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13630326_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630320_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630320_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630324_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630324_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630322_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630346_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630352_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630350_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630346_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630348_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13630350_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13630570_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13630566_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13830021_2 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632089_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632089_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632255_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632091_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632122_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632124_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632091_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13830017_2 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632092_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632092_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632124_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632098_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13830017_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13830019_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632098_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632101_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13830021_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13830023_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632101_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632122_2 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632102_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632102_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13830023_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632218_0 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13830019_2 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13801183_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632218_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632255_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632245_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632245_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632455_1 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632455_2 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13632449_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13632449_1 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13905302_1 | SOURCE | DUCT | EXHAUST | ETA 22
OutPort_13699344_1 | SOURCE | DUCT | VENTILATION
InPort_13704474_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704476_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704476_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704502_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704502_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704504_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704516_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704524_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704522_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704516_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704518_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704522_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704626_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704634_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704632_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704626_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704628_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704632_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704684_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704692_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704690_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704684_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704686_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704690_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704738_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704736_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704783_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704738_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704785_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704783_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704803_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704797_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704797_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704801_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704801_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704799_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704823_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704817_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704817_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704821_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704821_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704819_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704887_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704823_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704891_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704885_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704885_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704889_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704889_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704887_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_13704986_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705002_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13704986_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13704988_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13704988_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705096_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705000_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705002_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705096_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705098_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705098_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13908543_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705154_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705176_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705154_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705174_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705172_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705278_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705172_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705174_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705176_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14054655_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705256_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705278_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705256_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705276_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705274_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705276_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13928233_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13711418_0 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13711418_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13927902_1 | SOURCE | DUCT | VENTILATION | ODA 18
OutPort_13711420_0 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13711420_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928145_1 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13711558_0 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13928233_2 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13928244_1 | SINK | DUCT | VENTILATION | ODA 18
OutPort_13711558_1 | SOURCE | DUCT | VENTILATION | ODA 18
InPort_13934396_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13715968_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13715968_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13934398_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13715968_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13934532_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13934398_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13715973_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13715973_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13830027_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079186_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716070_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716070_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079059_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716117_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13934396_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716157_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716117_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716117_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13905969_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716117_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13906204_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13933717_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716157_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911506_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716284_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716284_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911508_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716284_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14077287_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716284_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14077531_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13911508_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716291_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716291_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911289_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716291_4 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079976_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080167_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13716488_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716488_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080170_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716651_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13911506_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716651_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14000837_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716651_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13843538_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716849_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081751_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081884_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13716849_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13716851_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081586_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081704_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13716851_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13716867_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14080764_0 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081940_3 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13716867_1 | SOURCE | DUCT | EXHAUST | ETA 4
Port_13716871_0 | SOURCEANDSINK | DUCT | EXHAUST | ETA 4
Port_14081368_1 | SOURCEANDSINK | DUCT | EXHAUST | ETA 4
InPort_14081586_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13716871_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_13716871_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13929570_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716871_3 | SINK | DUCT | EXHAUST | ETA 4
OutPort_13929829_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13716875_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14081368_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 4
Port_13716875_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_13716875_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13929282_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716875_3 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13929350_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13716875_4 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13929415_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13717200_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14081940_2 | SOURCEANDSINK | DUCT | EXHAUST | ETA 4
Port_13717200_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080659_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_13738023_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13735667_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13735667_2 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13740716_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13735667_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737329_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13736023_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13735667_4 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13735974_0 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13736023_2 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13737470_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13735974_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13740716_2 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13736064_0 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13736064_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032282_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_14034914_2 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13736728_0 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13736728_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14034915_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13737332_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737316_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13737316_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737730_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13737329_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737330_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13737330_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737332_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13760985_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13737470_2 | SOURCE | DUCT | EXHAUST | EHA 3
Port_13737589_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737801_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737589_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737731_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13737730_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13737640_0 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13737640_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737677_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13737640_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14073366_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13737676_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737798_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737677_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737731_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737796_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737799_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737796_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737801_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737798_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13737799_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13737948_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13738023_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14074251_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13737948_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14074249_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13738044_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13738044_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14074251_2 | SOURCE | DUCT | VENTILATION | SUP 27
Port_13738044_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14074289_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_13740119_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13738627_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13738627_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13740345_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13738879_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13738863_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13738931_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13738965_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13739175_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073621_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739198_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739853_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739198_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739851_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739200_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739853_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739200_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073619_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739321_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739406_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739321_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739407_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13739394_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739399_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739394_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14074289_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739399_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739401_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739401_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13739407_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
InPort_13740345_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13740211_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13740211_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14074249_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13966762_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13741310_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13759590_1 | SINK | DUCT | VENTILATION | ODA 3
OutPort_13759720_1 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13759720_0 | SINK | DUCT | VENTILATION | ODA 3
OutPort_14032391_2 | SOURCE | DUCT | VENTILATION | ODA 3
InPort_13760009_0 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760619_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13760037_2 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760009_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13760030_0 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760037_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13932335_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760030_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13760526_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14034833_1 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13760619_2 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760526_3 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14034833_2 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760616_0 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13760616_1 | SINK | DUCT | EXHAUST | EHA 3
OutPort_14034834_2 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_14033967_0 | SINK | DUCT | EXHAUST | EHA 3
OutPort_13760985_2 | SOURCE | DUCT | EXHAUST | EHA 3
InPort_13761749_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13761733_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13924807_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13761749_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13762048_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762065_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14042345_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762048_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762065_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762387_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762373_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762391_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762389_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762373_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762387_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762389_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13762550_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002598_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_13762550_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_13762550_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13841897_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13762558_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14002589_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_13762684_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762697_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762697_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762713_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762697_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13841699_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762713_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762705_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13762705_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13842127_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13763089_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13763054_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13763054_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790834_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13835585_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13763062_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13763062_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14061046_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13763298_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14061084_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14061087_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13763298_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13830053_2 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763476_0 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763476_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13801240_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763478_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763485_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763487_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763478_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13830049_2 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763479_0 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763479_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763487_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763481_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13830049_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13830051_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763481_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763482_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13830053_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13830055_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763482_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763485_2 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763483_0 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763483_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13830055_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763495_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13830051_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763770_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763495_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763758_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13958450_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13938247_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763758_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13958447_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13763770_2 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13763847_1 | SINK | DUCT
OutPort_13763947_1 | SOURCE | DUCT
InPort_13763853_1 | SINK | DUCT
OutPort_13763847_2 | SOURCE | DUCT
InPort_13763850_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13830057_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14003421_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13763850_2 | SOURCE | DUCT | VENTILATION | ETA 1
Port_13763853_2 | SOURCEANDSINK | DUCT
InPort_13763857_0 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14003421_2 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14003423_2 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13763857_1 | SOURCE | DUCT | VENTILATION | ETA 1
Port_13763947_2 | SOURCEANDSINK | DUCT
Port_13763997_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13930692_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13763997_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
Port_13830063_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
InPort_13764198_0 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14003423_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_13938609_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13764198_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_13764308_0 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13938609_2 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14045104_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13764308_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_13764382_0 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14045100_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_13967293_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_13764382_1 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14051704_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764550_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764550_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14051718_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14051719_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764559_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054053_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764562_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764562_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14050732_1 | SOURCE | DUCT | EXHAUST | ETA 35
Port_13764678_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
InPort_13764742_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054053_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054065_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764742_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764751_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054264_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764765_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764751_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13764760_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764765_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14000047_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_13764760_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_13765152_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13938251_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13904850_1 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13765152_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13790051_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790716_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13830067_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790051_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14061082_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790054_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790054_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13830067_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13830069_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790345_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790345_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790855_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790347_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13830069_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14035640_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790347_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14035644_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790352_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790352_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14035648_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790675_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790407_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790407_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14035644_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790669_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790675_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790673_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790669_2 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790716_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790671_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790671_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790673_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790834_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13835587_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790855_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790849_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790849_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790909_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790909_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790901_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790901_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790919_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14000613_0 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13790913_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790913_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14000700_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13790919_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14000613_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_13801183_0 | SINK | DUCT | EXHAUST | ETA 22
OutPort_13801179_1 | SOURCE | DUCT | VENTILATION | ETA 22
InPort_13801179_1 | SINK | DUCT | VENTILATION | ETA 22
OutPort_13801183_0 | SOURCE | DUCT | EXHAUST | ETA 22
InPort_13801240_0 | SINK | DUCT | VENTILATION | ETA 31
OutPort_13801238_1 | SOURCE | DUCT | VENTILATION | ETA 31
InPort_13801547_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13835077_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14054881_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13801547_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13801547_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13801637_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14057696_0 | SINK | DUCT | VENTILATION | ODA 1
OutPort_13802574_1 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_13802643_1 | SINK | DUCT | EXHAUST
InPort_13820875_1 | SINK | DUCT | EXHAUST | EHA 10
OutPort_13899255_1 | SOURCE | DUCT | EXHAUST | EHA 10
InPort_13821062_0 | SINK | DUCT | VENTILATION | ODA 10
OutPort_13821060_1 | SOURCE | DUCT | VENTILATION | ODA 10
OutPort_13825869_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13825869_3 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826461_0 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826461_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826467_2 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826501_0 | SINK | DUCT | VENTILATION | ODA 11
InPort_13826567_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826501_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826534_0 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826567_2 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826685_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826534_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826683_0 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826681_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826681_2 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826754_0 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826754_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826752_2 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13827581_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827054_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827054_3 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827499_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827216_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827202_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827214_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827216_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827357_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827502_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827507_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827357_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827499_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827507_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827747_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827581_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14003222_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827750_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827750_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827762_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827758_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14003222_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827909_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13849735_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13828009_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13845172_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13828009_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13968504_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13828374_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13828374_3 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13968655_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13931936_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13828398_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13828398_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13968629_1 | SOURCE | DUCT | VENTILATION | SUP 20
Port_13829040_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13969314_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13829040_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13829125_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13829058_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964534_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829058_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964535_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829060_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13932118_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829412_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829434_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829412_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13932118_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829432_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964534_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829432_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829434_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13829830_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13829862_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13829860_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13829830_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830105_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13829856_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13829856_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13829860_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13829884_1 | SINK | DUCT | VENTILATION | ETA 3
OutPort_13829884_2 | SOURCE | DUCT | VENTILATION | ETA 3
InPort_13829898_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830141_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13829900_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13829898_1 | SOURCE | DUCT | VENTILATION | ETA 28
OutPort_13829900_2 | SOURCE | DUCT | VENTILATION | ETA 28
Port_13829902_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13830027_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079182_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13830057_2 | SINK | DUCT | VENTILATION | ETA 1
Port_13830063_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 8
InPort_13830117_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830105_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13834746_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830117_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830141_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830167_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830167_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13834760_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830365_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830392_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830389_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830365_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830385_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830389_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830392_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830660_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830484_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830510_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830508_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830484_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830586_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830506_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830506_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830508_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830568_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830586_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830584_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830568_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830582_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830584_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830642_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830664_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830662_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830642_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830660_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830662_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830747_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033273_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830768_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830747_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14033434_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830768_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830789_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13925608_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13925643_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830823_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830823_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830852_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830852_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830846_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830846_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_14000839_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830846_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13910000_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830846_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13910039_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13830846_4 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13910108_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13930348_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831340_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831340_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930336_3 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831348_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831351_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831404_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831348_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831351_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831354_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831353_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13930346_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831356_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831353_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831354_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831356_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831422_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831404_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831426_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831420_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831420_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831424_2 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831424_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831422_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831772_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831426_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13831594_0 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13938315_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13904835_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831594_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13930138_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13831772_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13928410_2 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13832057_0 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13832057_1 | SINK | DUCT | EXHAUST | ETA 2
OutPort_13928412_1 | SOURCE | DUCT | EXHAUST | ETA 2
InPort_13832353_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13972597_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13928737_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13832353_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13832355_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13928737_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13972403_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13832355_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13832411_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13929979_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13972703_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13832411_3 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13834141_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959472_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13834341_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13834141_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13834264_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13843838_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13959600_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13834264_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13843866_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13834341_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13834748_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13834746_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14076701_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13834748_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13834760_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13834762_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_14054623_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13835070_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13835070_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14054881_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13835138_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13835538_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000885_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13835138_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13835446_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13835138_4 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13908775_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13835536_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13835587_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_13835585_2 | SOURCE | DUCT | EXHAUST | ETA 29
Port_13835599_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
