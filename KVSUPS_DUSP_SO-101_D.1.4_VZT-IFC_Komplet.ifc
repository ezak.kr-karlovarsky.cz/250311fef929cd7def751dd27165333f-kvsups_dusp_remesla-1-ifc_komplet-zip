Properties of the parts of a building model (IFC4), part 21 of 21

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (298)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému = Group | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa
14042784 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2559.71 | 2396.86 | 2503.14 | 2340.29 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0606 | 0606 | no
14042828 | -1.PP_SO-101 | 498.787 | 0.0201032 | 0.250718 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2430 | 2350 | 2350 | 2270 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0607 | 0607 | no
14042840 | -1.PP_SO-101 | 8.87302 | 0.0201032 | 0.00446006 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 100 | 2459.71 | 2403.14 | 2396.86 | 2340.29 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0608 | 0608 | no
14044953 | 3.NP_SO-101 | 6.20712 | 0.0201032 | 0.00312004 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 160 | Zpětný vzduch | 0 | ETA 1 | 2 | Odváděný | ETA | PO02.02.0618 | 0618 | yes
14048149 | 4.NP_SO-101 | 8737.57 | 0.0122696 | 3.43123 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.736919 | 0.0843391 | 4.NP_SO-101 | 0 | 3962.53 | 3900 | 3900.03 | 3837.5 | 125 | Zpětný vzduch | 2.65769 | ETA 19 | 384 | Odváděný | ETA | PO02.02.0623 | 0623 | yes
14048253 | 4.NP_SO-101 | 1450 | 0.01227 | 0.569416 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.122292 | 0.0843391 | 4.NP_SO-101 |  | 3775 | 3775 | 2325 | 2325 | 125 | Zpětný vzduch | 0.441045 | ETA 19 | 384 | Odváděný | ETA | PO02.02.0624 | 0624 | yes
14054655 | 3.NP_SO-101 | 4439.11 | 0.0254431 | 2.51026 | 180 mm | 0 | 180 mm | 0.064486 | 0.00833333 | 3894.99 | 0.327479 | 0.0530066 | 0.0148045 | 3.NP_SO-101 | 0 | 3140 | 3050 | 3050 | 2960 | 180 | Zpětný vzduch | 0.821986 | ETA 19 | 386 | Odváděný | ETA | PO02.02.0637 | 0637 | yes
14055137 | 1.NP_SO-101 | 273.793 | 0.159008 | 0.387066 | 450 mm | 0 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3105 | 2880 | 2880 | 2655 | 450 | Přívod vzduchu | 0 | SUP 27 | 365 | Přívodní | SUP | PO02.02.0640 | 0640 | yes | Identifikační data - Komentáře: VZT1
14055526 | -1.PP_SO-101 | 707.354 | 0.0254431 | 0.399999 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2540 | 2450 | 2450 | 2360 | 180 | Zpětný vzduch | 0 | ETA 35 | 219 | Odváděný | ETA | PO02.02.0643 | 0643 | yes
14061032 | 4.NP_SO-101 | 265.117 | 0.0254422 | 0.14992 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 100 | 3310.92 | 3059.81 | 3247.28 | 2996.17 | 180 | Zpětný vzduch | 0 | ETA 29 | 377 | Odváděný | ETA | PO02.02.0659 | 0659
14061082 | 4.NP_SO-101 | 109.897 | 0.04908 | 0.0863133 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2023.77 | 2023.77 | 1913.87 | 1913.87 | 250 | Zpětný vzduch | 0 | ETA 29 | 296 | Odváděný | ETA | PO02.02.0660 | 0660
14064705 | 4.NP_SO-101 | 177.141 | 0.0254431 | 0.100171 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.0179498 | 0.10133 | 4.NP_SO-101 | 0 | 4190 | 4100 | 4100 | 4010 | 180 | Zpětný vzduch | 0.0309279 | ETA 19 | 397 | Odváděný | ETA | PO02.02.0672 | 0672
14064706 | 4.NP_SO-101 | 133.693 | 0.0254431 | 0.0756017 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.0135472 | 0.10133 | 4.NP_SO-101 | 99.9999 | 4110.92 | 3952.74 | 4047.28 | 3889.1 | 180 | Zpětný vzduch | 0.0233421 | ETA 19 | 397 | Odváděný | ETA | PO02.02.0673 | 0673
14067664 | 3.NP_SO-101 | 114.505 | 0.0314112 | 0.0719455 | 200 mm | 0 | 200 mm | 1.52313 | 0.05 | 21032.9 | 1.59155 | 0.0241357 | 0.210783 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Zpětný vzduch | 0.0158461 | ETA 29 | 376 | Odváděný | ETA | PO02.02.0677 | 0677
14067683 | 3.NP_SO-101 | 667.493 | 0.0314112 | 0.419398 | 200 mm | 0 | 200 mm | 1.52313 | 0.05 | 21032.9 | 1.59155 | 0.140696 | 0.210783 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Zpětný vzduch | 0.0923729 | ETA 29 | 376 | Odváděný | ETA | PO02.02.0678 | 0678
14069765 | 2.NP_SO-101 | 138.119 | 0.0201032 | 0.069426 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00358011 | 0.0259205 | 2.NP_SO-101 | 373.205 | 4140.06 | 3985.94 | 4119.35 | 3965.23 | 160 | Zpětný vzduch | 0.0346594 | ETA 19 | 228 | Odváděný | ETA | PO02.02.0680 | 0680
14069784 | 2.NP_SO-101 | 384.501 | 0.0201032 | 0.193271 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.00996648 | 0.0259205 | 2.NP_SO-101 | 579308 | 3944.52 | 3560 | 3944.5 | 3559.99 | 160 | Zpětný vzduch | 0.0964864 | ETA 19 | 228 | Odváděný | ETA | PO02.02.0681 | 0681
14071558 | 1.NP_SO-101 | 50 | 0.0314112 | 0.0314159 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2951.29 | 2851.29 | 2851.29 | 2751.29 | 200 | Zpětný vzduch | 0 | ETA 5 | 253 | Odváděný | ETA | PO02.02.0691 | 0691
14075248 | 1.NP_SO-101 | 372.895 | 0.04908 | 0.292871 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3005 | 2880 | 2880 | 2755 | 250 | Přívod vzduchu | 0 | SUP 27 | 373 | Přívodní | SUP | PO02.02.0703 | 0703
14075354 | 1.NP_SO-101 | 188.148 | 0.04908 | 0.147771 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3005 | 2880 | 2880 | 2755 | 250 | Přívod vzduchu | 0 | SUP 27 | 373 | Přívodní | SUP | PO02.02.0704 | 0704
14079182 | 1.NP_SO-101 | 333.785 | 0.0201032 | 0.167779 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 307 | Odváděný | ETA | PO02.02.0717 | 0717 | yes
14079474 | 1.NP_SO-101 | 1062.72 | 0.0201032 | 0.534179 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3430 | 3350 | 3350 | 3270 | 160 | Zpětný vzduch | 0 | ETA 4 | 353 | Odváděný | ETA | PO02.02.0718 | 0718 | yes | Identifikační data - Komentáře: VZT9/10
14081693 | 3.NP_SO-101 | 100.797 | 0.0201032 | 0.050666 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 100 | 3454.71 | 3398.14 | 3326.86 | 3270.29 | 160 | Zpětný vzduch | 0 | ETA 4 | 390 | Odváděný | ETA | PO02.02.0724 | 0724
14081751 | 3.NP_SO-101 | 56.6619 | 0.04908 | 0.0445022 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3570 | 3445 | 3445 | 3320 | 250 | Zpětný vzduch | 0 | ETA 4 | 396 | Odváděný | ETA | PO02.02.0725 | 0725
14081802 | 3.NP_SO-101 | 818.288 | 0.0201032 | 0.411316 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3525 | 3445 | 3445 | 3365 | 160 | Zpětný vzduch | 0 | ETA 4 | 316 | Odváděný | ETA | PO02.02.0726 | 0726

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/vývod (104)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.2 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: SPIRO; Název typu: SPIRO POZINK/vývod; Označení typu: 04; Popis: Potrubí spiro pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Uzamknutí velikosti: no
Jiné - Rodina: Kulaté potrubí; Id typu: 9070558; Rodina a typ: Kulaté potrubí: SPIRO POZINK/vývod; Typ: SPIRO POZINK/vývod
Name (Kulaté potrubí:SPIRO POZINK/vývod:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost = Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Koeficient ztrát | Typ systému | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Název systému = Group | Řez | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13123321 | -1.PP_SO-101 | 5113.73 | 0.0201032 | 2.57044 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.04.0029 | 0029 | yes
13409872 | 1.NP_SO-101 | 9936.45 | 0.04908 | 7.80407 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3575 | 3450 | 3450 | 3325 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 119 | SUP | PO02.04.0038 | 0038 | no
13410323 | -1.PP_SO-101 | 1168.19 | 0.0397548 | 0.825744 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | -1.PP_SO-101 | 3993.19 | 2825 | 3993.19 | 2825 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 412 | ETA | PO02.04.0040 | 0040 | yes
13411568 | -1.PP_SO-101 | 4733.69 | 0.0201032 | 2.37941 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0046 | 0046 | yes
13411616 | -1.PP_SO-101 | 630.027 | 0.0201032 | 0.316686 | 160 mm | 24830.6 | 3.31689 | 0.0472222 | 2.34864 | 0.357358 | 0.567211 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0.107739 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 310 | SUP | PO02.04.0047 | 0047 | yes | Identifikační data - Komentáře: POD STROPEM
13421340 | 3.NP_SO-101 | 1714 | 0.0201032 | 0.86155 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 206 | SUP | PO02.04.0052 | 0052 | no
13421856 | -1.PP_SO-101 | 26.576 | 0.04908 | 0.0208728 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2387.59 | 2262.59 | 2262.59 | 2137.59 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 328 | SUP | PO02.04.0053 | 0053 | yes
13424462 | -1.PP_SO-101 | 30.1735 | 0.04908 | 0.0236982 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2525 | 2400 | 2400 | 2275 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 385 | ETA | PO02.04.0055 | 0055 | yes
13435564 | 3.NP_SO-101 | 347.307 | 0.04908 | 0.272774 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3325 | 3200 | 3200 | 3075 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.04.0059 | 0059 | yes | Identifikační data - Komentáře: VZT 7/8
13435587 | 4.NP_SO-101 | 7275 | 0.04908 | 5.71377 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 4.NP_SO-101 | 6725 | 6725 | -550 | -550 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.04.0060 | 0060 | yes | Identifikační data - Komentáře: VZT5/6
13439641 | 1.NP_SO-101 | 2371.12 | 0.01227 | 0.931137 | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3512.5 | 3450 | 3450 | 3387.5 | 0 | Přívodní | 125 | Přívod vzduchu | SUP 27 | 125 | SUP | PO02.04.0064 | 0064 | no
13439676 | 1.NP_SO-101 | 3300.62 | 0.01227 | 1.29615 | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3512.5 | 3450 | 3450 | 3387.5 | 0 | Přívodní | 125 | Přívod vzduchu | SUP 27 | 125 | SUP | PO02.04.0065 | 0065 | no
13444619 | 1.NP_SO-101 | 865 | 0.04908 | 0.679369 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 334 | SUP | PO02.04.0080 | 0080 | yes
13444633 | 1.NP_SO-101 | 10246.8 | 0.0254431 | 5.79442 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3340 | 3250 | 3250 | 3160 | 0 | Přívodní | 180 | Přívod vzduchu | SUP 27 | 303 | SUP | PO02.04.0081 | 0081 | no
13444719 | 1.NP_SO-101 | 158.484 | 0.04908 | 0.124473 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 311 | ETA | PO02.04.0082 | 0082 | yes
13444861 | 1.NP_SO-101 | 9769.72 | 0.04908 | 7.67312 | 250 mm | 8413.18 | 0.155969 | 0.025 | 0.509296 | 0.0142013 | 0.0208741 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.0910522 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 311 | ETA | PO02.04.0083 | 0083 | no
13454191 | 1.NP_SO-101 | 8440.83 | 0.04908 | 6.62941 | 250 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.0305459 | 0.0102914 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.440653 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 326 | ETA | PO02.04.0089 | 0089 | no
13454224 | 1.NP_SO-101 | 10302.6 | 0.04908 | 8.09165 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 131 | SUP | PO02.04.0090 | 0090 | no
13454238 | 1.NP_SO-101 | 10117.4 | 0.04908 | 7.94619 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 131 | SUP | PO02.04.0091 | 0091 | no
13455338 | 3.NP_SO-101 | 2644.94 | 0.0201032 | 1.32949 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 325 | SUP | PO02.04.0092 | 0092 | yes
13455523 | 3.NP_SO-101 | 2301.65 | 0.04908 | 1.80771 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3235.97 | 3110.97 | 3110.97 | 2985.97 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 43 | 319 | SUP | PO02.04.0093 | 0093 | no
13456168 | 1.NP_SO-101 | 3380 | 0.04908 | 2.65464 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1020433 | 1.NP_SO-101 | 3000.01 | 3000 | -379.997 | -380.009 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.04.0098 | 0098 | yes
13456508 | 3.NP_SO-101 | 7450 | 0.04908 | 5.85122 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 3.NP_SO-101 | 2950 | 2950 | -4500 | -4500 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.04.0102 | 0102 | yes | Identifikační data - Komentáře: VZT5/6
13480542 | 3.NP_SO-101 | 1199.16 | 0.04908 | 0.941817 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3325 | 3200 | 3200 | 3075 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.04.0128 | 0128 | yes | Identifikační data - Komentáře: VEDENO POD STROPEM
13500070 | 1.NP_SO-101 | 2460.01 | 0.159008 | 3.47776 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 1.NP_SO-101 | 2430 | 2430 | -30.0106 | -30.0106 | 0 | Přívodní | 450 | Přívod vzduchu | SUP 1 | 202 | SUP | PO02.04.0130 | 0130 | yes
13505572 | 2.NP_SO-101 | 18.2639 | 0.0779194 | 0.018074 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 2.NP_SO-101 | 2185 | 2185 | 2166.74 | 2166.74 | 0 | Znehodnocený | 315 | Odváděný vzduch | EHA 8 | 2 | EHA | PO02.04.0141 | 0141 | yes
13505681 | 2.NP_SO-101 | 542.014 | 0.0779194 | 0.536378 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 2.NP_SO-101 | 2708.75 | 2708.75 | 2166.74 | 2166.74 | 0 | Čerstvý | 315 | Přívod vzduchu | ODA 11 | 2 | ODA | PO02.04.0143 | 0143 | yes
13506992 | 4.NP_SO-101 | 7023.75 | 0.0779194 | 6.95071 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 4.NP_SO-101 | 6883.75 | 6883.75 | -140 | -140 | 0 | Znehodnocený | 315 | Odváděný vzduch | EHA 8 | 8 | EHA | PO02.04.0149 | 0149 | yes | Identifikační data - Komentáře: VZT 2
13507035 | 3.NP_SO-101 | 753.392 | 0.0779194 | 0.745558 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3702.5 | 3545 | 3545 | 3387.5 | 0 | Znehodnocený | 315 | Odváděný vzduch | EHA 8 | 8 | EHA | PO02.04.0150 | 0150 | yes | Identifikační data - Komentáře: VZT 2
13508656 | 3.NP_SO-101 | 5412.31 | 0.0201032 | 2.72052 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 326 | SUP | PO02.04.0152 | 0152 | yes
13531019 | 1.NP_SO-101 | 146.679 | 0.159008 | 0.207362 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3150 | 3150 | 2925 | 0 | Odváděný | 450 | Zpětný vzduch | ETA 30 | 375 | ETA | PO02.04.0182 | 0182 | yes
13537890 | 1.NP_SO-101 | 1271.46 | 0.0397548 | 0.89874 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 1.NP_SO-101 | 2675 | 2675 | 1403.54 | 1403.54 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 123 | ETA | PO02.04.0190 | 0190 | yes
13539665 | 1.NP_SO-101 | 183.551 | 0.04908 | 0.144161 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 123 | SUP | PO02.04.0193 | 0193 | yes
13539699 | 1.NP_SO-101 | 790 | 0.04908 | 0.620465 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 337 | SUP | PO02.04.0194 | 0194 | yes
13539788 | 1.NP_SO-101 | 183.551 | 0.04908 | 0.144161 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 131 | SUP | PO02.04.0195 | 0195 | yes
13614336 | 1.NP_SO-101 | 2737.13 | 0.159008 | 3.86952 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 1.NP_SO-101 | 2700 | -37.1268 | 2700 | -37.1268 | 0 | Odváděný | 450 | Zpětný vzduch | ETA 30 | 375 | ETA | PO02.04.0227 | 0227 | yes
13624536 | -1.PP_SO-101 | 356.447 | 0.04908 | 0.279953 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2387.59 | 2262.59 | 2262.59 | 2137.59 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 328 | SUP | PO02.04.0236 | 0236 | yes
13704988 | 3.NP_SO-101 | 2224.59 | 0.0201032 | 1.1182 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 199 | SUP | PO02.04.0266 | 0266 | yes
13705002 | 3.NP_SO-101 | 2109.13 | 0.0201032 | 1.06016 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 324 | SUP | PO02.04.0267 | 0267 | yes
13705098 | 3.NP_SO-101 | 475.189 | 0.0201032 | 0.238856 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 199 | SUP | PO02.04.0268 | 0268 | yes
13738879 | -1.PP_SO-101 | 31.5488 | 0.04908 | 0.0247784 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2387.59 | 2262.59 | 2262.59 | 2137.59 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 328 | SUP | PO02.04.0297 | 0297 | yes
13834264 | 1.NP_SO-101 | 35.1632 | 0.04908 | 0.0276171 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3005 | 2880 | 2880 | 2755 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 269 | SUP | PO02.04.0372 | 0372 | yes
13840889 | -1.PP_SO-101 | 200 | 0.0201032 | 0.100531 | 160 mm | 24830.6 | 3.31689 | 0.0472222 | 2.34864 | 0.113442 | 0.567211 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0.0342014 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 310 | SUP | PO02.04.0379 | 0379 | yes | Identifikační data - Komentáře: POD STROPEM
13841099 | -1.PP_SO-101 | 2929.06 | 0.0201032 | 1.4723 | 160 mm | 24830.6 | 3.31689 | 0.0472222 | 2.34864 | 1.48556 | 0.567211 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0.447877 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 359 | SUP | PO02.04.0381 | 0381 | yes | Identifikační data - Komentáře: POD STROPEM
13842518 | 1.NP_SO-101 | 535.991 | 0.04908 | 0.420966 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 131 | SUP | PO02.04.0383 | 0383 | yes
13842532 | 1.NP_SO-101 | 3579.63 | 0.04908 | 2.81143 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 123 | SUP | PO02.04.0384 | 0384 | yes
13842676 | 1.NP_SO-101 | 2515.32 | 0.0397548 | 1.77797 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3362.5 | 3250 | 3250 | 3137.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 305 | SUP | PO02.04.0385 | 0385 | yes
13842730 | 1.NP_SO-101 | 2789.18 | 0.0397548 | 1.97155 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3362.5 | 3250 | 3250 | 3137.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 305 | SUP | PO02.04.0386 | 0386 | no
13842875 | 1.NP_SO-101 | 3782.05 | 0.04908 | 2.97041 | 250 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.0389224 | 0.0102914 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.561493 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 326 | ETA | PO02.04.0387 | 0387 | no
13843132 | 1.NP_SO-101 | 1226.2 | 0.04908 | 0.963053 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 307 | ETA | PO02.04.0388 | 0388 | yes
13843172 | 1.NP_SO-101 | 181.052 | 0.04908 | 0.142198 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 311 | ETA | PO02.04.0389 | 0389 | yes
13843866 | 1.NP_SO-101 | 328.612 | 0.04908 | 0.258091 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3005 | 2880 | 2880 | 2755 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 269 | SUP | PO02.04.0390 | 0390 | yes
13844021 | 3.NP_SO-101 | 1216.81 | 0.0201032 | 0.611635 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 3.NP_SO-101 | 2950.97 | 1734.16 | 2950.97 | 1734.16 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 326 | SUP | PO02.04.0391 | 0391 | yes
13907116 | 1.NP_SO-101 | 1058.58 | 0.04908 | 0.831405 | 250 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.0108942 | 0.0102914 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.157159 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 326 | ETA | PO02.04.0421 | 0421 | yes
13907188 | 1.NP_SO-101 | 1128.91 | 0.04908 | 0.886647 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 307 | ETA | PO02.04.0422 | 0422 | yes
13907425 | 1.NP_SO-101 | 58.3435 | 0.04908 | 0.0458229 | 250 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.000600434 | 0.0102914 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.00866184 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 326 | ETA | PO02.04.0423 | 0423 | yes
13908775 | 3.NP_SO-101 | 3577.24 | 0.04908 | 2.80956 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3235.97 | 3110.97 | 3110.97 | 2985.97 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 43 | 319 | SUP | PO02.04.0425 | 0425 | no
13926230 | -1.PP_SO-101 | 580.027 | 0.0397548 | 0.409997 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2562.5 | 2450 | 2450 | 2337.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 307 | SUP | PO02.04.0456 | 0456 | yes
13926269 | -1.PP_SO-101 | 943.165 | 0.0397548 | 0.666684 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2512.5 | 2400 | 2400 | 2287.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 351 | ETA | PO02.04.0457 | 0457 | yes
13926595 | -1.PP_SO-101 | 169.822 | 0.0397548 | 0.12004 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2512.5 | 2400 | 2400 | 2287.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 351 | ETA | PO02.04.0458 | 0458 | yes
13926752 | -1.PP_SO-101 | 169.822 | 0.0397548 | 0.12004 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2562.5 | 2450 | 2450 | 2337.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 307 | SUP | PO02.04.0459 | 0459 | yes
13926914 | -1.PP_SO-101 | 2286.8 | 0.0397548 | 1.61645 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2512.5 | 2400 | 2400 | 2287.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 409 | ETA | PO02.04.0460 | 0460 | yes
13927001 | -1.PP_SO-101 | 340.662 | 0.0397548 | 0.240799 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2562.5 | 2450 | 2450 | 2337.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 307 | SUP | PO02.04.0461 | 0461 | yes
13937879 | 3.NP_SO-101 | 4831.99 | 0.0779194 | 4.78174 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 3268.47 | 3110.97 | 3110.97 | 2953.47 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 43 | 208 | SUP | PO02.04.0507 | 0507 | yes
13959121 | 1.NP_SO-101 | 1545.21 | 0.04908 | 1.2136 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3005 | 2880 | 2880 | 2755 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 269 | SUP | PO02.04.0516 | 0516 | yes
13959132 | 1.NP_SO-101 | 598.995 | 0.04908 | 0.47045 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | 1.NP_SO-101 | 3465.17 | 2953.22 | 3376.78 | 2864.83 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 269 | SUP | PO02.04.0517 | 0517 | yes
13959873 | 1.NP_SO-101 | 511.897 | 0.04908 | 0.402043 | 250 mm | 8413.18 | 0.155969 | 0.025 | 0.509296 | 0.0106854 | 0.0208741 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.0685096 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 401 | ETA | PO02.04.0518 | 0518 | yes
13960493 | 1.NP_SO-101 | 782.611 | 0.04908 | 0.614661 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 450 | ETA | PO02.04.0521 | 0521 | yes
13961186 | 1.NP_SO-101 | 4627.41 | 0.04908 | 3.63436 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3445 | 3320 | 3320 | 3195 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0524 | 0524 | yes
13964887 | -1.PP_SO-101 | 394.925 | 0.04908 | 0.310173 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2575 | 2450 | 2450 | 2325 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 328 | SUP | PO02.04.0530 | 0530 | yes
13964898 | -1.PP_SO-101 | 57.9363 | 0.04908 | 0.0455031 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2465.17 | 2376.78 | 2335.81 | 2247.42 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 328 | SUP | PO02.04.0531 | 0531 | yes
13970301 | 1.NP_SO-101 | 187.674 | 0.04908 | 0.147399 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 337 | SUP | PO02.04.0546 | 0546 | yes
13970306 | 1.NP_SO-101 | 105.479 | 0.04908 | 0.0828427 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 338 | SUP | PO02.04.0547 | 0547 | yes
13970328 | 1.NP_SO-101 | 316.152 | 0.04908 | 0.248305 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | 1.NP_SO-101 | 3265.17 | 3176.78 | 2953.22 | 2864.83 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 27 | 338 | SUP | PO02.04.0549 | 0549 | yes
13970508 | 1.NP_SO-101 | 376.542 | 0.04908 | 0.295735 | 250 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.00387513 | 0.0102914 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0.0559025 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 297 | ETA | PO02.04.0550 | 0550 | yes
14001944 | -1.PP_SO-101 | 2286.8 | 0.0397548 | 1.61645 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2562.5 | 2450 | 2450 | 2337.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 348 | SUP | PO02.04.0559 | 0559 | yes
14002210 | -1.PP_SO-101 | 1991.2 | 0.0397548 | 1.40749 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2712.5 | 2600 | 2600 | 2487.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 348 | SUP | PO02.04.0560 | 0560 | yes
14002221 | -1.PP_SO-101 | 25.7359 | 0.0397548 | 0.0181917 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2613.65 | 2534.1 | 2515.9 | 2436.35 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 348 | SUP | PO02.04.0561 | 0561 | yes
14002259 | -1.PP_SO-101 | 2191.73 | 0.0397548 | 1.54924 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2712.5 | 2600 | 2600 | 2487.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 409 | ETA | PO02.04.0562 | 0562 | yes
14002270 | -1.PP_SO-101 | 96.4466 | 0.0397548 | 0.0681741 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2613.65 | 2534.1 | 2465.9 | 2386.35 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 409 | ETA | PO02.04.0563 | 0563 | yes
14004122 | -1.PP_SO-101 | 740.904 | 0.0397548 | 0.523714 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2712.5 | 2600 | 2600 | 2487.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 356 | SUP | PO02.04.0568 | 0568 | yes | Identifikační data - Komentáře: VEDENO DO 1.NP
14004196 | -1.PP_SO-101 | 745.756 | 0.0397548 | 0.527144 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2712.5 | 2600 | 2600 | 2487.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 412 | ETA | PO02.04.0569 | 0569 | yes
14031024 | -1.PP_SO-101 | 34.3629 | 0.0201032 | 0.0172727 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0584 | 0584 | yes | Identifikační data - Komentáře: POD STROPEM
14044332 | -1.PP_SO-101 | 395.934 | 0.0201032 | 0.199018 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2730 | 2650 | 2650 | 2570 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.04.0609 | 0609 | yes
14044339 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2659.71 | 2603.14 | 2496.86 | 2440.29 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.04.0610 | 0610 | yes
14044407 | -1.PP_SO-101 | 964.77 | 0.0201032 | 0.484946 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2730 | 2650 | 2650 | 2570 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.04.0611 | 0611 | yes
14044458 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2659.71 | 2603.14 | 2496.86 | 2440.29 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.04.0613 | 0613 | yes
14044498 | -1.PP_SO-101 | 166.58 | 0.0201032 | 0.0837323 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2730 | 2650 | 2650 | 2570 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0614 | 0614 | yes
14044505 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2659.71 | 2603.14 | 2496.86 | 2440.29 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0615 | 0615 | yes
14044548 | -1.PP_SO-101 | 934.509 | 0.0201032 | 0.469735 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 2730 | 2650 | 2650 | 2570 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0616 | 0616 | yes
14044622 | -1.PP_SO-101 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | -1.PP_SO-101 | 2659.71 | 2603.14 | 2496.86 | 2440.29 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 362 | SUP | PO02.04.0617 | 0617 | yes
14057012 | 2.NP_SO-101 | 1589.67 | 0.0201032 | 0.799053 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 |  | 2.NP_SO-101 | 5149.67 | 5149.67 | 3560 | 3560 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 195 | SUP | PO02.04.0645 | 0645 | yes
14071500 | 1.NP_SO-101 | 840 | 0.04908 | 0.659734 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3445 | 3320 | 3320 | 3195 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0690 | 0690
14072171 | 1.NP_SO-101 | 406.025 | 0.04908 | 0.318892 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 57.735 | 1.NP_SO-101 | 3394.76 | 3083.49 | 3286.51 | 2975.24 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0697 | 0697
14072185 | 1.NP_SO-101 | 329.808 | 0.04908 | 0.25903 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3175 | 3050 | 3050 | 2925 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0698 | 0698
14074921 | 1.NP_SO-101 | 396.198 | 0.04908 | 0.311173 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 450 | ETA | PO02.04.0701 | 0701
14074931 | 1.NP_SO-101 | 116.501 | 0.04908 | 0.0914995 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 450 | ETA | PO02.04.0702 | 0702
14075567 | 1.NP_SO-101 | 786.447 | 0.04908 | 0.617674 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3445 | 3320 | 3320 | 3195 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0705 | 0705
14075577 | 1.NP_SO-101 | 3.10112 | 0.04908 | 0.00243561 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3275 | 3150 | 3150 | 3025 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 453 | ETA | PO02.04.0706 | 0706
14075617 | 1.NP_SO-101 | 63.6755 | 0.04908 | 0.0500106 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3275 | 3150 | 3150 | 3025 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0707 | 0707
14075697 | 1.NP_SO-101 | 376.648 | 0.04908 | 0.295818 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3275 | 3150 | 3150 | 3025 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 453 | ETA | PO02.04.0708 | 0708
14075750 | 1.NP_SO-101 | 3.10112 | 0.04908 | 0.00243561 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3275 | 3150 | 3150 | 3025 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0709 | 0709
14076166 | 1.NP_SO-101 | 33.3095 | 0.04908 | 0.0261612 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 100 | 1.NP_SO-101 | 3335.17 | 3223.22 | 3246.78 | 3134.83 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0710 | 0710
14076184 | 1.NP_SO-101 | 22.8932 | 0.04908 | 0.0179803 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 3275 | 3150 | 3150 | 3025 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.04.0711 | 0711

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 2848.71 m2; Hrubý objem: 10412.3 m3; Obsazená plocha: 2848.71 m2; Obsazený objem: 10412.3 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
