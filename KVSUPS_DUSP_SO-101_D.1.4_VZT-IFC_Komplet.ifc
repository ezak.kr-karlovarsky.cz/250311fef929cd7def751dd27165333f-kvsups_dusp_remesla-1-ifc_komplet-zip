Properties of the parts of a building model (IFC4), part 17 of 21

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (43)
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířka odsazení od základny (mm) | Délka01 (mm) | Delta 1 (mm) | Delta 2 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Délka 4 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 | Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Polovina Š0 (mm)
13843705 | 1.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0311 | 0311 | yes | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13904835 | 2.NP_SO-101 | 180 mm × 180 mm-160 mm | 0 | 2.NP_SO-101 | 4270.2 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 3048 | 24.1421 | 10 | 10 | -0.025 | 0.025 | 0.000654302 | 90 | 90 | 0.0230465 | 80 | 160 | 180 | 180 × 180-160 | 180 | TA00.05.0336 | 0336 | yes | 0 | 0 | 0.4 | 0.965685 | 0.4 | 0.8 | 0.965685 | 0.4 | 0.4 | 0.8 | 10 | 10 | 10 | 10 | 24.1421 | 24.1421 | 90
13904850 | 2.NP_SO-101 | 180 mm × 180 mm-160 mm | 0 | 2.NP_SO-101 | 4270.2 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 3048 | 24.1421 | 10 | 10 | -0.025 | 0.025 | 0.000654302 | 90 | 90 | 0.0230465 | 80 | 160 | 180 | 180 × 180-160 | 180 | TA00.05.0337 | 0337 | yes | 0 | 0 | 0.4 | 0.965685 | 0.4 | 0.8 | 0.965685 | 0.4 | 0.4 | 0.8 | 10 | 10 | 10 | 10 | 24.1421 | 24.1421 | 90
13905276 | 1.NP_SO-101 | 180 mm × 180 mm-160 mm | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 3048 | 24.1421 | 10 | 10 | -0.025 | 0.025 | 0.000654302 | 90 | 90 | 0.0230465 | 80 | 160 | 180 | 180 × 180-160 | 180 | TA00.05.0338 | 0338 | yes | 0 | 0 | 0.4 | 0.965685 | 0.4 | 0.8 | 0.965685 | 0.4 | 0.4 | 0.8 | 10 | 10 | 10 | 10 | 24.1421 | 24.1421 | 90
13905302 | 1.NP_SO-101 | 180 mm × 180 mm-160 mm | 0 | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 3048 | 24.1421 | 10 | 10 | -0.025 | 0.025 | 0.000654302 | 90 | 90 | 0.0230465 | 80 | 160 | 180 | 180 × 180-160 | 180 | TA00.05.0339 | 0339 | yes | 0 | 0 | 0.4 | 0.965685 | 0.4 | 0.8 | 0.965685 | 0.4 | 0.4 | 0.8 | 10 | 10 | 10 | 10 | 24.1421 | 24.1421 | 90
13917231 | 4.NP_SO-101 | 280 mm × 280 mm-315 mm | 0 | 4.NP_SO-101 | 3720 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 42.2487 | 17.5 | 17.5 | -0.0388889 | 0.0388889 | 0.00344371 | 140 | 140 | 0.0705798 | 157.5 | 315 | 280 | 280 × 280-315 | 280 | TA00.05.0361 | 0361 | yes | 0 | 0 | 0.7 | 1.68995 | 0.7 | 1.4 | 1.68995 | 0.7 | 0.7 | 1.4 | 17.5 | 17.5 | 17.5 | 17.5 | 42.2487 | 42.2487 | 140
13918889 | 2.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0363 | 0363 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13924524 | -1.PP_SO-101 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-101 | 2100 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0376 | 0376 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13932118 | 2.NP_SO-101 | 300 mm × 600 mm-355 mm |  | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 3048 | 295.741 | 27.5 | 122.5 | -0.0416667 | 0.0833333 | 0.0432502 | 150 | 300 | 0.318873 | 177.5 | 355 | 300 | 300 × 600-355 | 600 | TA00.05.0416 | 0416 | yes | 0 | 0 | 1.1 | 11.8296 | 1.1 | 2.2 | 2.65563 | 4.9 | 4.9 | 9.8 | 27.5 | 27.5 | 122.5 | 122.5 | 295.741 | 66.3909 | 150
13932949 | 4.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0420 | 0420 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
13972703 | 1.NP_SO-101 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-101 | 3155 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 3048 | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 315 | 315 × 315-315 | 315 | TA00.05.0507 | 0507 | yes | 0 | 0.0000461902 | 0 | 0 | 0 | 0 | 0 | 0.00000184761 | -0.00000184761 | 0 | 0 | 0 | 0.0000461902 | -0.0000461902 | 0 | 0 | 157.5
13999400 | 2.NP_SO-101 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-101 | 3225 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 3048 | 102.604 | 32.5 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0514 | 0514 | no | 0 | 0 | 1.3 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 32.5 | 32.5 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5
14000406 | 4.NP_SO-101 | 160 mm × 160 mm-160 mm | 0 | 4.NP_SO-101 | 7275 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 3048 | 40 | 0 | 0 | -0.0222222 | 0.0222222 | 0.000950749 | 80 | 80 | 0.0256 | 80 | 160 | 160 | 160 × 160-160 | 160 | TA00.05.0526 | 0526 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 80
14000613 | 4.NP_SO-101 | 160 mm × 160 mm-160 mm | 0 | 4.NP_SO-101 | 3575 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 3048 | 40 | 0 | 0 | -0.0222222 | 0.0222222 | 0.000950749 | 80 | 80 | 0.0256 | 80 | 160 | 160 | 160 × 160-160 | 160 | TA00.05.0528 | 0528 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 80
14004350 | -1.PP_SO-101 | 280 mm × 150 mm-225 mm | 0 | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 90.533 | 27.5 | 37.5 | -0.0388889 | 0.0208333 | 0.00392719 | 140 | 75 | 0.0643154 | 112.5 | 225 | 280 | 280 × 150-225 | 150 | TA00.05.0579 | 0579 | yes | 0 | 0 | 1.1 | 3.62132 | 1.1 | 2.2 | 2.65563 | 1.5 | 1.5 | 3 | 27.5 | 27.5 | 37.5 | 37.5 | 90.533 | 66.3909 | 140
14004441 | -1.PP_SO-101 | 280 mm × 150 mm-225 mm | 0 | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 3048 | 90.533 | 27.5 | 37.5 | -0.0388889 | 0.0208333 | 0.00392719 | 140 | 75 | 0.0643154 | 112.5 | 225 | 280 | 280 × 150-225 | 150 | TA00.05.0582 | 0582 | yes | 0 | 0 | 1.1 | 3.62132 | 1.1 | 2.2 | 2.65563 | 1.5 | 1.5 | 3 | 27.5 | 27.5 | 37.5 | 37.5 | 90.533 | 66.3909 | 140
14004573 | -1.PP_SO-101 | 280 mm × 150 mm-225 mm | 0 | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3075.5 | 90.533 | 27.5 | 37.5 | -0.0465278 | 0.0208333 | 0.00392719 | 167.5 | 75 | 0.0650372 | 112.5 | 225 | 280 | 280 × 150-225 | 150 | TA00.05.0585 | 0585 | yes | 27.5 | 0 | 2.2 | 3.62132 | 0 | 2.2 | 2.2 | 1.5 | 1.5 | 3 | 55 | 0 | 37.5 | 37.5 | 90.533 | 55 | 140
14049136 | 1.NP_SO-101 | 180 mm × 355 mm-200 mm | 0 | 1.NP_SO-101 | 3238.39 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 3048 | 187.102 | 10 | 77.5 | -0.025 | 0.0493056 | 0.00928123 | 90 | 177.5 | 0.114947 | 100 | 200 | 180 | 180 × 355-200 | 355 | TA00.05.0670 | 0670 | yes | 0 | 0 | 0.4 | 7.48406 | 0.4 | 0.8 | 0.965685 | 3.1 | 3.1 | 6.2 | 10 | 10 | 77.5 | 77.5 | 187.102 | 24.1421 | 90
14054625 | 3.NP_SO-101 | 315 mm × 250 mm-180 mm | 0.907963 | 3.NP_SO-101 | 3392.96 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 162.959 | 67.5 | 35 | -0.04375 | 0.0347222 | 0.00842212 | 157.5 | 125 | 0.105059 | 90 | 180 | 315 | 315 × 250-180 | 250 | TA00.05.0687 | 0687 | yes | 0 | 0 | 2.7 | 3.3799 | 2.7 | 5.4 | 6.51838 | 1.4 | 1.4 | 2.8 | 67.5 | 67.5 | 35 | 35 | 84.4975 | 162.959 | 157.5
14055553 | -1.PP_SO-101 | 180 mm × 160 mm-180 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 3048 | 24.1421 | 0 | 10 | -0.025 | 0.0222222 | 0.000682795 | 90 | 80 | 0.0239288 | 90 | 180 | 180 | 180 × 160-180 | 160 | TA00.05.0700 | 0700 | yes | 0 | 0 | 0 | 0.965685 | 0 | 0 | 0 | 0.4 | 0.4 | 0.8 | 0 | 0 | 10 | 10 | 24.1421 | 0 | 90
14063567 | 4.NP_SO-101 | 500 mm × 400 mm-400 mm | 0 | 4.NP_SO-101 | 3887.49 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 120.711 | 50 | 0 | -0.0694444 | 0.0555556 | 0.0203463 | 250 | 200 | 0.194593 | 200 | 400 | 500 | 500 × 400-400 | 400 | TA00.05.0731 | 0731 |  | 0 | 0 | 2 | 0 | 2 | 4 | 4.82843 | 0 | 0 | 0 | 50 | 50 | 0 | 0 | 0 | 120.711 | 250
14067495 | 4.NP_SO-101 | 280 mm × 280 mm-315 mm | 0 | 4.NP_SO-101 | 3720 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 42.2487 | 17.5 | 17.5 | -0.0388889 | 0.0388889 | 0.00344371 | 140 | 140 | 0.0705798 | 157.5 | 315 | 280 | 280 × 280-315 | 280 | TA00.05.0748 | 0748 |  | 0 | 0 | 0.7 | 1.68995 | 0.7 | 1.4 | 1.68995 | 0.7 | 0.7 | 1.4 | 17.5 | 17.5 | 17.5 | 17.5 | 42.2487 | 42.2487 | 140
14069022 | 4.NP_SO-101 | 250 mm × 280 mm-280 mm |  | 4.NP_SO-101 | 3840 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 36.2132 | 15 | 0 | -0.0347222 | 0.0388889 | 0.00248393 | 125 | 140 | 0.0572539 | 140 | 280 | 250 | 250 × 280-280 | 280 | TA00.05.0757 | 0757 |  | 0.00011078 | 0.00011078 | 0.600004 | 0 | 0.599996 | 1.2 | 1.44853 | 0.00000443119 | -0.00000443119 | 0 | 15.0001 | 14.9999 | 0.00011078 | -0.00011078 | 0 | 36.2132 | 125
14076842 | -1.PP_SO-101 | 200 mm × 125 mm-160 mm |  | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 15 | ETA | 3048 | 48.2843 | 20 | 17.5 | -0.0277778 | 0.0173611 | 0.00114444 | 100 | 62.5 | 0.0287817 | 80 | 160 | 200 | 200 × 125-160 | 125 | TA00.05.0810 | 0810 |  | 0 | 0 | 0.8 | 1.68995 | 0.8 | 1.6 | 1.93137 | 0.7 | 0.7 | 1.4 | 20 | 20 | 17.5 | 17.5 | 42.2487 | 48.2843 | 100
14079669 | 1.NP_SO-101 | 200 mm × 125 mm-160 mm | 0 | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 3048 | 48.2843 | 20 | 17.5 | -0.0277778 | 0.0173611 | 0.00114444 | 100 | 62.5 | 0.0287817 | 80 | 160 | 200 | 200 × 125-160 | 125 | TA00.05.0814 | 0814 |  | 0 | 0 | 0.8 | 1.68995 | 0.8 | 1.6 | 1.93137 | 0.7 | 0.7 | 1.4 | 20 | 20 | 17.5 | 17.5 | 42.2487 | 48.2843 | 100
14080167 | 2.NP_SO-101 | 200 mm × 125 mm-100 mm | 0 | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 3048 | 120.711 | 50 | 12.5 | -0.0277778 | 0.0173611 | 0.00197579 | 100 | 62.5 | 0.0410444 | 50 | 100 | 200 | 200 × 125-100 | 125 | TA00.05.0816 | 0816 |  | 0 | 0 | 2 | 1.20711 | 2 | 4 | 4.82843 | 0.5 | 0.5 | 1 | 50 | 50 | 12.5 | 12.5 | 30.1777 | 120.711 | 100
14080764 | 3.NP_SO-101 | 250 mm-200 mm × 125 mm | 0 | 3.NP_SO-101 | 3445 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 3048 | 150.888 | 25 | 62.5 | -0.0277778 | 0.0173611 | 0.00576959 | 100 | 62.5 | 0.0857079 | 125 | 250 | 200 | 250-200 × 125 | 125 | TA00.05.0822 | 0822 |  | 0 | 0 | 1 | 6.03553 | 1 | 2 | 2.41421 | 2.5 | 2.5 | 5 | 25 | 25 | 62.5 | 62.5 | 150.888 | 60.3553 | 100
14080979 | -1.PP_SO-101 | 180 mm × 125 mm-160 mm | 0 | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 3048 | 42.2487 | 10 | 17.5 | -0.025 | 0.0173611 | 0.000943642 | 90 | 62.5 | 0.0256068 | 80 | 160 | 180 | 180 × 125-160 | 125 | TA00.05.0824 | 0824 |  | 0 | 0 | 0.4 | 1.68995 | 0.4 | 0.8 | 0.965685 | 0.7 | 0.7 | 1.4 | 10 | 10 | 17.5 | 17.5 | 42.2487 | 24.1421 | 90

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (8)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 01; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | a (mm) = c (mm) = Výš. (mm) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) = Max cd (mm) | Max bd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13739175 | -1.PP_SO-101 | 630 | 0.02475 | 0.6363 | 450 mm × 630 mm-355 mm × 630 mm | -1.PP_SO-101 | 1900.01 | SUP 1 | 90 | 630 | 450 | 355 | 0.152614 | 690 | 510 | 415 | 450 × 630-355 × 630 | TA00.01.0204 | 0204 | yes | 90 | 0 | 0 | 0 | 0 | 10277.5 | 50 | 5 | 505 | 600 | 713.81 | 455 | 325 | 455 | 455 | 355 | 555 | 277.5 | 325 | 47.5 | 10000 | 325 | 327.5 | 630 | 630 | 450 | 225 | 455 | 955 | 875
13739399 | -1.PP_SO-101 |  |  |  | 400 mm × 560 mm-355 mm × 560 mm | -1.PP_SO-101 | 2262.59 | SUP 27 | 45 | 560 | 400 | 355 | 0.0718785 | 620 | 460 | 415 | 400 × 560-355 × 560 | TA00.01.0205 | 0205 | yes | 135 | 35.3553 | 3.53553 | 178.266 | 196.222 | 10092.4 | 35.3553 | 3.53553 | 550 | 403.553 | 367.82 | 321.734 | 300 | 143.467 | 346.36 | 355 | 555 | 277.5 | 124.264 | 22.5 | 9896.22 | 146.764 | 142.444 | 560 | 560 | 400 | 200 | 143.467 | 846.36 | 800
13739406 | -1.PP_SO-101 | 355 | 0.03465 | 0.48635 | 630 mm × 355 mm-630 mm × 355 mm | -1.PP_SO-101 | 1900.01 | SUP 1 | 90 | 355 | 630 | 630 | 0.170395 | 415 | 690 | 690 | 630 × 355-630 × 355 | TA00.01.0207 | 0207 | yes | 90 | 0 | 0 | 0 | 0 | 10415 | 50 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 415 | 465 | 630 | 630 | 630 | 315 | 730 | 1230 | 1145
13739407 | -1.PP_SO-101 | 630 | 0.019525 | 0.5166 | 355 mm × 630 mm-355 mm × 630 mm | -1.PP_SO-101 | 1900 | SUP 1 | 45 | 630 | 355 | 355 | 0.0733453 | 690 | 415 | 415 | 355 × 630-355 × 630 | TA00.01.0208 | 0208 | yes | 135 | 35.3553 | 3.53553 | 133.266 | 196.222 | 10114.9 | 35.3553 | 3.53553 | 505 | 371.734 | 348.242 | 321.734 | 277.5 | 188.467 | 455 | 355 | 555 | 277.5 | 114.944 | 0 | 9918.72 | 114.944 | 164.944 | 630 | 630 | 355 | 177.5 | 188.467 | 955 | 732.5
13849551 | 4.NP_SO-101 | 400 | 0.03465 | 0.548 | 1000 mm × 400 mm-630 mm × 400 mm | 4.NP_SO-101 | 1270.11 | SUP 43 | 90 | 400 | 630 | 1000 | 0.308173 | 460 | 690 | 1060 | 1000 × 400-630 × 400 | TA00.01.0319 | 0319 | yes | 90 | 0 | 0 | 0 | 0 | 10600 | 50 | 5 | 1150 | 780 | 1320.19 | 1100 | 415 | 730 | 730 | 630 | 1200 | 600 | 415 | -185 | 10000 | 415 | 650 | 630 | 1000 | 1000 | 315 | 1100 | 1230 | 1515
13999279 | 3.NP_SO-101 | 315 | 0.0154 | 0.21105 | 280 mm × 315 mm-158 mm × 315 mm | 3.NP_SO-101 | 3110.97 | SUP 43 | 90 | 315 | 280 | 157.5 | 0.0314463 | 375 | 340 | 217.5 | 280 × 315-158 × 315 | TA00.01.0510 | 0510 | yes | 90 | 0 | 0 | 0 | 0 | 10178.8 | 50 | 5 | 307.5 | 430 | 459.028 | 257.5 | 240 | 257.5 | 257.5 | 157.5 | 357.5 | 178.75 | 240 | 61.25 | 10000 | 240 | 228.75 | 315 | 315 | 280 | 140 | 257.5 | 757.5 | 620
14074249 | -1.PP_SO-101 | 400 | 0.01375 | 0.244 | 560 mm × 400 mm-250 mm × 400 mm | -1.PP_SO-101 | 2262.59 | SUP 27 | 90 | 400 | 250 | 560 | 0.0965629 | 460 | 310 | 620 | 560 × 400-250 × 400 | TA00.01.0788 | 0788 |  | 90 | 0 | 0 | 0 | 0 | 10380 | 50 | 5 | 710 | 400 | 747.061 | 660 | 225 | 350 | 350 | 250 | 760 | 380 | 225 | -155 | 10000 | 225 | 430 | 400 | 560 | 560 | 125 | 660 | 850 | 885 | Mechanické – tok - Tlaková ztráta: 0 Pa
14074251 | -1.PP_SO-101 | 560 | 0.022 | 0.5096 | 400 mm × 560 mm-400 mm × 560 mm | -1.PP_SO-101 | 2262.59 | SUP 27 | 90 | 560 | 400 | 400 | 0.130197 | 620 | 460 | 460 | 400 × 560-400 × 560 | TA00.01.0789 | 0789 |  | 90 | 0 | 0 | 0 | 0 | 10300 | 50 | 5 | 550 | 550 | 707.107 | 500 | 300 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 300 | 350 | 560 | 560 | 400 | 200 | 500 | 1000 | 800 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (13)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 01; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) = a (mm) = c (mm) = Výš. (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 5 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) = Délka 8 (mm) | Délka 6 (mm) | Délka 9 (mm) | Max ab (mm) = Max abcd (mm) = Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13826681 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 3100 | Čerstvý | Přívod vzduchu | ODA 11 | ODA | 90 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0249 | 0249 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13826685 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 3100 | Čerstvý | Přívod vzduchu | ODA 11 | ODA | 90 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0251 | 0251 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13827293 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 2500 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 90 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0254 | 0254 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13827762 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 2750 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 90 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0259 | 0259 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14000329 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-101 | 7275 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 90 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0524 | 0524 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14032209 | -1.PP_SO-101 | 315 | 0.0308 | 0.38745 | 560 mm × 315 mm-560 mm × 315 mm | -1.PP_SO-101 | 2440 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 45 | 560 | 560 | 0.0720507 | 375 | 620 | 620 | 560 × 315-560 × 315 | TA00.01.0603 | 0603 | yes | 135 | 35.3553 | 3.53553 | 193.31 | 0 | 268.701 | 10157.4 | 35.3553 | 3.53553 | 710 | 516.69 | 505.142 | 466.69 | 380 | 273.381 | 660 | 560 | 760 | 380 | 157.401 | 9888.7 | 207.401 | 560 | 560 | 280 | 273.381 | 1160 | 1040
14032285 | -1.PP_SO-101 | 315 | 0.0308 | 0.38745 | 560 mm × 315 mm-560 mm × 315 mm | -1.PP_SO-101 | 2440 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 560 | 560 | 0.124698 | 375 | 620 | 620 | 560 × 315-560 × 315 | TA00.01.0605 | 0605 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10380 | 50 | 5 | 710 | 710 | 933.381 | 660 | 380 | 660 | 660 | 560 | 760 | 380 | 380 | 10000 | 430 | 560 | 560 | 280 | 660 | 1160 | 1040
14034908 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 560 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 1300 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 315 | 560 | 0.155238 | 620 | 375 | 620 | 560 × 560-315 × 560 | TA00.01.0618 | 0618 | yes | 90 | 0 | 0 | 0 | -122.5 | 0 | 10380 | 50 | 5 | 710 | 465 | 779.631 | 660 | 257.5 | 415 | 415 | 315 | 760 | 380 | 257.5 | 10000 | 430 | 560 | 560 | 157.5 | 660 | 915 | 917.5
14034914 | -1.PP_SO-101 | 315 | 0.0308 | 0.38745 | 560 mm × 315 mm-560 mm × 315 mm | -1.PP_SO-101 | 2440 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 45 | 560 | 560 | 0.0720507 | 375 | 620 | 620 | 560 × 315-560 × 315 | TA00.01.0620 | 0620 | yes | 135 | 35.3553 | 3.53553 | 193.31 | 0 | 268.701 | 10157.4 | 35.3553 | 3.53553 | 710 | 516.69 | 505.142 | 466.69 | 380 | 273.381 | 660 | 560 | 760 | 380 | 157.401 | 9888.7 | 207.401 | 560 | 560 | 280 | 273.381 | 1160 | 1040
14057710 | 4.NP_SO-101 | 710 | 0.03905 | 1.0863 | 710 mm × 710 mm-710 mm × 710 mm | 4.NP_SO-101 | 2061.74 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 88.1629 | 710 | 710 | 0.408382 | 770 | 770 | 770 | 710 × 710-710 × 710 | TA00.01.0704 | 0704 |  | 91.8371 | 1.60293 | 0.160293 | 25.1479 | 0 | 14.5867 | 10440.6 | 49.9743 | 4.99743 | 25303.2 | 859.584 | 1127 | 809.584 | 455 | 784.436 | 810 | 710 | 910 | 455 | 440.64 | 9985.87 | 490.64 | 710 | 710 | 355 | 784.436 | 1310 | 1265
14068415 | 4.NP_SO-101 | 710 | 0.03905 | 1.0863 | 710 mm × 710 mm-400 mm × 710 mm | 4.NP_SO-101 | 965 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 710 | 400 | 0.287227 | 770 | 770 | 460 | 710 × 710-400 × 710 | TA00.01.0751 | 0751 |  | 90 | 0 | 0 | 0 | 155 | 0 | 10300 | 50 | 5 | 550 | 860 | 951.893 | 500 | 455 | 500 | 500 | 400 | 600 | 300 | 455 | 10000 | 350 | 710 | 710 | 355 | 500 | 1000 | 1265
14068418 | 4.NP_SO-101 | 400 | 0.0308 | 0.492 | 560 mm × 400 mm-560 mm × 400 mm | 4.NP_SO-101 | 965 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 560 | 560 | 0.158347 | 460 | 620 | 620 | 560 × 400-560 × 400 | TA00.01.0753 | 0753 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10380 | 50 | 5 | 710 | 710 | 933.381 | 660 | 380 | 660 | 660 | 560 | 760 | 380 | 380 | 10000 | 430 | 560 | 560 | 280 | 660 | 1160 | 1040
14068507 | 4.NP_SO-101 | 450 | 0.0605 | 1.0395 | 1100 mm × 450 mm-560 mm × 450 mm | 4.NP_SO-101 | 1034 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 1100 | 560 | 0.351884 | 510 | 1160 | 620 | 1100 × 450-560 × 450 | TA00.01.0754 | 0754 |  | 90 | 0 | 0 | 0 | 270 | 0 | 10380 | 50 | 5 | 710 | 1250 | 1369.53 | 660 | 650 | 660 | 660 | 560 | 760 | 380 | 650 | 10000 | 430 | 1100 | 560 | 550 | 660 | 1160 | 1850

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (27)
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 01; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; Id typu: 1165284; r1: 100 mm; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Šířka 2: 200 mm; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) = a (mm) = c (mm) = Výš. (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 1 (mm) | Délka 10 (mm) | Délka 11 (mm) | Délka 12 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) = Délka 8 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm) | Tlaková ztráta (Pa)
12981197 | 4.NP_SO-101 | 710 | 0.03465 | 0.9727 | 630 mm × 710 mm-630 mm × 710 mm | 4.NP_SO-101 | 800 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 630 | 630 | 0.340791 | 770 | 690 | 690 | 630 × 710-630 × 710 | TA00.01.0001 | 0001 | yes | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 0 | 465 | 710 | 710 | 630 | 710 | 315 | 730 | 1230 | 1145
13518843 | 4.NP_SO-101 | 710 | 0.03465 | 0.9727 | 630 mm × 710 mm-630 mm × 710 mm | 4.NP_SO-101 | 2030 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 630 | 630 | 0.340791 | 770 | 690 | 690 | 630 × 710-630 × 710 | TA00.01.0089 | 0089 | yes | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 0 | 465 | 710 | 710 | 630 | 710 | 315 | 730 | 1230 | 1145
13519190 | 4.NP_SO-101 | 500 | 0.019525 | 0.41 | 710 mm × 500 mm-355 mm × 500 mm | 4.NP_SO-101 | 800 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 355 | 710 | 0.187421 | 560 | 415 | 770 | 710 × 500-355 × 500 | TA00.01.0090 | 0090 | yes | 90 | 10455 | 0 | 50 | 0 | 5 | 860 | 505 | 929.045 | 810 | 277.5 | 0 | 455 | 455 | 355 | 910 | 455 | 277.5 | -177.5 | 10000 | 0 | 505 | 500 | 710 | 710 | 710 | 177.5 | 810 | 955 | 1087.5
13519202 | 4.NP_SO-101 | 500 | 0.019525 | 0.41 | 355 mm × 500 mm-355 mm × 500 mm | 4.NP_SO-101 | 800 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 355 | 355 | 0.0968961 | 560 | 415 | 415 | 355 × 500-355 × 500 | TA00.01.0091 | 0091 | yes | 90 | 10277.5 | 0 | 50 | 0 | 5 | 505 | 505 | 643.467 | 455 | 277.5 | 0 | 455 | 455 | 355 | 555 | 277.5 | 277.5 | 0 | 10000 | 0 | 327.5 | 500 | 500 | 355 | 500 | 177.5 | 455 | 955 | 732.5
13519409 | 4.NP_SO-101 | 355 | 0.0275 | 0.39405 | 500 mm × 355 mm-500 mm × 355 mm | 4.NP_SO-101 | 504 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 45 | 500 | 500 | 0.0683178 | 415 | 560 | 560 | 500 × 355-500 × 355 | TA00.01.0092 | 0092 | yes | 135 | 10145 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 650 | 474.264 | 459.22 | 424.264 | 350 | 175.736 | 248.528 | 600 | 500 | 700 | 350 | 144.975 | 0 | 9897.49 | 247.487 | 194.975 | 500 | 500 | 500 | 500 | 250 | 248.528 | 1100 | 950
13519426 | 4.NP_SO-101 | 355 | 0.0275 | 0.39405 | 500 mm × 355 mm-500 mm × 355 mm | 4.NP_SO-101 | 800 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 45 | 500 | 500 | 0.0683178 | 415 | 560 | 560 | 500 × 355-500 × 355 | TA00.01.0093 | 0093 | yes | 135 | 10145 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 650 | 474.264 | 459.22 | 424.264 | 350 | 175.736 | 248.528 | 600 | 500 | 700 | 350 | 144.975 | 0 | 9897.49 | 247.487 | 194.975 | 500 | 500 | 500 | 500 | 250 | 248.528 | 1100 | 950
13737470 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 1930.15 | Znehodnocený | Odváděný vzduch | EHA 3 | EHA | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.01.0196 | 0196 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5 | 0
13760037 | -1.PP_SO-101 | 560 | 0.0275 | 0.6216 | 500 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 600 | Znehodnocený | Odváděný vzduch | EHA 3 | EHA | 90 | 500 | 315 | 0.139446 | 620 | 560 | 375 | 500 × 560-315 × 560 | TA00.01.0214 | 0214 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 650 | 729.538 | 415 | 350 | 0 | 415 | 415 | 315 | 515 | 257.5 | 350 | 92.5 | 10000 | 0 | 307.5 | 560 | 560 | 500 | 560 | 250 | 415 | 915 | 950 | 0
13827268 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 2500 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0253 | 0253 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5 | 0
13827502 | 2.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 2.NP_SO-101 | 2750 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0255 | 0255 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5 | 0
13827758 | 2.NP_SO-101 | 355 | 0.01375 | 0.21655 | 315 mm × 355 mm-250 mm × 355 mm | 2.NP_SO-101 | 2750 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 90 | 250 | 315 | 0.0504747 | 415 | 310 | 375 | 315 × 355-250 × 355 | TA00.01.0258 | 0258 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 400 | 542.886 | 415 | 225 | 0 | 350 | 350 | 250 | 515 | 257.5 | 225 | -32.5 | 10000 | 0 | 307.5 | 355 | 355 | 315 | 355 | 125 | 415 | 850 | 640 | 0
14031465 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-101 | 580.079 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0598 | 0598 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5
14031473 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-101 | 829.241 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0599 | 0599 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5
14032282 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 2440 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.01.0604 | 0604 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5 | 0
14032391 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 1300 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.01.0606 | 0606 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5 | 0
14034824 | -1.PP_SO-101 | 500 | 0.0308 | 0.615 | 560 mm × 500 mm-500 mm × 500 mm | -1.PP_SO-101 | 1930 | Znehodnocený | Odváděný vzduch | EHA 3 | EHA | 90 | 560 | 500 | 0.184594 | 560 | 620 | 560 | 560 × 500-500 × 500 | TA00.01.0614 | 0614 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 710 | 891.964 | 600 | 380 | 0 | 600 | 600 | 500 | 700 | 350 | 380 | 30 | 10000 | 0 | 400 | 560 | 560 | 560 | 500 | 280 | 600 | 1100 | 1040 | 0
14034834 | -1.PP_SO-101 | 500 | 0.0308 | 0.615 | 560 mm × 500 mm-560 mm × 500 mm | -1.PP_SO-101 | 600 | Znehodnocený | Odváděný vzduch | EHA 3 | EHA | 90 | 560 | 560 | 0.197934 | 560 | 620 | 620 | 560 × 500-560 × 500 | TA00.01.0617 | 0617 | yes | 90 | 10380 | 0 | 50 | 0 | 5 | 710 | 710 | 933.381 | 660 | 380 | 0 | 660 | 660 | 560 | 760 | 380 | 380 | 0 | 10000 | 0 | 430 | 560 | 560 | 560 | 560 | 280 | 660 | 1160 | 1040 | 0
14034915 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 2440 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.01.0621 | 0621 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5 | 0
14035580 | -1.PP_SO-101 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | -1.PP_SO-101 | 1300 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.01.0626 | 0626 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5 | 0
14047940 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-101 | 995 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0665 | 0665 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5 | 0.0480448
14047960 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-101 | 631.936 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 315 | 315 | 0.0309819 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.01.0666 | 0666 | yes | 135 | 10106.7 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 465 | 343.449 | 317.627 | 293.449 | 257.5 | 121.551 | 171.899 | 415 | 315 | 515 | 257.5 | 106.66 | 0 | 9924.58 | 182.08 | 156.66 | 315 | 315 | 315 | 315 | 157.5 | 171.899 | 915 | 672.5 | -8007.38
14053300 | 4.NP_SO-101 | 1100 | 0.02475 | 1.111 | 450 mm × 1100 mm-450 mm × 1100 mm | 4.NP_SO-101 | 384 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 30 | 450 | 450 | 0.138684 | 1160 | 510 | 510 | 450 × 1100-450 × 1100 | TA00.01.0680 | 0680 | yes | 150 | 10087.1 | 43.3013 | 25 | 4.33013 | 2.5 | 367.543 | 325 | 284.701 | 275 | 325 | 127.628 | 147.372 | 550 | 450 | 650 | 325 | 87.0835 | 0 | 9924.58 | 281.458 | 137.083 | 1100 | 1100 | 450 | 1100 | 225 | 147.372 | 1050 | 875
14053415 | 4.NP_SO-101 | 1100 | 0.02475 | 1.111 | 450 mm × 1100 mm-450 mm × 1100 mm | 4.NP_SO-101 | 504 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 30 | 450 | 450 | 0.138684 | 1160 | 510 | 510 | 450 × 1100-450 × 1100 | TA00.01.0681 | 0681 | yes | 150 | 10087.1 | 43.3013 | 25 | 4.33013 | 2.5 | 367.543 | 325 | 284.701 | 275 | 325 | 127.628 | 147.372 | 550 | 450 | 650 | 325 | 87.0835 | 0 | 9924.58 | 281.458 | 137.083 | 1100 | 1100 | 450 | 1100 | 225 | 147.372 | 1050 | 875
14055089 | 3.NP_SO-101 | 250 | 0.019525 | 0.205 | 355 mm × 250 mm-355 mm × 250 mm | 3.NP_SO-101 | 2035.81 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 15 | 355 | 355 | 0.0162101 | 310 | 415 | 415 | 355 × 250-355 × 250 | TA00.01.0690 | 0690 | yes | 165 | 10036.5 | 48.2963 | 12.941 | 4.82963 | 1.2941 | 171.917 | 167.763 | 118.779 | 117.763 | 277.5 | 57.8608 | 59.9019 | 455 | 355 | 555 | 277.5 | 36.5336 | 0 | 9964.71 | 268.044 | 86.5336 | 355 | 355 | 355 | 355 | 177.5 | 59.9019 | 955 | 732.5 | 0
14055108 | 3.NP_SO-101 | 250 | 0.019525 | 0.205 | 355 mm × 250 mm-355 mm × 250 mm | 3.NP_SO-101 | 2620.28 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 15 | 355 | 355 | 0.0162101 | 310 | 415 | 415 | 355 × 250-355 × 250 | TA00.01.0692 | 0692 | yes | 165 | 10036.5 | 48.2963 | 12.941 | 4.82963 | 1.2941 | 171.917 | 167.763 | 118.779 | 117.763 | 277.5 | 57.8608 | 59.9019 | 455 | 355 | 555 | 277.5 | 36.5336 | 0 | 9964.71 | 268.044 | 86.5336 | 355 | 355 | 355 | 355 | 177.5 | 59.9019 | 955 | 732.5 | 0
14063966 | 4.NP_SO-101 | 450 | 0.019525 | 0.369 | 355 mm × 450 mm-355 mm × 450 mm | 4.NP_SO-101 | 504 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 355 | 355 | 0.0872065 | 510 | 415 | 415 | 355 × 450-355 × 450 | TA00.01.0732 | 0732 |  | 90 | 10277.5 | 0 | 50 | 0 | 5 | 505 | 505 | 643.467 | 455 | 277.5 | 0 | 455 | 455 | 355 | 555 | 277.5 | 277.5 | 0 | 10000 | 0 | 327.5 | 450 | 450 | 355 | 450 | 177.5 | 455 | 955 | 732.5
14063969 | 4.NP_SO-101 | 450 | 0.0605 | 1.0395 | 1100 mm × 450 mm-355 mm × 450 mm | 4.NP_SO-101 | 504 | Znehodnocený | Odváděný vzduch | EHA 14 | EHA | 90 | 1100 | 355 | 0.258184 | 510 | 1160 | 415 | 1100 × 450-355 × 450 | TA00.01.0733 | 0733 |  | 90 | 10277.5 | 0 | 50 | 0 | 5 | 505 | 1250 | 1283.36 | 455 | 650 | 0 | 455 | 455 | 355 | 555 | 277.5 | 650 | 372.5 | 10000 | 0 | 327.5 | 1100 | 1100 | 1100 | 450 | 550 | 455 | 955 | 1850

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (62)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 01; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) = a (mm) = c (mm) = Výš. (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 5 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) = Délka 8 (mm) | Délka 6 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13442659 | 3.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm | 0.250545 | 3.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 90 | 200 | 200 | 0.0339325 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0028 | 0028 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 400 | 400 | 200 | 400 | 100 | 300 | 800 | 500
13442946 | 3.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm |  | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 2 | SUP | 90 | 200 | 200 | 0.0339325 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0030 | 0030 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 400 | 400 | 200 | 400 | 100 | 300 | 800 | 500
13520466 | 4.NP_SO-101 | 1000 | 0.02475 | 1.01 | 450 mm × 1000 mm-400 mm × 1000 mm | 0 | 4.NP_SO-101 | 1034 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 450 | 400 | 0.260247 | 1060 | 510 | 460 | 450 × 1000-400 × 1000 | TA00.01.0094 | 0094 | yes | 90 | 0 | 0 | 0 | 25 | 0 | 10300 | 50 | 5 | 550 | 600 | 743.303 | 500 | 325 | 500 | 500 | 400 | 600 | 300 | 325 | 10000 | 350 | 1000 | 1000 | 450 | 1000 | 225 | 500 | 1000 | 875
13614596 | -1.PP_SO-101 | 315 | 0.03465 | 0.43155 | 630 mm × 315 mm-630 mm × 315 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 90 | 630 | 630 | 0.151196 | 375 | 690 | 690 | 630 × 315-630 × 315 | TA00.01.0149 | 0149 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10415 | 50 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 730 | 730 | 630 | 830 | 415 | 415 | 10000 | 465 | 630 | 630 | 630 | 630 | 315 | 730 | 1230 | 1145
13614597 | -1.PP_SO-101 | 630 | 0.017325 | 0.4662 | 315 mm × 630 mm-315 mm × 630 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 90 | 315 | 315 | 0.102097 | 690 | 375 | 375 | 315 × 630-315 × 630 | TA00.01.0150 | 0150 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 630 | 630 | 315 | 630 | 157.5 | 415 | 915 | 672.5
13737330 | -1.PP_SO-101 | 400 | 0.0385 | 0.604 | 700 mm × 400 mm-400 mm × 400 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 90 | 700 | 400 | 0.159598 | 460 | 760 | 460 | 700 × 400-400 × 400 | TA00.01.0194 | 0194 | yes | 90 | 0 | 0 | 0 | 150 | 0 | 10300 | 50 | 5 | 550 | 850 | 943.398 | 500 | 450 | 500 | 500 | 400 | 600 | 300 | 450 | 10000 | 350 | 700 | 700 | 700 | 400 | 350 | 500 | 1000 | 1250
13737676 | -1.PP_SO-101 | 315 | 0.03465 | 0.43155 | 630 mm × 315 mm-630 mm × 315 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 45 | 630 | 630 | 0.0865122 | 375 | 690 | 690 | 630 × 315-630 × 315 | TA00.01.0197 | 0197 | yes | 135 | 35.3553 | 3.53553 | 213.812 | 0 | 293.449 | 10171.9 | 35.3553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 9878.45 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
13737677 | -1.PP_SO-101 | 355 | 0.03465 | 0.48635 | 630 mm × 355 mm-630 mm × 355 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 45 | 630 | 630 | 0.0974978 | 415 | 690 | 690 | 630 × 355-630 × 355 | TA00.01.0198 | 0198 | yes | 135 | 35.3553 | 3.53553 | 213.812 | 0 | 293.449 | 10171.9 | 35.3553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 9878.45 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
13764546 | -1.PP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 160 | 160 | 0.0197942 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0230 | 0230 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10180 | 50 | 5 | 310 | 310 | 367.696 | 260 | 180 | 260 | 260 | 160 | 360 | 180 | 180 | 10000 | 230 | 315 | 315 | 160 | 315 | 80 | 260 | 760 | 440
13764559 | 2.NP_SO-101 | 160 | 0.017325 | 0.1184 | 315 mm × 160 mm-315 mm × 160 mm | 0 | 2.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 315 | 315 | 0.0259295 | 220 | 375 | 375 | 315 × 160-315 × 160 | TA00.01.0231 | 0231 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13764678 | 4.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm |  | 4.NP_SO-101 | 3550 | Odváděný | Zpětný vzduch | ETA 13 | ETA | 90 | 200 | 200 | 0.0339325 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0233 | 0233 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 400 | 400 | 200 | 400 | 100 | 300 | 800 | 500
13764765 | 4.NP_SO-101 | 160 | 0.017325 | 0.1184 | 315 mm × 160 mm-315 mm × 160 mm | 0 | 4.NP_SO-101 | 1800 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 315 | 315 | 0.0259295 | 220 | 375 | 375 | 315 × 160-315 × 160 | TA00.01.0234 | 0234 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13849553 | 4.NP_SO-101 | 1000 | 0.02475 | 1.01 | 450 mm × 1000 mm-400 mm × 1000 mm |  | 4.NP_SO-101 | 384 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 90 | 450 | 400 | 0.260247 | 1060 | 510 | 460 | 450 × 1000-400 × 1000 | TA00.01.0320 | 0320 | yes | 90 | 0 | 0 | 0 | 25 | 0 | 10300 | 50 | 5 | 550 | 600 | 743.303 | 500 | 325 | 500 | 500 | 400 | 600 | 300 | 325 | 10000 | 350 | 1000 | 1000 | 450 | 1000 | 225 | 500 | 1000 | 875
13936059 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm | 0.125003 | 4.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 280 | 280 | 0.0381797 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0431 | 0431 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10240 | 50 | 5 | 430 | 430 | 537.401 | 380 | 240 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 290 | 280 | 280 | 280 | 280 | 140 | 380 | 880 | 620
13936227 | 4.NP_SO-101 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-280 mm × 315 mm | -6785.92 | 4.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 315 | 280 | 0.0477483 | 375 | 375 | 340 | 315 × 315-280 × 315 | TA00.01.0432 | 0432 | yes | 90 | 0 | 0 | 0 | 17.5 | 0 | 10240 | 50 | 5 | 430 | 465 | 562.694 | 380 | 257.5 | 380 | 380 | 280 | 480 | 240 | 257.5 | 10000 | 290 | 315 | 315 | 315 | 315 | 157.5 | 380 | 880 | 672.5
13936991 | 4.NP_SO-101 | 200 | 0.0099 | 0.094 | 180 mm × 200 mm-180 mm × 200 mm | 0 | 4.NP_SO-101 | 2340 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 180 | 180 | 0.0147042 | 260 | 240 | 240 | 180 × 200-180 × 200 | TA00.01.0434 | 0434 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10190 | 50 | 5 | 330 | 330 | 395.98 | 280 | 190 | 280 | 280 | 180 | 380 | 190 | 190 | 10000 | 240 | 200 | 200 | 180 | 200 | 90 | 280 | 780 | 470
13939067 | 4.NP_SO-101 | 200 | 0.0099 | 0.094 | 180 mm × 200 mm-180 mm × 200 mm | 0 | 4.NP_SO-101 | 2340 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 90 | 180 | 180 | 0.0147042 | 260 | 240 | 240 | 180 × 200-180 × 200 | TA00.01.0448 | 0448 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10190 | 50 | 5 | 330 | 330 | 395.98 | 280 | 190 | 280 | 280 | 180 | 380 | 190 | 190 | 10000 | 240 | 200 | 200 | 180 | 200 | 90 | 280 | 780 | 470
13939334 | 4.NP_SO-101 | 180 | 0.011 | 0.0918 | 200 mm × 180 mm-200 mm × 180 mm | 0.0399532 | 4.NP_SO-101 | 2340 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 200 | 200 | 0.0152696 | 240 | 260 | 260 | 200 × 180-200 × 180 | TA00.01.0449 | 0449 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 200 | 200 | 200 | 200 | 100 | 300 | 800 | 500
14000453 | 1.NP_SO-101 | 315 | 0.011 | 0.16065 | 200 mm × 315 mm-200 mm × 315 mm | 0 | 1.NP_SO-101 | 19249.6 | Odváděný | Odváděný vzduch | ETA 5 | ETA | 90 | 200 | 200 | 0.0267219 | 375 | 260 | 260 | 200 × 315-200 × 315 | TA00.01.0527 | 0527 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 315 | 315 | 200 | 315 | 100 | 300 | 800 | 500
14004395 | -1.PP_SO-101 | 150 | 0.0154 | 0.1005 | 280 mm × 150 mm-280 mm × 150 mm | 1.05672 | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 90 | 280 | 280 | 0.0204534 | 210 | 340 | 340 | 280 × 150-280 × 150 | TA00.01.0580 | 0580 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10240 | 50 | 5 | 430 | 430 | 537.401 | 380 | 240 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 290 | 280 | 280 | 280 | 280 | 140 | 380 | 880 | 620
14004409 | -1.PP_SO-101 | 150 | 0.0154 | 0.1005 | 280 mm × 150 mm-280 mm × 150 mm | 1.05672 | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 90 | 280 | 280 | 0.0204534 | 210 | 340 | 340 | 280 × 150-280 × 150 | TA00.01.0581 | 0581 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10240 | 50 | 5 | 430 | 430 | 537.401 | 380 | 240 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 290 | 280 | 280 | 280 | 280 | 140 | 380 | 880 | 620
14004493 | -1.PP_SO-101 | 150 | 0.0154 | 0.1005 | 280 mm × 150 mm-280 mm × 150 mm | 0 | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 90 | 280 | 280 | 0.0204534 | 210 | 340 | 340 | 280 × 150-280 × 150 | TA00.01.0583 | 0583 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10240 | 50 | 5 | 430 | 430 | 537.401 | 380 | 240 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 290 | 280 | 280 | 280 | 280 | 140 | 380 | 880 | 620
14004501 | -1.PP_SO-101 | 150 | 0.0154 | 0.1005 | 280 mm × 150 mm-280 mm × 150 mm | 0 | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 90 | 280 | 280 | 0.0204534 | 210 | 340 | 340 | 280 × 150-280 × 150 | TA00.01.0584 | 0584 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10240 | 50 | 5 | 430 | 430 | 537.401 | 380 | 240 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 290 | 280 | 280 | 280 | 280 | 140 | 380 | 880 | 620
14035677 | 4.NP_SO-101 | 400 | 0.0275 | 0.444 | 1000 mm × 400 mm-500 mm × 400 mm | 0 | 4.NP_SO-101 | 1576.9 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 500 | 1000 | 0.262957 | 460 | 560 | 1060 | 1000 × 400-500 × 400 | TA00.01.0630 | 0630 | yes | 90 | 0 | 0 | 0 | -250 | 0 | 10600 | 50 | 5 | 1150 | 650 | 1253 | 1100 | 350 | 600 | 600 | 500 | 1200 | 600 | 350 | 10000 | 650 | 500 | 1000 | 1000 | 1000 | 250 | 1100 | 1100 | 1450
14047359 | 4.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm |  | 4.NP_SO-101 | 72.6795 | Odváděný | Zpětný vzduch | ETA 13 | ETA | 30 | 200 | 200 | 0.0171775 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0662 | 0662 | yes | 150 | 43.3013 | 4.33013 | 69.6152 | 0 | 173.205 | 10053.6 | 25 | 2.5 | 223.205 | 200 | 155.291 | 150 | 200 | 80.3848 | 300 | 200 | 400 | 200 | 53.5898 | 9953.59 | 103.59 | 400 | 400 | 200 | 400 | 100 | 80.3848 | 800 | 500
14047392 | 4.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm |  | 4.NP_SO-101 | -117.846 | Odváděný | Zpětný vzduch | ETA 13 | ETA | 30 | 200 | 200 | 0.0171775 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0663 | 0663 | yes | 150 | 43.3013 | 4.33013 | 69.6152 | 0 | 173.205 | 10053.6 | 25 | 2.5 | 223.205 | 200 | 155.291 | 150 | 200 | 80.3848 | 300 | 200 | 400 | 200 | 53.5898 | 9953.59 | 103.59 | 400 | 400 | 200 | 400 | 100 | 80.3848 | 800 | 500
14050732 | 3.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 3.NP_SO-101 | 149.92 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0674 | 0674 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14050747 | 3.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 3.NP_SO-101 | -92.5667 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0675 | 0675 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14051166 | 1.NP_SO-101 | 315 | 0.011 | 0.16065 | 200 mm × 315 mm-200 mm × 315 mm | 0 | 1.NP_SO-101 | 16831.7 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 90 | 200 | 200 | 0.0267219 | 375 | 260 | 260 | 200 × 315-200 × 315 | TA00.01.0676 | 0676 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 315 | 315 | 200 | 315 | 100 | 300 | 800 | 500
14051704 | 3.NP_SO-101 | 160 | 0.017325 | 0.1184 | 315 mm × 160 mm-315 mm × 160 mm | 0 | 3.NP_SO-101 | -800 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 315 | 315 | 0.0259295 | 220 | 375 | 375 | 315 × 160-315 × 160 | TA00.01.0677 | 0677 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14051718 | 2.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 2.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0678 | 0678 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14051731 | 2.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 2.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0679 | 0679 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14054053 | 3.NP_SO-101 | 160 | 0.017325 | 0.1184 | 315 mm × 160 mm-315 mm × 160 mm | 0 | 3.NP_SO-101 | 3480 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 315 | 315 | 0.0259295 | 220 | 375 | 375 | 315 × 160-315 × 160 | TA00.01.0682 | 0682 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14054065 | 3.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 3.NP_SO-101 | 3480 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0683 | 0683 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14054263 | 3.NP_SO-101 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 3.NP_SO-101 | 3480 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 30 | 160 | 160 | 0.0102941 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.01.0684 | 0684 | yes | 150 | 43.3013 | 4.33013 | 60.3332 | 0 | 155.885 | 10048.2 | 25 | 2.5 | 200.111 | 180 | 134.586 | 130 | 180 | 69.6668 | 260 | 160 | 360 | 180 | 48.2309 | 9958.23 | 98.2309 | 315 | 315 | 160 | 315 | 80 | 69.6668 | 760 | 440
14054264 | 4.NP_SO-101 | 160 | 0.017325 | 0.1184 | 315 mm × 160 mm-315 mm × 160 mm | 0 | 4.NP_SO-101 | -520 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 90 | 315 | 315 | 0.0259295 | 220 | 375 | 375 | 315 × 160-315 × 160 | TA00.01.0685 | 0685 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10257.5 | 50 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14058113 | 4.NP_SO-101 | 500 | 0.022 | 0.455 | 500 mm × 500 mm-400 mm × 500 mm | 0 | 4.NP_SO-101 | 1576.9 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 400 | 500 | 0.143998 | 560 | 460 | 560 | 500 × 500-400 × 500 | TA00.01.0705 | 0705 |  | 90 | 0 | 0 | 0 | -50 | 0 | 10350 | 50 | 5 | 650 | 550 | 781.025 | 600 | 300 | 500 | 500 | 400 | 700 | 350 | 300 | 10000 | 400 | 500 | 500 | 500 | 500 | 200 | 600 | 1000 | 900
14058133 | 4.NP_SO-101 | 500 | 0.022 | 0.455 | 400 mm × 500 mm-400 mm × 500 mm | 0 | 4.NP_SO-101 | 2628.13 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 400 | 400 | 0.0691236 | 560 | 460 | 460 | 400 × 500-400 × 500 | TA00.01.0707 | 0707 |  | 135 | 35.3553 | 3.53553 | 146.447 | 0 | 212.132 | 10124.3 | 35.3553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 174.264 | 500 | 500 | 400 | 500 | 200 | 207.107 | 1000 | 800
14058303 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm | 0.235685 | 4.NP_SO-101 | 3720 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 280 | 280 | 0.023402 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0708 | 0708 |  | 135 | 35.3553 | 3.53553 | 111.299 | 0 | 169.706 | 10099.4 | 35.3553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 149.411 | 280 | 280 | 280 | 280 | 140 | 157.401 | 880 | 620
14058471 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm | 0.235685 | 4.NP_SO-101 | 3136.02 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 280 | 280 | 0.023402 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0709 | 0709 |  | 135 | 35.3553 | 3.53553 | 111.299 | 0 | 169.706 | 10099.4 | 35.3553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 149.411 | 280 | 280 | 280 | 280 | 140 | 157.401 | 880 | 620
14060003 | 4.NP_SO-101 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 4.NP_SO-101 | 1576.9 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 30 | 400 | 400 | 0.106832 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.01.0711 | 0711 |  | 150 | 43.3013 | 4.33013 | 116.025 | 0 | 259.808 | 10080.4 | 25 | 2.5 | 338.675 | 300 | 258.819 | 250 | 300 | 133.975 | 500 | 400 | 600 | 300 | 80.3848 | 9930.38 | 130.385 | 1000 | 1000 | 400 | 1000 | 200 | 133.975 | 1000 | 800
