Properties of the parts of a building model (IFC4), part 6 of 21

# IfcSpace: Zástupce ředitele A305:13895267, A305
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Počet dospělých: 1; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.682041; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 209.755 W; Specifikované výkonové zatížení: 272.681 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0.0138889 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.00754904 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 72.8809 m3; Plocha: 19.4869 m2
Identifikační data - Číslo: A305; Číslo místnosti: Neobsazené; ID systému: 3; Název: Zástupce ředitele; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: wc A221:13933356, A221
In: -1.PP_SO-101
LongName: wc; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4200 mm; NetVolume: 64.4962 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.780897; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 240.157 W; Specifikované výkonové zatížení: 312.204 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.0777778 m3/s; Specifikovaný přívod vzduchu: 0.0361111 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0361111 m3/s; Tok venkovního vzduchu: 0.0086432 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4200 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4200 mm; Objem: 64.4962 m3; Plocha: 22.3113 m2
Identifikační data - Číslo: A221; Číslo místnosti: Neobsazené; ID systému: 1; Název: wc; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: wc A222:14064343, A222
In: 1.NP_SO-101
LongName: wc; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4200 mm; GrossVolume: 2.88765 m3; NetVolume: 2.88765 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0326025; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 10.0266 W; Specifikované výkonové zatížení: 13.0346 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000360855 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-101; Horní odsazení: 4200 mm; Podlaží: 1.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4200 mm; Objem: 2.88765 m3; Plocha: 0.9315 m2
Identifikační data - Číslo: A222; Číslo místnosti: Neobsazené; ID systému: 10; Název: wc; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid A0104:13899649, A0104
In: -1.PP_SO-101
LongName: Úklid; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; NetVolume: 11.3427 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.167098; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 51.3893 W; Specifikované výkonové zatížení: 66.8061 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.00184949 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 11.3427 m3; Plocha: 4.77422 m2
Identifikační data - Číslo: A0104; Číslo místnosti: Neobsazené; ID systému: 5; Název: Úklid; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid A4112:13895052, A4112
In: 4.NP_SO-101
LongName: Úklid; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 4.97145 m3; NetVolume: 4.97145 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0756525; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 23.2662 W; Specifikované výkonové zatížení: 30.2461 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.00833333 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000837345 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 4.97145 m3; Plocha: 2.1615 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A4112; Číslo místnosti: Neobsazené; ID systému: 13; Název: Úklid; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Ředitelna A301:13895271, A301
In: 3.NP_SO-101
LongName: Ředitelna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 231.664 m3; NetVolume: 231.664 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet dospělých: 9; Počet osob: 2.16798; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 666.74 W; Specifikované výkonové zatížení: 866.762 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.0166667 m3/s; Specifikovaný přívod vzduchu: 0.125 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.125 m3/s; Tok venkovního vzduchu: 0.0239958 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 231.664 m3; Plocha: 61.9421 m2
Identifikační data - Číslo: A301; Číslo místnosti: Neobsazené; ID systému: 3; Název: Ředitelna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šablonárna A0103:13900573, A0103
In: -1.PP_SO-101
LongName: Šablonárna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 52.6757 m3; NetVolume: 52.6757 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.00833333 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 52.6757 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103; Číslo místnosti: Neobsazené; ID systému: 1; Název: Šablonárna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - M A0111:13899628, A0111
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0333333 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111; Číslo místnosti: Neobsazené; ID systému: 5; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - M A0115.1:13899547, A0115.1
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0833333 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1; Číslo místnosti: Neobsazené; ID systému: 8; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0108:13899631, A0108
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0333333 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108; Číslo místnosti: Neobsazené; ID systému: 6; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0114.1:13899532, A0114.1
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0833333 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 3300 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1; Číslo místnosti: Neobsazené; ID systému: 7; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šicí a střihačská dílna A401:13895048, A401
In: 4.NP_SO-101
LongName: Šicí a střihačská dílna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 874.79 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet dospělých: 2; Počet osob: 7.73182; Počet žáků: 20; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2377.85 W; Specifikované výkonové zatížení: 3091.2 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0.0333333 m3/s; Specifikovaný přívod vzduchu: 0.166667 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.155556 m3/s; Tok venkovního vzduchu: 0.0855782 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 874.79 m3; Plocha: 220.909 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A401; Číslo místnosti: Neobsazené; ID systému: 3; Název: Šicí a střihačská dílna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcAirTerminal: Mřížka - odvod:TRS-K, H 75, L 225-1225 (122)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 02; Popis: Výustka vzduchotechniky; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - odvod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětný vzduch
Kóty - Průměr vedení: 250 mm; Šířka: 75 mm; Šířka H: 75 mm; Šířka mřížky: 129 mm; Výška mřížky T: 94 mm; Výška potrubí: 75 mm
Jiné - Typ: TRS-K, H 75, L 225-1225; Id typu: 13431859; Rodina: Mřížka - odvod; Rodina a typ: Mřížka - odvod: TRS-K, H 75, L 225-1225
Name (Mřížka - odvod:TRS-K, H 75, L 225-1225:...) | In | Proudění vzduchu (m3/s) = Průtok (m3/s) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Typ systému | Název systému = Group | Zkratka systému | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13457955 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 28 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0020 | 0020 | 11.25
13457981 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 28 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0021 | 0021 | 11.25
13458261 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0022 | 0022 | 16.25
13458289 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0023 | 0023 | 16.25
13458311 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0024 | 0024 | 16.25
13458355 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0025 | 0025 | 16.25
13458391 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0026 | 0026 | 16.25
13458427 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Odváděný | ETA 29 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0027 | 0027 | 16.25
13458937 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0028 | 0028 | 11.25
13458961 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0029 | 0029 | 11.25
13460418 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0030 | 0030 | 11.25
13460442 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0031 | 0031 | 11.25
13460472 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0032 | 0032 | 11.25
13460539 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2900 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0033 | 0033 | 11.25
13461252 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0046 | 0046 | 11.25
13461308 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0047 | 0047 | 11.25
13461332 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0048 | 0048 | 11.25
13501439 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0052 | 0052 | 11.25
13501541 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0053 | 0053 | 11.25
13501751 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0054 | 0054 | 11.25
13501771 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0055 | 0055 | 11.25
13501795 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0056 | 0056 | 11.25
13502776 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3125 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0062 | 0062 | 11.25
13502818 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3125 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0063 | 0063 | 11.25
13502889 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3125 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0064 | 0064 | 11.25
13503431 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3200 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0065 | 0065 | 11.25
13504010 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0066 | 0066 | 11.25
13504128 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2550 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0067 | 0067 | 11.25
13505019 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3200 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0068 | 0068 | 11.25
13505055 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3200 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0069 | 0069 | 11.25
13505091 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3200 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0070 | 0070 | 11.25
13508921 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3320 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0082 | 0082 | 11.25
13509966 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0085 | 0085 | 11.25
13509986 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0086 | 0086 | 11.25
13510049 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0087 | 0087 | 16.25
13510097 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2640.02 | Odváděný | ETA 29 | ETA | 525 | 579 | 0.00394846 | 0.131847 | 525 × 75 | VV07.02.0088 | 0088 | 26.25
13511705 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0090 | 0090 | 11.25
13511769 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0091 | 0091 | 11.25
13511793 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0092 | 0092 | 11.25
13512362 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3520 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0093 | 0093 | 11.25
13512398 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3520 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0094 | 0094 | 11.25
13512440 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3510 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0095 | 0095 | 11.25
13512468 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3487.5 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0096 | 0096 | 11.25
13513909 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0097 | 0097 | 11.25
13522385 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0098 | 0098 | 11.25
13522462 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0099 | 0099 | 11.25
13522486 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0100 | 0100 | 11.25
13522730 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0101 | 0101 | 11.25
13522766 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0102 | 0102 | 11.25
13523290 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2900 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0103 | 0103 | 11.25
13523400 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0105 | 0105 | 11.25
13523424 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0106 | 0106 | 11.25
13523779 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0107 | 0107 | 11.25
13523811 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0108 | 0108 | 11.25
13532742 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3200 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0112 | 0112 | 11.25
13539979 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2640 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0116 | 0116 | 11.25
13540674 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0118 | 0118 | 11.25
13540762 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0119 | 0119 | 11.25
13540816 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0120 | 0120 | 11.25
13540907 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0121 | 0121 | 11.25
13541001 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0122 | 0122 | 11.25
13541126 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0123 | 0123 | 11.25
13545139 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1700 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0124 | 0124 | 11.25
13546883 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0125 | 0125 | 11.25
13546884 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0126 | 0126 | 11.25
13546885 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0127 | 0127 | 11.25
13546886 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0128 | 0128 | 11.25
13630474 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0130 | 0130 | 11.25
13630506 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0131 | 0131 | 11.25
13630534 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 35 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0132 | 0132 | 11.25
13630566 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0133 | 0133 | 11.25
13699344 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3600 |  |  |  | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0134 | 0134 | 11.25
13801179 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný | ETA 22 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0136 | 0136 | 11.25
13801238 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | Odváděný | ETA 31 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0137 | 0137 | 11.25
13801637 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3050 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0138 | 0138 | 11.25
13841699 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2440 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0145 | 0145 | 11.25
13841819 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2440 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0146 | 0146 | 11.25
13841897 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2320 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0147 | 0147 | 11.25
13842118 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0148 | 0148 | 11.25
13842390 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2640 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0149 | 0149 | 11.25
13843538 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0151 | 0151 | 11.25
13905969 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0157 | 0157 | 16.25
13906204 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0158 | 0158 | 16.25
13906663 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0159 | 0159 | 16.25
13906780 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0160 | 0160 | 16.25
13906951 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0161 | 0161 | 16.25
13909727 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0162 | 0162 | 21.25
13909793 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0163 | 0163 | 21.25
13909850 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3140 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0164 | 0164 | 21.25
13910000 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2900 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0165 | 0165 | 21.25
13910039 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2900 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0166 | 0166 | 21.25
13910108 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2900 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0167 | 0167 | 21.25
13910699 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2975 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0168 | 0168 | 21.25
13910848 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2975 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0169 | 0169 | 21.25
13912057 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3900 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0170 | 0170 | 11.25
13912172 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3900 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0171 | 0171 | 11.25
13912393 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0172 | 0172 | 11.25
13912727 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2200 | Odváděný | ETA 29 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0173 | 0173 | 11.25
13918431 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3225 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0174 | 0174 | 21.25
13918487 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0175 | 0175 | 21.25
13919130 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3225 | Odváděný | ETA 28 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0177 | 0177 | 11.25
13920737 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 2 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0178 | 0178 | 21.25
13920775 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný | ETA 2 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0179 | 0179 | 21.25
13923717 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1700 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0180 | 0180 | 11.25
13924106 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2100 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0181 | 0181 | 11.25
13929282 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3280 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0183 | 0183 | 11.25
13929350 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3280 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0184 | 0184 | 11.25
13929415 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3200 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0185 | 0185 | 11.25
13929570 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3280 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0186 | 0186 | 11.25
13929829 | 3.NP_SO-101 | 0.00833333 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3280 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0187 | 0187 | 11.25
13931088 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3150 | Odváděný | ETA 8 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0188 | 0188 | 11.25
13931182 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3150 | Odváděný | ETA 8 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0189 | 0189 | 11.25
13933187 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0192 | 0192 | 11.25
13934532 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3270 | Odváděný | ETA 4 | ETA | 325 | 379 | 0.00246286 | 0.087247 | 325 × 75 | VV07.02.0193 | 0193 | 16.25
13939390 | 4.NP_SO-101 | 0.00833333 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2250 | Odváděný | ETA 19 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0196 | 0196 | 11.25
13958858 | 1.NP_SO-101 | 0.00833333 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3125 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0197 | 0197 | 11.25
13965540 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2370 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0198 | 0198 | 11.25
14043019 | -1.PP_SO-101 | 0.00833333 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | Odváděný | ETA 30 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0206 | 0206 | 11.25
14072544 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3150.45 | Odváděný | ETA 28 | ETA | 425 | 479 | 0.00320566 | 0.109547 | 425 × 75 | VV07.02.0208 | 0208 | 21.25
14077287 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0210 | 0210 | 11.25
14077531 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0211 | 0211 | 11.25
14079976 | 2.NP_SO-101 | 0.00833333 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3270 | Odváděný | ETA 4 | ETA | 225 | 279 | 0.00172006 | 0.064947 | 225 × 75 | VV07.02.0212 | 0212 | 11.25

# IfcAirTerminal: Mřížka - přívod:TRS-K, H 75, L 225-1225 (71)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 01; Popis: Výustka vzduchotechniky; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - přívod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod vzduchu
Kóty - Průměr vedení: 250 mm; Výška mřížky T: 94 mm
Jiné - Id typu: 13433494; Rodina: Mřížka - přívod; Rodina a typ: Mřížka - přívod: TRS-K, H 75, L 225-1225; Typ: TRS-K, H 75, L 225-1225
Name (Mřížka - přívod:TRS-K, H 75, L 225-1225:...) | In | Proudění vzduchu (m3/s) = Průtok (m3/s) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Typ systému | Název systému = Group | Zkratka systému | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13433496 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6526.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0001 | 0001 | 11.25
13433502 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6506.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0002 | 0002 | 11.25
13442128 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6526.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0003 | 0003 | 11.25
13442130 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6531.29 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0004 | 0004 | 11.25
13442131 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6566.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0005 | 0005 | 11.25
13442132 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6506.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0006 | 0006 | 11.25
13452333 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2550 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0007 | 0007 | 11.25
13453704 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3110.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0008 | 0008 | 11.25
13453734 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3110.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0009 | 0009 | 11.25
13453768 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3110.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0010 | 0010 | 11.25
13453982 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -889.029 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0011 | 0011 | 11.25
13455042 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0012 | 0012 | 16.25
13455066 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0013 | 0013 | 16.25
13455090 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0014 | 0014 | 16.25
13455118 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0015 | 0015 | 21.25
13455190 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0016 | 0016 | 16.25
13455218 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3300 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0017 | 0017 | 16.25
13455738 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -889.029 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0018 | 0018 | 11.25
13455762 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -889.029 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0019 | 0019 | 11.25
13460634 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0034 | 0034 | 11.25
13460660 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0035 | 0035 | 11.25
13460684 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0036 | 0036 | 11.25
13460815 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0037 | 0037 | 11.25
13460839 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0038 | 0038 | 11.25
13460871 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0039 | 0039 | 11.25
