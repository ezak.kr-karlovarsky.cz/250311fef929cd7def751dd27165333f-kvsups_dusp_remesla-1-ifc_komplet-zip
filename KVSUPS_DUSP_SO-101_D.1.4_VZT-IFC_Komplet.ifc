Properties of the parts of a building model (IFC4), part 7 of 21

# IfcAirTerminal: Mřížka - přívod:TRS-K, H 75, L 225-1225 (71)
Name (Mřížka - přívod:TRS-K, H 75, L 225-1225:...) | In | Proudění vzduchu (m3/s) = Průtok (m3/s) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Typ systému | Název systému = Group | Zkratka systému | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13460895 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0040 | 0040 | 11.25
13460979 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3450 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0041 | 0041 | 11.25
13461007 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3450 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0042 | 0042 | 11.25
13461035 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3450 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0043 | 0043 | 11.25
13461088 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3450 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0044 | 0044 | 11.25
13461112 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3450 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0045 | 0045 | 11.25
13461509 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3180 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0049 | 0049 | 11.25
13461543 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3180 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0050 | 0050 | 11.25
13461634 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3180 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0051 | 0051 | 11.25
13502405 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0057 | 0057 | 11.25
13502595 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0058 | 0058 | 11.25
13502619 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0059 | 0059 | 11.25
13502647 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0060 | 0060 | 11.25
13502667 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0061 | 0061 | 11.25
13508058 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2550 | Přívodní | SUP 43 | SUP | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0072 | 0072 | 16.25
13508106 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0073 | 0073 | 21.25
13508126 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0074 | 0074 | 21.25
13508146 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0075 | 0075 | 21.25
13508258 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3280 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0076 | 0076 | 21.25
13508278 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3280 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0077 | 0077 | 21.25
13508298 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3280 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0078 | 0078 | 21.25
13508346 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3280 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0079 | 0079 | 21.25
13508818 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0080 | 0080 | 11.25
13508842 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0081 | 0081 | 11.25
13509033 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0083 | 0083 | 11.25
13509119 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0084 | 0084 | 11.25
13511606 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3110.97 | Přívodní | SUP 43 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0089 | 0089 | 21.25
13523349 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2920 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0104 | 0104 | 11.25
13525743 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6556.69 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.01.0109 | 0109 | 11.25
13525798 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6592.37 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.01.0110 | 0110 | 11.25
13532691 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3180 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0111 | 0111 | 11.25
13533516 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6532.37 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.01.0113 | 0113 | 11.25
13533691 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3730 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0114 | 0114 | 11.25
13533715 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3730 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0115 | 0115 | 11.25
13540312 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0117 | 0117 | 11.25
13625392 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2550 |  |  |  | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0129 | 0129 | 16.25
13763692 | -1.PP_SO-101 | 0.0472222 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0135 | 0135 | 11.25
13835446 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3110.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0143 | 0143 | 11.25
13841514 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2370 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0144 | 0144 | 11.25
13842605 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3250 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0150 | 0150 | 11.25
13918887 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3280 | Přívodní | SUP 20 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0176 | 0176 | 11.25
13932942 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2880 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0191 | 0191 | 11.25
13937291 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 6506.97 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0194 | 0194 | 11.25
13939294 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2250 | Přívodní | SUP 43 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0195 | 0195 | 11.25
14055762 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2880 | Přívodní | SUP 27 | SUP | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0207 | 0207 | 11.25
14072806 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | Přívodní | SUP 20 | SUP | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0209 | 0209 | 21.25

# IfcAirTerminal: Protidešťová žaluzie_Hranatá_Sání.CC:Protidešťová žaluzie_Hranatá_Sání.CC (4)
Type - Material: Protidešťová žuzie
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Pohon_Servo: yes
Type - Kóty - Délka: 50 mm; TLOUŠŤKA: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.30.60.11.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VV08; Nadpis OmniClass: Fixed Exterior Louvers and Grilles; Název typu: Protidešťová žaluzie_Hranatá_Sání.CC; Označení typu: 04; Popis: Protidešťová žaluzie; Popis sestavy: Žaluzie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Pohon_Ruční: no; Název rodiny: Protidešťová žaluzie_Hranatá_Sání.CC
Classification: VV08 Uniformat (Uniformat)
Mechanické – tok - Poměr průtoku: 1; Průtok: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Jiné - Id typu: 13758609; Rodina: Protidešťová žaluzie_Hranatá_Sání.CC; Rodina a typ: Protidešťová žaluzie_Hranatá_Sání.CC: Protidešťová žaluzie_Hranatá_Sání.CC; Typ: Protidešťová žaluzie_Hranatá_Sání.CC
Name (Protidešťová žaluzie_Hranatá_Sání.CC:Protidešťová žaluzie_Hranatá_Sání.CC:...) | In | Perimeter (mm) | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Název systému = Group | Objem (m3) | Plocha (m2) | ŠÍŘKA (mm) | Velikost | VÝŠKA (mm) | Kód prvku | Označení | C
13802574 | 4.NP_SO-101 | 1520 | Podlaží : STŘECHA_SO-101 | -4180 | STŘECHA_SO-101 | ODA 1 | 0.025205 | 0.5751 | 710 | 710 × 710 | 710 | VV08.04.0139 | 0139 | 6
13803672 | -1.PP_SO-101 | 730 | Podlaží : -1.PP_SO-101 | 1300 | -1.PP_SO-101 | ODA 3 | 0.00882 | 0.22015 | 315 | 315 × 560 | 560 | VV08.04.0141 | 0141 | 5
13821060 | 2.NP_SO-101 | 1300 | Podlaží : 2.NP_SO-101 | -845 | 2.NP_SO-101 | ODA 10 | 0.015 | 0.355 | 600 | 600 × 500 | 500 | VV08.04.0142 | 0142 | 4
13927823 | -1.PP_SO-101 | 1220 | Podlaží : -1.PP_SO-101 | -500 | -1.PP_SO-101 | ODA 18 | 0.01568 | 0.3696 | 560 | 560 × 560 | 560 | VV08.04.0182 | 0182 | 5

# IfcAirTerminal: Protidešťová žaluzie_Hranatá_Výfuk.CC:Protidešťová žaluzie_Hranatá_Výfuk.CC (14)
Type - Material: Protidešťová žuzie
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Pohon_Servo: yes
Type - Kóty - Délka: 50 mm; TLOUŠŤKA: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.30.60.11.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VV08; Nadpis OmniClass: Fixed Exterior Louvers and Grilles; Název typu: Protidešťová žaluzie_Hranatá_Výfuk.CC; Označení typu: 05; Popis: Protidešťová žaluzie; Popis sestavy: Žaluzie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Pohon_Ruční: no; Název rodiny: Protidešťová žaluzie_Hranatá_Výfuk.CC
Classification: VV08 Uniformat (Uniformat)
Mechanické – tok - Poměr průtoku: 1; Průtok: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Odváděný vzduch
Jiné - Id typu: 13796570; Rodina: Protidešťová žaluzie_Hranatá_Výfuk.CC; Rodina a typ: Protidešťová žaluzie_Hranatá_Výfuk.CC: Protidešťová žaluzie_Hranatá_Výfuk.CC; Typ: Protidešťová žaluzie_Hranatá_Výfuk.CC
Name (Protidešťová žaluzie_Hranatá_Výfuk.CC:Protidešťová žaluzie_Hranatá_Výfuk.CC:...) | In | Perimeter (mm) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Objem (m3) | Plocha (m2) | ŠÍŘKA (mm) | Velikost | VÝŠKA (mm) | Kód prvku | Označení | C | Typ systému | Název systému = Group | Zkratka systému
13802643 | 4.NP_SO-101 | 1520 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | -4245 | 0.022365 | 0.5143 | 710 | 710 × 630 | 630 | VV08.05.0140 | 0140 | 5
13904786 | 2.NP_SO-101 | 810 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 4270.2 | 0.00630125 | 0.161525 | 355 | 355 × 355 | 355 | VV08.05.0152 | 0152 | 3 | Znehodnocený | EHA 10 | EHA
13904832 | 2.NP_SO-101 | 460 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 4270.2 | 0.00162 | 0.0504 | 180 | 180 × 180 | 180 | VV08.05.0153 | 0153 | 2 | Odváděný | ETA 2 | ETA
13904848 | 2.NP_SO-101 | 460 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 4270.2 | 0.00162 | 0.0504 | 180 | 180 × 180 | 180 | VV08.05.0154 | 0154 | 2 | Odváděný | ETA 31 | ETA
13905274 | 1.NP_SO-101 | 460 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | 0.00162 | 0.0504 | 180 | 180 × 180 | 180 | VV08.05.0155 | 0155 | 2 | Odváděný | ETA 7 | ETA
13905300 | 1.NP_SO-101 | 460 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | 0.00162 | 0.0504 | 180 | 180 × 180 | 180 | VV08.05.0156 | 0156 | 2 | Odváděný | ETA 22 | ETA
13932335 | -1.PP_SO-101 | 1100 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 600 | 0.014 | 0.333 | 500 | 500 × 560 | 560 | VV08.05.0190 | 0190 | 5 | Znehodnocený | EHA 3 | EHA
14000047 | 4.NP_SO-101 | 420 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 1800 | 0.00252 | 0.07415 | 160 | 160 × 315 | 315 | VV08.05.0199 | 0199 | 3 | Odváděný | ETA 35 | ETA
14000269 | 4.NP_SO-101 | 600 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | 700 | 0.003125 | 0.0875 | 250 | 250 × 250 | 250 | VV08.05.0200 | 0200 | 3 | Odváděný | ETA 30 | ETA
14000341 | 4.NP_SO-101 | 730 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | 1000 | 0.00496125 | 0.130725 | 315 | 315 × 315 | 315 | VV08.05.0201 | 0201 | 3 | Znehodnocený | EHA 8 | EHA
14000422 | 4.NP_SO-101 | 420 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | 1000 | 0.00128 | 0.0416 | 160 | 160 × 160 | 160 | VV08.05.0202 | 0202 | 2 | Odváděný | ETA 1 | ETA
14000469 | 4.NP_SO-101 | 730 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | 974.6 | 0.00315 | 0.08875 | 315 | 315 × 200 | 200 | VV08.05.0203 | 0203 | 2 | Odváděný | ETA 5 | ETA
14000566 | 4.NP_SO-101 | 460 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | 700 | 0.00162 | 0.0504 | 180 | 180 × 180 | 180 | VV08.05.0204 | 0204 | 2 | Odváděný | ETA 4 | ETA
14000700 | 4.NP_SO-101 | 420 | STŘECHA_SO-101 | Podlaží : STŘECHA_SO-101 | -2700 | 0.00128 | 0.0416 | 160 | 160 × 160 | 160 | VV08.05.0205 | 0205 | 2 | Odváděný | ETA 29 | ETA

# IfcAirTerminal: Žaluzie protidešťová_Hranatá_Sání.CC:500x400, Žaluzie protidešťová_Hranatá_Sání.CC:500x400:13506025
In: 2.NP_SO-101
Type - Material: Mřížka vodorovná
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Pohon_Servo: yes
Type - Kóty - Délka: 50 mm; POTRUBÍ_ŠÍŘKA: 500 mm; POTRUBÍ_VÝŠKA: 400 mm; ŠÍŘKA: 500 mm; TLOUŠŤKA: 50 mm; VÝŠKA: 400 mm
Type - Identifikační data - Číslo OmniClass: 23.30.60.11.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VV08; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Fixed Exterior Louvers and Grilles; Název typu: 500x400; Označení typu: 03; Popis: Protidešťová žaluzie; Popis sestavy: Žaluzie; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Žaluzie protidešťová_Hranatá_Sání.CC; Pohon_Ruční: no; Servo zn: 365 mm
Classification: VV08 Uniformat (Uniformat); Group: ODA 11
Qto_AirTerminalBaseQuantities - Perimeter: 1100 mm
Mechanické – tok - Poměr průtoku: 1; Průtok: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 3100 mm; Výška od podlaží: 3100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 11; Zkratka systému: ODA
Grafika - S: yes
Kóty - Objem: 0.01 m3; Velikost: 500 × 400
Identifikační data - Kód prvku: VV08.03.0071; Označení: 0071
Jiné - C: 4; Id typu: 13506072; Rodina: Žaluzie protidešťová_Hranatá_Sání.CC; Rodina a typ: Žaluzie protidešťová_Hranatá_Sání.CC: 500x400; Typ: 500x400

# IfcBuildingElementProxy: 1_01_VZT_1PP_1NP:1_01_VZT_1PP_1NP, 1_01_VZT_1PP_1NP:1_01_VZT_1PP_1NP:13735667
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Topvex TC60-R-HWH-B_1
Type - Kóty - Délka: 2742 mm; MC Height: 1106 mm; MC Length: 2108 mm; MC Width: 2742 mm; Šířka: 1083 mm; Výška: 1695 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Topvex TC60-R-HWH-B_1; magiProductId: Topvex TC60-R-HWH-B_1; Model: Topvex TC60-R-HWH-B; Název typu: 1_01_VZT_1PP_1NP; Označení typu: 04; Popis: Kompaktní VZT jednotka, vertikální připojení, protiproudý deskový rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1; Výrobce: Systemair
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 1_01_VZT_1PP_1NP
Classification: JV01 Uniformat (Uniformat); Group: ETA 30; SUP 27; ODA 3; EHA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 45.4981 m2; NetVolume: 5.24205 m3
Mechanické – tok - Exhaust, top Air flow: 1.056 m3/s; Exhaust, top Airflow operation point max l/s: 1.108 m3/s; Exhaust, top Airflow operation point min l/s: 1.003 m3/s; Exhaust, top Maximum pressure drop: 82 Pa; Exhaust, top Minimum pressure drop: 68 Pa; Exhaust, top Pressure drop: 75 Pa; Extract, top Air flow: 1.056 m3/s; Extract, top Airflow operation point max l/s: 1.108 m3/s; Extract, top Airflow operation point min l/s: 1.003 m3/s; Extract, top Maximum pressure drop: 248 Pa; Extract, top Minimum pressure drop: 202 Pa; Extract, top Pressure drop: 225 Pa; Outdoor, top Air flow: 1.056 m3/s; Outdoor, top Airflow operation point max l/s: 1.108 m3/s; Outdoor, top Airflow operation point min l/s: 1.003 m3/s; Outdoor, top Maximum pressure drop: 82 Pa; Outdoor, top Minimum pressure drop: 68 Pa; Outdoor, top Pressure drop: 75 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 0.888889 m3/s; Průtok vzduchu odváděný: 0.888889 m3/s; Průtok vzduchu přívodní: 0.888889 m3/s; Průtok vzduchu znehodnocený: 0.888889 m3/s; Supply, top Air flow: 1.056 m3/s; Supply, top Airflow operation point max l/s: 1.108 m3/s; Supply, top Airflow operation point min l/s: 1.003 m3/s; Supply, top Maximum pressure drop: 248 Pa; Supply, top Minimum pressure drop: 202 Pa; Supply, top Pressure drop: 225 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: -300 mm; Výška od podlaží: -300 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, top Sound power level: 74 68 84 76 78 73 69 65 82 82 dB; Extract, top Sound power level: 69 66 74 63 61 51 42 40 68 68 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 27,ODA 3,ETA 30,EHA 3; Outdoor, top Sound power level: 71 65 74 64 60 50 45 41 67 67 dB; Supply, top Sound power level: 79 69 85 77 77 74 71 66 82 82 dB
Kóty - Objem: 5.24205 m3; Plocha: 22.7602 m2
Identifikační data - Kód prvku: JV01.04.0008; Komentáře: VZT č.1 VZT_jednotka_vertikální Vp/Vo=3200m3/h dp=300Pa ZZT-deskový P=4,4 kW; Označení: 0008; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13735638; Rodina: 1_01_VZT_1PP_1NP; Rodina a typ: 1_01_VZT_1PP_1NP: 1_01_VZT_1PP_1NP; Typ: 1_01_VZT_1PP_1NP

# IfcBuildingElementProxy: 2_01_VZT_2NP_chemie:2_01_VZT_2NP_chemie, 2_01_VZT_2NP_chemie:2_01_VZT_2NP_chemie:13413254
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: VZT 2.01 chemie
Type - Kóty - Délka: 2742 mm; MC Height: 1106 mm; MC Length: 2122 mm; MC Width: 2742 mm; Šířka: 1083 mm; Výška: 1695 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: VZT 2.01 chemie; magiProductId: VZT 2.01 chemie; Model: VZT 2.01 chemie; Název typu: 2_01_VZT_2NP_chemie; Označení typu: 01; Popis: Kompaktní VZT jednotka, vertikální připojení, protiproudý deskový rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 2_01_VZT_2NP_chemie
Classification: JV01 Uniformat (Uniformat); Group: SUP 20; ODA 11; ETA 28; EHA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 45.639 m2; NetVolume: 5.24207 m3
Mechanické – tok - Exhaust, top Air flow: 0.917 m3/s; Exhaust, top Airflow operation point max l/s: 0.963 m3/s; Exhaust, top Airflow operation point min l/s: 0.871 m3/s; Exhaust, top Maximum pressure drop: 69 Pa; Exhaust, top Minimum pressure drop: 56 Pa; Exhaust, top Pressure drop: 62 Pa; Extract, top Air flow: 0.917 m3/s; Extract, top Airflow operation point max l/s: 0.963 m3/s; Extract, top Airflow operation point min l/s: 0.871 m3/s; Extract, top Maximum pressure drop: 206 Pa; Extract, top Minimum pressure drop: 169 Pa; Extract, top Pressure drop: 188 Pa; Outdoor, top Air flow: 0.917 m3/s; Outdoor, top Airflow operation point max l/s: 0.963 m3/s; Outdoor, top Airflow operation point min l/s: 0.871 m3/s; Outdoor, top Maximum pressure drop: 69 Pa; Outdoor, top Minimum pressure drop: 56 Pa; Outdoor, top Pressure drop: 62 Pa; Pressure rise, extract: 250 Pa; Pressure rise, supply: 250 Pa; Průtok vzduchu čerstvý: 0.75 m3/s; Průtok vzduchu odváděný: 0.75 m3/s; Průtok vzduchu přívodní: 0.75 m3/s; Průtok vzduchu znehodnocený: 0.75 m3/s; Supply, top Air flow: 0.917 m3/s; Supply, top Airflow operation point max l/s: 0.963 m3/s; Supply, top Airflow operation point min l/s: 0.871 m3/s; Supply, top Maximum pressure drop: 206 Pa; Supply, top Minimum pressure drop: 169 Pa; Supply, top Pressure drop: 188 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 0 mm; Podlaží: 2.NP_SO-101; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, top Sound power level: 72 67 81 72 74 70 66 62 79 79 dB; Extract, top Sound power level: 67 65 72 60 57 47 39 37 65 65 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 20,ODA 11,ETA 28,EHA 8; Outdoor, top Sound power level: 70 63 73 61 57 48 43 38 66 66 dB; Supply, top Sound power level: 78 67 84 74 75 71 68 63 80 80 dB
Kóty - Objem: 5.24207 m3; Plocha: 22.8306 m2
Identifikační data - Kód prvku: JV01.01.0001; Komentáře: VZT č.2 VZT_jednotka_vertikální Vp/Vo=2700m3/h dp=300Pa ZZT-deskový P=4,4 kW; Označení: 0001; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13407840; Rodina: 2_01_VZT_2NP_chemie; Rodina a typ: 2_01_VZT_2NP_chemie: 2_01_VZT_2NP_chemie; Typ: 2_01_VZT_2NP_chemie

# IfcBuildingElementProxy: 3_01 VZT_3_NP_podkroví:3_01 VZT_3_NP_podkroví, 3_01 VZT_3_NP_podkroví:3_01 VZT_3_NP_podkroví:14028261
In: 4.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 780 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 11 3.01 3.NP_podkroví/3.01 3.NP_podkroví
Type - Kóty - Délka: 4164 mm; MC Height: 1300 mm; MC Length: 4164 mm; MC Width: 1182 mm; Šířka: 1182 mm; Výška: 1300 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Geniox 11 3.01 3.NP_podkroví/3.01 3.NP_podkroví; magiProductId: Geniox 11 3.01 3.NP_podkroví/3.01 3.NP_podkroví; Model: Geniox 11 : 3.01 3.NP_podkroví/3.01 3.NP_podkroví; Název typu: 3_01 VZT_3_NP_podkroví; Označení typu: 06; Popis: Kompaktní VZT jednotka, horizontální; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 3_01 VZT_3_NP_podkroví
Classification: JV01 Uniformat (Uniformat); Group: ETA 14
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 44.6871 m2; NetVolume: 6.17957 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 1.5 m3/s; Exhaust 1 Airflow min ls: 0.3 m3/s; Exhaust 1 Airflow operation point max ls: 0.963 m3/s; Exhaust 1 Airflow operation point min ls: 0.871 m3/s; Exhaust 1 Flow: 0.917 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 1.5 m3/s; Extract 1 Airflow min ls: 0.3 m3/s; Extract 1 Airflow operation point max ls: 0.963 m3/s; Extract 1 Airflow operation point min ls: 0.871 m3/s; Extract 1 Flow: 0.917 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 1.5 m3/s; Outdoor 1 Airflow min ls: 0.3 m3/s; Outdoor 1 Airflow operation point max ls: 0.963 m3/s; Outdoor 1 Airflow operation point min ls: 0.871 m3/s; Outdoor 1 Flow: 0.917 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 0.916667 m3/s; Průtok vzduchu odváděný: 0.916667 m3/s; Průtok vzduchu přívodní: 0.916667 m3/s; Průtok vzduchu znehodnocený: 0.916667 m3/s; Supply 1 Airflow max ls: 1.5 m3/s; Supply 1 Airflow min ls: 0.3 m3/s; Supply 1 Airflow operation point max ls: 0.963 m3/s; Supply 1 Airflow operation point min ls: 0.871 m3/s; Supply 1 Flow: 0.917 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 4.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 65 74 70 72 71 68 64 60 dB; Extract 1 Sound generation: 60 68 64 61 54 49 44 40 dB; Fan efficiency, extract: 67.0 %; Fan efficiency, supply: 66.5 %; Fan speed, extract: 2060 RPM; Fan speed, supply: 2288 RPM; Heat recovery: 88.5 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: ETA 14; Outdoor 1 Sound generation: 63 72 69 65 58 53 47 42 dB; SFPe, dimensional filters excluding frequency converter: 2.05 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 2.16 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.93 kW/(m3/s); SFPv, clean filters including frequency converter: 2.03 kW/(m3/s); Sound power level, extract: 62 dB(A); Sound power level, supply: 74 dB(A); Supply 1 Sound generation: 66 78 75 71 69 63 59 52 dB
Kóty - Objem: 6.17957 m3; Plocha: 22.3547 m2
Identifikační data - Kód prvku: JV01.06.0025; Komentáře: VZT č.3 VZT_jednotka_horizontální Vp/Vo=3300m3/h dp=300Pa ZZT-deskový P=2,7kW; Označení: 0025; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 14028232; Rodina: 3_01 VZT_3_NP_podkroví; Rodina a typ: 3_01 VZT_3_NP_podkroví: 3_01 VZT_3_NP_podkroví; Typ: 3_01 VZT_3_NP_podkroví

# IfcBuildingElementProxy: 4_01_VZT_2_NP kabinet:4_01_VZT_2_NP kabinet, 4_01_VZT_2_NP kabinet:4_01_VZT_2_NP kabinet:13611350
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Topvex FR03 HWH-R-CAV
Type - Kóty - Délka: 1600 mm; MC Height: 565 mm; MC Length: 1120 mm; MC Width: 2139 mm; Šířka: 1000 mm; Výška: 540 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Topvex FR03 HWH-R-CAV; magiProductId: Topvex FR03 HWH-R-CAV; Model: Topvex FR03 HWH-R-CAV; Název typu: 4_01_VZT_2_NP kabinet; Označení typu: 03; Popis: Kompaktní VZT jednotka do podhledu, rotační rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1; Výrobce: Systemair
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 4_01_VZT_2_NP kabinet
Classification: JV01 Uniformat (Uniformat); Group: ETA 29; SUP 43; ODA 10; EHA 10
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.7973 m2; NetVolume: 0.960108 m3
Mechanické – tok - Exhaust, left Air flow: 0.114 m3/s; Exhaust, left Airflow operation point max l/s: 0.12 m3/s; Exhaust, left Airflow operation point min l/s: 0.108 m3/s; Exhaust, left Maximum pressure drop: 69 Pa; Exhaust, left Minimum pressure drop: 56 Pa; Exhaust, left Pressure drop: 62 Pa; Extract, right Air flow: 0.114 m3/s; Extract, right Airflow operation point max l/s: 0.12 m3/s; Extract, right Airflow operation point min l/s: 0.108 m3/s; Extract, right Maximum pressure drop: 206 Pa; Extract, right Minimum pressure drop: 169 Pa; Extract, right Pressure drop: 188 Pa; Outdoor, left Air flow: 0.114 m3/s; Outdoor, left Airflow operation point max l/s: 0.12 m3/s; Outdoor, left Airflow operation point min l/s: 0.108 m3/s; Outdoor, left Maximum pressure drop: 69 Pa; Outdoor, left Minimum pressure drop: 56 Pa; Outdoor, left Pressure drop: 62 Pa; Pressure rise, extract: 250 Pa; Pressure rise, supply: 250 Pa; Průtok vzduchu čerstvý: 0.0555556 m3/s; Průtok vzduchu odváděný: 0.0555556 m3/s; Průtok vzduchu přívodní: 0.0555556 m3/s; Průtok vzduchu znehodnocený: 0.0555556 m3/s; Supply, right Air flow: 0.114 m3/s; Supply, right Airflow operation point max l/s: 0.12 m3/s; Supply, right Airflow operation point min l/s: 0.108 m3/s; Supply, right Maximum pressure drop: 206 Pa; Supply, right Minimum pressure drop: 169 Pa; Supply, right Pressure drop: 188 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 3450 mm; Výška od podlaží: 3450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, left Sound power level: 74 78 73 62 61 57 47 49 68 68 dB; Extract, right Sound power level: 70 73 59 41 38 29 22 22 58 58 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 43,ODA 10,ETA 29,EHA 10; Outdoor, left Sound power level: 71 74 57 42 39 33 28 20 59 59 dB; Supply, right Sound power level: 75 77 70 62 61 59 52 45 68 68 dB
Kóty - Objem: 0.960108 m3; Plocha: 5.40982 m2
Identifikační data - Kód prvku: JV01.03.0006; Komentáře: VZT č.4 VZT_jednotka_podstropní Vp/Vo=200m3/h dp=300Pa ZZT-deskový P=1,9 kW; Označení: 0006; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13611307; Rodina: 4_01_VZT_2_NP kabinet; Rodina a typ: 4_01_VZT_2_NP kabinet: 4_01_VZT_2_NP kabinet; Typ: 4_01_VZT_2_NP kabinet

# IfcBuildingElementProxy: Dveřní mřížka:500x200 (35)
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Šířka: 150 mm; Šířka mřížky: 500 mm; Výška: 200 mm; Výška mřížky: 200 mm
Type - Identifikační data - Kód sestavy: VV07; Název typu: 500x200; Označení typu: 01; Popis sestavy: Mřížka
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Dveřní mřížka
Classification: VV07 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Úroveň dveří nad podlahou: 0 mm
Jiné - Id typu: 13524686; Rodina: Dveřní mřížka; Rodina a typ: Dveřní mřížka: 500x200; Typ: 500x200
Name (Dveřní mřížka:500x200:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Podlaží | Výška od podlaží (mm) | Plocha (m2) | Šířka dveří (mm) | Tloušťka dveří (mm) = Tloušťka mřížky (mm) | Kód prvku | Označení
13524702 | 2.NP_SO-101 | 0.34 | 0.01 | 2.NP_SO-101 | 2600 | 0.17 | 700 | 100 | VV07.01.0001 | 0001
13524914 | 2.NP_SO-101 | 0.34 | 0.01 | 2.NP_SO-101 | 2600 | 0.17 | 700 | 100 | VV07.01.0002 | 0002
13524937 | 2.NP_SO-101 | 0.22 | 0.006 | 2.NP_SO-101 | 2600 | 0.11 | 500 | 100 | VV07.01.0003 | 0003
13524994 | 2.NP_SO-101 | 0.22 | 0.006 | 2.NP_SO-101 | 2600 | 0.11 | 500 | 100 | VV07.01.0004 | 0004
13525190 | 2.NP_SO-101 | 0.34 | 0.01 | 2.NP_SO-101 | 2600 | 0.17 | 700 | 100 | VV07.01.0005 | 0005
13525222 | 2.NP_SO-101 | 0.34 | 0.01 | 2.NP_SO-101 | 2600 | 0.17 | 700 | 100 | VV07.01.0006 | 0006 | Jiné - Páteřní trasa: no
13525242 | 2.NP_SO-101 | 0.28 | 0.008 | 2.NP_SO-101 | 4000 | 0.14 | 600 | 100 | VV07.01.0007 | 0007
13525285 | 2.NP_SO-101 | 0.28 | 0.008 | 2.NP_SO-101 | 4000 | 0.14 | 600 | 100 | VV07.01.0008 | 0008
13525324 | 2.NP_SO-101 | 0.34 | 0.01 | 2.NP_SO-101 | 4000 | 0.17 | 700 | 100 | VV07.01.0009 | 0009
13525359 | 4.NP_SO-101 | 0.34 | 0.01 | 4.NP_SO-101 | 0 | 0.17 | 700 | 100 | VV07.01.0010 | 0010
13525373 | 4.NP_SO-101 | 0.34 | 0.01 | 4.NP_SO-101 | 0 | 0.17 | 700 | 100 | VV07.01.0011 | 0011
13525403 | 4.NP_SO-101 | 0.34 | 0.01 | 4.NP_SO-101 | 0 | 0.17 | 700 | 100 | VV07.01.0012 | 0012
13525412 | 4.NP_SO-101 | 0.34 | 0.01 | 4.NP_SO-101 | 0 | 0.17 | 700 | 100 | VV07.01.0013 | 0013
13525476 | 4.NP_SO-101 | 0.28 | 0.008 | 4.NP_SO-101 | 2200 | 0.14 | 600 | 100 | VV07.01.0014 | 0014
13532286 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0015 | 0015
13532330 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0016 | 0016
13532343 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0017 | 0017
13532375 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0018 | 0018
13532412 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0019 | 0019
13532434 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 1650 | 0.17 | 700 | 100 | VV07.01.0020 | 0020
13532484 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 1650 | 0.17 | 700 | 100 | VV07.01.0021 | 0021
13537998 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | 3150 | 0.17 | 700 | 100 | VV07.01.0024 | 0024
13832462 | -1.PP_SO-101 | 0.83 | 0.045 | -1.PP_SO-101 | 2150 | 0.415 | 700 | 450 | VV07.01.0091 | 0091
13832494 | -1.PP_SO-101 | 0.34 | 0.01 | -1.PP_SO-101 | -850 | 0.17 | 700 | 100 | VV07.01.0092 | 0092
13900755 | 4.NP_SO-101 | 0.28 | 0.008 | 4.NP_SO-101 | 2100 | 0.14 | 600 | 100 | VV07.01.0114 | 0114
13957611 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0143 | 0143
13957699 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0144 | 0144
13957710 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0145 | 0145
13957782 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0146 | 0146
13957793 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0147 | 0147
13957824 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0148 | 0148
13957867 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0149 | 0149
13957903 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0150 | 0150
13957952 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0151 | 0151
13958005 | -1.PP_SO-101 | 0.248848 | 0.00696162 | -1.PP_SO-101 | -850 | 0.124424 | 548.081 | 100 | VV07.01.0152 | 0152

# IfcBuildingElementProxy: Odsávací zákryt:Odsávací zákryt (6)
In: 1.NP_SO-101
Type - Material: <Unnamed>, EquipSpace
Type - Obecné - Date of publishing: 2014-08-12; Design country: United States; Edition number: 1; Manufacturer country: United States; Manufacturer name: SEPS2BIM; Nominal height: 530; Nominal width: 1830; Product SKU: L2337; QR code: http://bimobject.com/seps2bim/product/L2337; Region North America: US; Weight Net (Kg): 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 600 mm; Šířka: 600 mm; Výška: 350 mm
Type - Identifikační data - Kód sestavy: JV; Název typu: Odsávací zákryt; Označení typu: 05; Popis: Canopy fumehood. The unit includes a switched fan unit with pilot light; corrosion resistant steel, aluminum, or chemical resistant and fire retardant seamless fiberglass construction; dimensions as indicated on design drawings; fire suppression systems and any other special requirements to be defined during the facility design. It also includes a 3/4 horsepower motor blower. The static pressure loss shall not exceed 0.91 at 1290 cfm and 1.65 at 1935 cfm. It is equipped with baffles to maximize slot velocities and control fumes. Used in laboratories for low to moderate risk biological agents. Other sizes may be available. Blower motor mounted separate from the canopy and may not be included in the size specification.; Popis sestavy: Jednotka VZT; Product data url: http://bimobject.com/seps2bim/product/L2337
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Odsávací zákryt
Classification: JV Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.2632 m2; NetVolume: 0.0486493 m3
Text - CCI Funkční systém: J; CCI Komponenta: UCC; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0486493 m3; Plocha: 2.1316 m2
Jiné - Id typu: 13953250; Rodina: Odsávací zákryt; Rodina a typ: Odsávací zákryt: Odsávací zákryt; Typ: Odsávací zákryt
Name (Odsávací zákryt:Odsávací zákryt:...) | Průtok vzduchu odváděný (m3/s) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
13953266 | 0.208333 | 2000 | JV.05.0019 | 0019 | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13955055 | 0.208333 | 2086.86 | JV.05.0020 | 0020 | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13955078 | 0.208333 | 2100 | JV.05.0021 | 0021 | Identifikační data - Komentáře: Odvětrací zákryt/digestoř 600x600mm
13955267 | 0.138889 | 1200 | JV.05.0022 | 0022
13957033 | 0.138889 | 2000 | JV.05.0023 | 0023
13957087 | 0.138889 | 2000 | JV.05.0024 | 0024

# IfcBuildingElementProxy: Odvodní ventilátor:Odvodní ventilátor (16)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DÉLKA: 303 mm; POTRUBÍ_PRŮMĚR: 100 mm; Šířka: 233 mm; Výška: 293 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.35.17.24; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VN01; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Axial Fans; Název typu: Odvodní ventilátor; Označení typu: 02; Popis: Popis; Popis sestavy: Axiální; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; a: 30 mm; b: 84.708 mm; C: 115 mm; D: 97 mm; E: 100 mm; F: 90 mm; G: 20 mm; H: 60 mm; Název rodiny: Odvodní ventilátor
Classification: VN01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.176726 m2; NetVolume: 0.00521594 m3
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00521594 m3; Plocha: 0.0460233 m2
Jiné - Id typu: 13542076; Rodina: Odvodní ventilátor; Rodina a typ: Odvodní ventilátor: Odvodní ventilátor; Typ: Odvodní ventilátor
Name (Odvodní ventilátor:Odvodní ventilátor:...) | In | PRŮTOK (m3/s) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | Kód prvku | Komentáře | Označení | Páteřní trasa
13542109 | -1.PP_SO-101 | 0.05 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | VN01.02.0002 | VZT č.6 Odvodní_ventilátor Vo=410m3/h dp=200Pa P=0,1 kW | 0002 | yes
13542127 | -1.PP_SO-101 | 0.05 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Odváděný vzduch | ETA 30 | VN01.02.0003 | VZT č.5 Odvodní_ventilátor Vo=630m3/h dp=200Pa P=0,1kW | 0003 | yes
13546861 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | VN01.02.0004 | VZT č.7 Odvodní_ventilátor Vo=400m3/h dp=200Pa P=0,1 kW | 0004 | yes
13547030 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 35 | VN01.02.0005 | VZT č.8 Odvodní_ventilátor Vo=400m3/h dp=200Pa P=0,1kW | 0005 | yes
13632091 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný vzduch | ETA 22 | VN01.02.0007 | VZT č.17 Odvodní_ventilátor Vo=50m3/h dp=150Pa P=0,1kW | 0007 | yes
13762048 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2520 | Zpětný vzduch | ETA 4 | VN01.02.0009 | VZT č.9 Odvodní_ventilátor Vo=150m3/h dp=200Pa P=0,1kW | 0009 | yes
13763478 | -1.PP_SO-101 | 0.0388889 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | Zpětný vzduch | ETA 31 | VN01.02.0010 | VZT č.16 Odvodní_ventilátor Vo=50m3/h dp=150Pa P=0,1kW | 0010 | yes
13763847 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3150 | Nedefinovaný |  | VN01.02.0011 | VZT č.14 Odvodní_ventilátor Vo=150m3/h dp=200Pa P=0,2kW | 0011 | yes
13790669 | 4.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 182.906 | Odváděný vzduch | ETA 29 | VN01.02.0012 | VZT č.13 Odvodní_ventilátor Vo=265m3/h dp=150Pa P=0,1 kW | 0012 | yes
13831348 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2780 | Odváděný vzduch | ETA 2 | VN01.02.0013 | VZT č.15b Odvodní_ventilátor dp=150Pa P=0,1kW | 0013 | yes
13905580 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3150 | Odváděný vzduch | ETA 7 | VN01.02.0014 | VZT č.15d Odvodní_ventilátor dp=150Pa P=0,1kW | 0014 | yes
13911153 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3350 | Zpětný vzduch | ETA 4 | VN01.02.0015 | VZT č.11 Odvodní_ventilátor Vo=160m3/h dp=200Pa P=0,1kW | 0015 | yes
13920363 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2450 | Odváděný vzduch | ETA 2 | VN01.02.0016 | VZT č.15a Odvodní_ventilátor Vo=390m3/h dp=150Pa P=0,1 kW | 0016 | yes
13921888 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2851.29 | Zpětný vzduch | ETA 5 | VN01.02.0017 | VZT č.15c Odvodní_ventilátor dp=150Pa P=0,1kW | 0017 | yes
13935050 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3445 | Odváděný vzduch | ETA 4 | VN01.02.0018 | VZT č.12 Odvodní_ventilátor Vo=265m3/h dp=200Pa P=0,1kW | 0018 | yes
14079138 | 1.NP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3350 | Zpětný vzduch | ETA 4 | VN01.02.0026 |  | 0026

# IfcBuildingElementProxy: Požární klapka hranatá.LH:280x250, Požární klapka hranatá.LH:280x250:13835695
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 280 mm; Jmenovitá velikost vstupu - výška: 250 mm; Jmenovitá velikost výstupu - šířka: 280 mm; Jmenovitá velikost výstupu - výška: 250 mm; Šířka: 280 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 250 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 280x250; Označení typu: 18; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ETA 12
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.59822 m2; NetVolume: 0.0374436 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 280 mm × 250 mm-280 mm × 250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 280 mm × 250 mm-280 mm × 250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.0583333 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: FMA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no; Výška od podlaží: 3840 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 12; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0363896 m3; Velikost: 280 × 250-280 × 250
Identifikační data - Kód prvku: PK00.18.0098; Označení: 0098
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 14069013; Rodina a typ: Požární klapka hranatá.LH: 280x250; Typ: 280x250

# IfcBuildingElementProxy: Požární klapka hranatá.LH:280x280, Požární klapka hranatá.LH:280x280:13935328
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 280 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 280 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 280 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 280x280; Označení typu: 32; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: SUP 43
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.72782 m2; NetVolume: 0.0418476 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 280 mm × 280 mm-280 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 280 mm × 280 mm-280 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: FMA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no; Výška od podlaží: 2790 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0406916 m3; Velikost: 280 × 280-280 × 280
Identifikační data - Kód prvku: PK00.32.0137; Označení: 0137
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Typ: 280x280; Id typu: 13916567; Rodina a typ: Požární klapka hranatá.LH: 280x280

# IfcBuildingElementProxy: Požární klapka hranatá.LH:315x315, Požární klapka hranatá.LH:315x315:13829040
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 315 mm; Šířka: 315 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 315x315; Označení typu: 14; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: SUP 20
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.04247 m2; NetVolume: 0.0527606 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 315 mm-315 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 315 mm-315 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: -0.0166667 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: FMA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no; Výška od podlaží: 3100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0513544 m3; Velikost: 315 × 315-315 × 315
Identifikační data - Kód prvku: PK00.14.0076; Označení: 0076
Jiné - Páteřní trasa: yes; Id typu: 13826722; Rodina: Požární klapka hranatá.LH; Rodina a typ: Požární klapka hranatá.LH: 315x315; Typ: 315x315

# IfcBuildingElementProxy: Požární klapka hranatá.LH:315x315 (4)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 315 mm; Šířka: 315 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 315x315; Označení typu: 14; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.04247 m2; NetVolume: 0.0527606 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 315 mm-315 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 315 mm-315 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: FMA; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0513544 m3; Velikost: 315 × 315-315 × 315
Jiné - Páteřní trasa: yes; Id typu: 13826722; Rodina: Požární klapka hranatá.LH; Rodina a typ: Požární klapka hranatá.LH: 315x315; Typ: 315x315
Name (Požární klapka hranatá.LH:315x315:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13826752 | 2.NP_SO-101 | 2.NP_SO-101 | 3100 | Čerstvý | Přívod vzduchu | ODA 11 | ODA | PK00.14.0072 | 0072 | Mechanické – tok - Tlaková ztráta: 0 Pa
13827214 | 2.NP_SO-101 | 2.NP_SO-101 | 2500 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | PK00.14.0074 | 0074 | Mechanické – tok - Tlaková ztráta: 0 Pa
13829058 | 2.NP_SO-101 | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | PK00.14.0077 | 0077
13849403 | 4.NP_SO-101 | 4.NP_SO-101 | 163.537 | Přívodní | Přívod vzduchu | SUP 43 | SUP | PK00.14.0111 | 0111

# IfcBuildingElementProxy: Požární klapka hranatá.LH:315x315, Požární klapka hranatá.LH:315x315:13849435
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 315 mm; Šířka: 315 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 315x315; Označení typu: 14; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.04247 m2; NetVolume: 0.0527606 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 315 mm-315 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 315 mm-315 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.0333333 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: FMA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no; Výška od podlaží: 163.537 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0513544 m3; Velikost: 315 × 315-315 × 315
Identifikační data - Kód prvku: PK00.14.0112; Označení: 0112
Jiné - Páteřní trasa: yes; Id typu: 13826722; Rodina: Požární klapka hranatá.LH; Rodina a typ: Požární klapka hranatá.LH: 315x315; Typ: 315x315

# IfcBuildingElementProxy: Požární klapka kruhová.LH:Standardní (4)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 400 mm; Jmenovitá velikost vstupu: 0 mm; Jmenovitá velikost výstupu: 0 mm; Průměr: 450 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: Standardní; Označení typu: 04; Popis: Požární klapka kruhová; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka kruhová.LH
Classification: PK00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; f: 100 mm; g: 15 mm; Lgt1: 220.022 mm; Lgt2: 269.997 mm; Požární klapka, pol1: 36.5 mm
Jiné - Typ: Standardní; Id typu: 13624454; Rodina: Požární klapka kruhová.LH; Rodina a typ: Požární klapka kruhová.LH: Standardní
Name (Požární klapka kruhová.LH:Standardní:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | DN (mm) = Průměr vedení (mm) | h (mm) | Poloměr potrubí (mm) = Vnější poloměr (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13624534 | -1.PP_SO-101 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | -1.PP_SO-101 | 2262.59 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 250 | 62.5 | 125 | 250-250 | PK00.04.0032 | 0032 | yes
13834746 | 2.NP_SO-101 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | 62.5 | 125 | 250-250 | PK00.04.0094 | 0094 | yes
13835599 | 4.NP_SO-101 | 0.935318 | 0.0508239 | 400 mm-400 mm |  | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 400 | 100 | 200 | 400-400 | PK00.04.0097 | 0097 | yes
14061505 | 4.NP_SO-101 | 0.935318 | 0.0508239 | 400 mm-400 mm | 0 | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 400 | 100 | 200 | 400-400 | PK00.04.0157 | 0157

# IfcBuildingElementProxy: Požární klapka kruhová.LH:Standardní (3)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 400 mm; Jmenovitá velikost vstupu: 0 mm; Jmenovitá velikost výstupu: 0 mm; Průměr: 450 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: Standardní; Označení typu: 04; Popis: Požární klapka kruhová; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka kruhová.LH
Classification: PK00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no; Připojení EPS: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Lgt1: 220.022 mm; Lgt2: 269.997 mm; Požární klapka, pol1: 36.5 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 13624454; Rodina: Požární klapka kruhová.LH; Rodina a typ: Požární klapka kruhová.LH: Standardní
Name (Požární klapka kruhová.LH:Standardní:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Volná velikost = Celková velikost | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | DN (mm) = Průměr vedení (mm) | f (mm) | g (mm) | h (mm) | Poloměr potrubí (mm) = Vnější poloměr (mm) | Velikost | Kód prvku | Označení
13624511 | -1.PP_SO-101 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0.166667 | 1.66367 | -1.PP_SO-101 | 2400 | Zpětný vzduch | ETA 30 | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.04.0031 | 0031
13834760 | 2.NP_SO-101 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0.0416667 | 0.103979 | 2.NP_SO-101 | 3225 | Zpětný vzduch | ETA 28 | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.04.0095 | 0095
13835585 | 4.NP_SO-101 | 0.389246 | 0.0106026 | 180 mm-180 mm | 0 | 0 | 4.NP_SO-101 | 3300 | Odváděný vzduch | ETA 29 | 180 | 90 | 13.5 | 45 | 90 | 180-180 | PK00.04.0096 | 0096

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:200x180, Regulátor průtoku vzduchu hranatý.LH:200x180:13939121
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 200 mm; Jmenovitá velikost vstupu - výška: 180 mm; Jmenovitá velikost výstupu - šířka: 200 mm; Jmenovitá velikost výstupu - výška: 180 mm; Šířka: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 180 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 200x180; Označení typu: 33; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: SUP 43
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.6916 m2; NetVolume: 0.018575 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm × 180 mm-200 mm × 180 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm × 180 mm-200 mm × 180 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
