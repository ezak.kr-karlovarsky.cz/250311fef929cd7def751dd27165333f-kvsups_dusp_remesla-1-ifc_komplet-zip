Properties of the parts of a building model (IFC4), part 14 of 21

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (16)
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Výškové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka = Poloviční šířka 1 (mm) | Odskok – výška | Plocha (m2) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Delta 2 (mm) | Čís.1 = Čís.2 = Čís.4 | Čís.3 | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm)
14063360 | 4.NP_SO-101 |  |  |  | 600 mm × 500 mm-500 mm × 400 mm | 0 | 4.NP_SO-101 | 3698.68 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 120.711 | 0.0299765 | 250 | 200 | 0.223524 | 300 | 200 | 250 | 100 | 100 | 500 | 600 | 600 × 500-500 × 400 | 400 | 500 | TA00.09.0727 | 0727 |  | 0 | 2 | 4 | 2 | 2 | 4 | 2 | 120.711 | 120.711
14063362 | 4.NP_SO-101 |  |  |  | 600 mm × 500 mm-500 mm × 400 mm | 0 | 4.NP_SO-101 | 2813.8 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 120.711 | 0.0299765 | 250 | 200 | 0.223524 | 300 | 200 | 250 | 100 | 100 | 500 | 600 | 600 × 500-500 × 400 | 400 | 500 | TA00.09.0728 | 0728 |  | 0 | 2 | 4 | 2 | 2 | 4 | 2 | 120.711 | 120.711
14071598 | 1.NP_SO-101 |  |  |  | 355 mm × 180 mm-315 mm × 200 mm | 0 | 1.NP_SO-101 | 16576.7 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 3048 | 48.2843 | 0.00307007 | 157.5 | 100 | 0.0530368 | 177.5 | 100 | 90 | 40 | 20 | 315 | 355 | 355 × 180-315 × 200 | 200 | 180 | TA00.09.0774 | 0774 |  | 0 | 0.8 | 0.64 | 0.4 | 0.4 | 0.16 | 0.4 | 24.1421 | 48.2843
14081034 | 4.NP_SO-101 | 125 | 0.00458701 | 0.0540328 | 200 mm × 125 mm-180 mm × 125 mm | 0 | 4.NP_SO-101 | -12630 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 3048 | 24.1421 | 0.000573376 | 100 | 62.5 | 0.0180952 | 90 | 62.5 | 62.5 | 20 | 0 | 200 | 180 | 200 × 125-180 × 125 | 125 | 125 | TA00.09.0827 | 0827 |  | 0 | 0.4 | 0.16 | 1 | 1 | 1 | 1 | 60.3553 | 24.1421
14081962 | 4.NP_SO-101 | 125 | 0.00458701 | 0.0540328 | 125 mm × 200 mm-125 mm × 180 mm | 0 | 4.NP_SO-101 | 6730 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 3048 | 24.1421 | 0.000573376 | 62.5 | 90 | 0.0173106 | 62.5 | 90 | 100 | 0 | 20 | 125 | 125 | 125 × 200-125 × 180 | 180 | 200 | TA00.09.0837 | 0837 |  | 0 | 1 | 1 | 0.4 | 0.4 | 0.16 | 0.4 | 24.1421 | 60.3553

# IfcDuctFitting: M_Hranatý spoj T:Standardní, M_Hranatý spoj T:Standardní:13935470
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: O; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 11; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranatý spoj T
Classification: TA00 Uniformat (Uniformat); Group: SUP 43
Qto_DuctFittingBaseQuantities - Length: 400 mm; GrossCrossSectionArea: 0.178875 m2; NetCrossSectionArea: 0.178875 m2; OuterSurfaceArea: 0.744 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 400 mm-630 mm × 400 mm-225 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 400 mm-630 mm × 400 mm-225 mm × 400 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 1270.11 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka1a: 112.5 mm; Délka3a: 315 mm; Délka potrubí 1: 137.5 mm; Délka potrubí 3: 340 mm; Objem: 0.07155 m3; Rameno: 25 mm; Šířka potrubí 1: 630 mm; Šířka potrubí 3: 225 mm; Velikost: 630 × 400-630 × 400-225 × 400; Výška potrubí: 400 mm
Identifikační data - Kód prvku: TA00.11.0426; Označení: 0426
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559782; Rodina: M_Hranatý spoj T; Rodina a typ: M_Hranatý spoj T: Standardní

# IfcDuctFitting: M_Hranatý spoj T:Standardní (2)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: O; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 11; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranatý spoj T
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Odváděný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Rameno: 25 mm
Jiné - Typ: Standardní; Id typu: 1559782; Rodina: M_Hranatý spoj T; Rodina a typ: M_Hranatý spoj T: Standardní
Name (M_Hranatý spoj T:Standardní:...) | In | Length (mm) = Výška potrubí (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka1a (mm) | Délka3a (mm) | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Šířka potrubí 1 (mm) | Šířka potrubí 3 (mm) | Velikost | Kód prvku | Označení
14055549 | -1.PP_SO-101 | 160 | 0.07695 | 0.1824 | 315 mm × 160 mm-315 mm × 160 mm-180 mm × 160 mm | -1.PP_SO-101 | 2450 | ETA 35 | 90 | 157.5 | 115 | 182.5 | 0.012312 | 315 | 180 | 315 × 160-315 × 160-180 × 160 | TA00.11.0699 | 0699 | Jiné - Páteřní trasa: yes
14081940 | 3.NP_SO-101 | 200 | 0.025 | 0.13 | 125 mm × 200 mm-125 mm × 200 mm-125 mm × 200 mm | 3.NP_SO-101 | 3445 | ETA 4 | 62.5 | 62.5 | 87.5 | 87.5 | 0.005 | 125 | 125 | 125 × 200-125 × 200-125 × 200 | TA00.11.0835 | 0835

# IfcDuctFitting: M_Kulaté koleno:1 D (306)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Násobitel poloměru: 1
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: K; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 1 D; Označení typu: 02; Popis: Koleno; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté koleno
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Jiné - Id typu: 1452114; Rodina: M_Kulaté koleno; Rodina a typ: M_Kulaté koleno: 1 D; Typ: 1 D
Name (M_Kulaté koleno:1 D:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka1 (mm) | Objem (m3) | Poloměr potrubí (mm) | Střední poloměr (mm) | Úhel (deg) | Velikost | Kód prvku | Označení | Páteřní trasa | Tlaková ztráta (Pa)
12987259 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0002 | 0002 | no
12987273 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 42.8719 | 0.00168433 | 80 | 160 | 30 | 160-160 | TA00.02.0003 | 0003 | no
12987283 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 42.8719 | 0.00168433 | 80 | 160 | 30 | 160-160 | TA00.02.0004 | 0004 | no
12987390 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3300 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0005 | 0005 | no | 0
12987513 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0006 | 0006 | no
12987525 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 21.0644 | 0.000842165 | 80 | 160 | 15 | 160-160 | TA00.02.0007 | 0007 | no
12987539 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 21.0644 | 0.000842165 | 80 | 160 | 15 | 160-160 | TA00.02.0008 | 0008 | no
12987626 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2710.13 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0010 | 0010 | no
12988200 | 4.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 4.NP_SO-101 | 3900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 125 | 0.00240949 | 62.5 | 125 | 90 | 125-125 | TA00.02.0012 | 0012 | yes | -27727.5
12995197 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0013 | 0013 | yes | -41317.2
13415163 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0016 | 0016 | no
13427874 | 1.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 1.NP_SO-101 | 3000 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0018 | 0018 | yes | 0
13442119 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0021 | 0021 | no
13444871 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0036 | 0036 | yes | 0
13445091 | 1.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0037 | 0037 | yes | 0
13452292 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0038 | 0038 | no | 0
13452388 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0039 | 0039 | no | 0
13452397 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0040 | 0040 | no | 0
13454246 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0041 | 0041 | no | 0
13455946 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0042 | 0042 | yes | 0
13455955 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0043 | 0043 | yes | 0
13456352 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0044 | 0044 | yes | 0
13456573 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0045 | 0045 | yes | 0
13456575 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0046 | 0046 | yes | 0
13456611 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0047 | 0047 | yes | 0
13457582 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0048 | 0048 | no | 0
13457662 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3225 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0049 | 0049 | no | -43324.3
13462444 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0051 | 0051 | yes | 0
13462446 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3180 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0052 | 0052 | yes | 0
13462621 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 4210 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0054 | 0054 | yes
13462635 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 4210 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0055 | 0055 | yes
13462671 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0056 | 0056 | yes | 0
13480632 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0057 | 0057 | yes | 0
13503622 | 1.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 1.NP_SO-101 | 3000 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0059 | 0059 | yes | 0
13503749 | 1.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 1.NP_SO-101 | 3450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 125 | 0.00240949 | 62.5 | 125 | 90 | 125-125 | TA00.02.0061 | 0061 | no | 0
13504195 | 1.NP_SO-101 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 450 | 0.112416 | 225 | 450 | 90 | 450-450 | TA00.02.0062 | 0062 | yes
13505492 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 130.477 | 0.0192793 | 157.5 | 315 | 45 | 315-315 | TA00.02.0065 | 0065 | yes
13505504 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0066 | 0066 | yes
13505529 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0068 | 0068 | yes | 0
13505575 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2500 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0070 | 0070 | yes | 0
13505767 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2485 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0073 | 0073 | yes | 0
13505769 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2485 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0074 | 0074 | yes | 0
13507043 | 3.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 3.NP_SO-101 | 3545 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0075 | 0075 | yes | 0
13507146 | 3.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 3.NP_SO-101 | 3545 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0076 | 0076 | yes | 0
13508662 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0077 | 0077 | yes | 0
13508698 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0078 | 0078 | yes | 0
13509278 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0081 | 0081 | no | 0
13509331 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0082 | 0082 | no | -92963.8
13509401 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3275 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0084 | 0084 | yes
13509592 | 3.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0085 | 0085 | yes
13512038 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0087 | 0087 | yes | 0
13513859 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 400 | 0.0789531 | 200 | 400 | 90 | 400-400 | TA00.02.0088 | 0088 | yes
13523692 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0096 | 0096 | no | -41317.2
13527689 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0099 | 0099 | yes
13529317 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 4100 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0106 | 0106 | yes
13529328 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0107 | 0107 | yes
13529850 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0108 | 0108 | yes | 0
13531029 | 1.NP_SO-101 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 450 | 0.112416 | 225 | 450 | 90 | 450-450 | TA00.02.0109 | 0109 | yes
13533468 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0110 | 0110 | no
13533650 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0112 | 0112 | no
13533652 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0113 | 0113 | yes
13539766 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0116 | 0116 | yes | 0
13540619 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0117 | 0117 | no | -165269
13540623 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0119 | 0119 | no | -232147
13546877 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0133 | 0133 | no | 0
13546881 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0134 | 0134 | no | 0
13547046 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0139 | 0139 | no | 0
13547048 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0140 | 0140 | no | 0
13547847 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0143 | 0143 | no | -41317.2
13548004 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0144 | 0144 | yes | 0
13577663 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0145 | 0145 | yes | 0
13619416 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0151 | 0151 | yes | -693188
13624780 | 1.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 1.NP_SO-101 | 3155 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0152 | 0152 | yes | 0
13625875 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3155 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0156 | 0156 | yes | 0
13625914 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3155 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0157 | 0157 | yes | 0
13626260 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2350 | Odváděný | Zpětný vzduch | ETA 32 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0158 | 0158 | yes
13626278 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2350 | Odváděný | Zpětný vzduch | ETA 32 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0159 | 0159 | yes
13630884 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0169 | 0169 | yes | 0
13630955 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 2640.02 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0170 | 0170 | yes | -10329.3
13632255 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0173 | 0173 | yes | 0
13632366 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0174 | 0174 | yes | -10329.3
13632455 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 22 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0175 | 0175 | yes | 0
13716157 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0192 | 0192 | no | 0
13762558 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0221 | 0221 | no
13762713 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0223 | 0223 | no | -224949
13763770 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0227 | 0227 | yes | -224949
13764674 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3550 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0232 | 0232 | yes
13790716 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 182.906 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0237 | 0237 | yes | 0
13790834 | 4.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 4.NP_SO-101 | 3300 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0238 | 0238 | no | 0
13790855 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2600 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0239 | 0239 | yes | 0
13790909 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2600 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0240 | 0240 | yes | 0
13790919 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3575 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0241 | 0241 | yes | 0
13820875 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 4270.2 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0244 | 0244 | yes | 0
13829100 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 130.477 | 0.0192793 | 157.5 | 315 | 45 | 315-315 | TA00.02.0261 | 0261 | yes
13830768 | 2.NP_SO-101 | 250 mm-250 mm | 15 | 280 mm-280 mm | 2.NP_SO-101 | 3100 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0294 | 0294 | yes | -6931.88 | Izolace - Typ izolace: Protipožární
13830852 | 2.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 2.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0296 | 0296 | no | -23771.9
13835077 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0303 | 0303 | no | -10329.3
13835536 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0304 | 0304 | no | 0
13835538 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3110.97 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0305 | 0305 | no | 0
13841268 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2500 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0306 | 0306 | no | -331686
13903464 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1455.67 | Odváděný | Zpětný vzduch | ETA 6 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0325 | 0325 | yes
13904131 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1532.39 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0326 | 0326 | no | 0
13904135 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0327 | 0327 | yes | 0
13904154 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1532.39 | Odváděný | Zpětný vzduch | ETA 16 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0328 | 0328 | yes | 0
13904158 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 16 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0329 | 0329 | yes | 0
13904262 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0330 | 0330 | yes
13904588 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0332 | 0332 | yes | 0
13904592 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0333 | 0333 | yes | 0
13905383 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0341 | 0341 | yes | 0
13905391 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0342 | 0342 | yes | 0
13905401 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0343 | 0343 | yes | 0
13905435 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3150 | Odváděný | Odváděný vzduch | ETA 7 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0344 | 0344 | yes | 0
13907468 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0348 | 0348 | no | -6931.88
13907470 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0349 | 0349 | yes | -6931.88
13911289 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0355 | 0355 | no | 0
13911506 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160.028 | 0.00505364 | 80 | 160 | 90.01 | 160-160 | TA00.02.0358 | 0358 | no | 0
13911508 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0359 | 0359 | no | -92963.8
13918679 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3280 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0362 | 0362 | no | 0
13923565 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 1700 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0373 | 0373 | no | -10329.3
13923981 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 1700 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0374 | 0374 | no | -41317.2
13924010 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0375 | 0375 | no | -41317.2
13924546 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2100 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0377 | 0377 | no | -10329.3
13924556 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0378 | 0378 | no | -10329.3
13924585 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0380 | 0380 | no | -10329.3
13924815 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0382 | 0382 | yes | -232147
13926459 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0384 | 0384 | yes | -95087.5
13927013 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0389 | 0389 | yes | 0
13927092 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2500 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0390 | 0390 | yes | -331686
13927210 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2640 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0391 | 0391 | yes | -899798
13927221 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2112.4 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0392 | 0392 | yes | -899798
13928145 | -1.PP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | -1.PP_SO-101 | -1350 | Čerstvý | Přívod vzduchu | ODA 18 | ODA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0394 | 0394 | no | 0
13928244 | -1.PP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | -1.PP_SO-101 | -500 | Čerstvý | Přívod vzduchu | ODA 18 | ODA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0396 | 0396 | no | 0
13928258 | -1.PP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | -1.PP_SO-101 | -1350 | Čerstvý | Přívod vzduchu | ODA 18 | ODA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0397 | 0397 | no | 0
13928412 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0399 | 0399 | no | 0
13928496 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0400 | 0400 | yes | 0
13929989 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -845 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0403 | 0403 | yes | -10329.3
13929996 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3155 | Odváděný | Zpětný vzduch | ETA 29 | ETA | 160.051 | 0.00505411 | 80 | 160 | 90.0184 | 160-160 | TA00.02.0404 | 0404 | yes | 0
13930138 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0405 | 0405 | no | 0
13930146 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0406 | 0406 | no
13930406 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0410 | 0410 | no
13930442 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 2780 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0411 | 0411 | no
13931301 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0414 | 0414 | yes | 0
13932505 | 4.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 125 | 0.00240949 | 62.5 | 125 | 90 | 125-125 | TA00.02.0417 | 0417 | yes | -27727.5
13932678 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0419 | 0419 | no | 0
13934396 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3350 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0421 | 0421 | no | 0
13935482 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 2790 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0429 | 0429 | yes | 0
13938247 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0442 | 0442 | yes | -224949
13938251 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 4270.2 | Odváděný | Zpětný vzduch | ETA 31 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0443 | 0443 | yes | -224949
13938315 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 4270.2 | Odváděný | Odváděný vzduch | ETA 2 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0444 | 0444 | yes | 0
13938609 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0446 | 0446 | yes | 0
13955227 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0450 | 0450 | yes | 0
13955255 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -1148.71 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0452 | 0452 | yes | 0
13959134 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0454 | 0454 | yes | 0
13959596 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0456 | 0456 | yes | 0
13959600 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0457 | 0457 | yes | 0
13959885 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0458 | 0458 | yes | -15596.7
13961126 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0460 | 0460 | no | 0
13961317 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0462 | 0462 | yes | -62386.9
13961469 | 1.NP_SO-101 | 200 mm-200 mm | 0 | 200 mm-200 mm | 1.NP_SO-101 | 2851.29 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 200 | 0.00986929 | 100 | 200 | 90 | 200-200 | TA00.02.0463 | 0463 | yes | 0
13964608 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3140 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 103.553 | 0.00963786 | 125 | 250 | 45 | 250-250 | TA00.02.0468 | 0468 | yes
13964613 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 2980 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 103.553 | 0.00963786 | 125 | 250 | 45 | 250-250 | TA00.02.0469 | 0469 | yes
13964632 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 3275 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0470 | 0470 | yes
13964636 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 2980 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0471 | 0471 | yes
13964640 | 2.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-101 | 2980 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0472 | 0472 | yes
13964726 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3300 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0473 | 0473 | no | 0
13964900 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2262.59 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0474 | 0474 | yes | 0
13964905 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0475 | 0475 | yes | 0
13965913 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0476 | 0476 | yes | -2024544
13965923 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2153.02 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0477 | 0477 | yes | -2024544
13966854 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0479 | 0479 | no | -165269
13966951 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0480 | 0480 | no | -165269
13967230 | 4.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 4.NP_SO-101 | 6975 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0481 | 0481 | yes | 0
13967293 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 7275 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0482 | 0482 | yes | 0
13969605 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3000 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0487 | 0487 | yes
13970295 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0490 | 0490 | yes | 0
13970338 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0492 | 0492 | yes | 0
13970607 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0495 | 0495 | yes | -6931.88
13971192 | 1.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0496 | 0496 | yes
13971343 | 1.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 1.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0498 | 0498 | yes | -103177
13971510 | 1.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 1.NP_SO-101 | 3300 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0501 | 0501 | yes | -103177
13972166 | 1.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 1.NP_SO-101 | 3155 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0502 | 0502 | yes | 0
13972403 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3155 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0503 | 0503 | yes | 0
13972445 | 1.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-101 | 3155 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0504 | 0504 | yes | 0
13972447 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | -845 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0505 | 0505 | yes | 0
13999346 | 2.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 2.NP_SO-101 | 3270 | Odváděný | Zpětný vzduch | ETA 28 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0512 | 0512 | no | -41317.2
13999491 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0517 | 0517 | yes | 0
14002162 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2110 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0567 | 0567 | yes | -331686
14002223 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0568 | 0568 | yes | 0
14002227 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0569 | 0569 | yes | 0
14002272 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0570 | 0570 | yes | -95087.5
14002276 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 93.1981 | 0.00702599 | 112.5 | 225 | 45 | 225-225 | TA00.02.0571 | 0571 | yes | -95087.5
14002593 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2743 | 0.00252651 | 80 | 160 | 45.0001 | 160-160 | TA00.02.0572 | 0572 | no
14002598 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2400 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2743 | 0.00252651 | 80 | 160 | 45.0001 | 160-160 | TA00.02.0573 | 0573 | no
14002739 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0574 | 0574 | no | 0
14002817 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0575 | 0575 | no | 0
14003423 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | -850 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0578 | 0578 | yes | 0
14004616 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2600 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0586 | 0586 | yes | 0
14030094 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 4210 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0590 | 0590 | yes
14030174 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 4100 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0593 | 0593 | yes | 0
14030232 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3730 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0594 | 0594 | yes | 0
14030236 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 3730 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0595 | 0595 | yes | 0
14031027 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2110 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0597 | 0597 | yes | -331686
14031542 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 1270.11 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 400 | 0.0789531 | 200 | 400 | 90 | 400-400 | TA00.02.0600 | 0600 | yes
14031643 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0602 | 0602 | yes
14033198 | -1.PP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | -1.PP_SO-101 | 2600 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0608 | 0608 | yes | -95087.5
14033208 | 1.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 1.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0610 | 0610 | yes | -95087.5
14033545 | 2.NP_SO-101 | 315 mm-315 mm | 0 | 315 mm-315 mm | 2.NP_SO-101 | 2485 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 315 | 0.0385592 | 157.5 | 315 | 90 | 315-315 | TA00.02.0613 | 0613 | yes | 0
14035123 | -1.PP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-101 | 2520 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0622 | 0622 | yes | 0
14035127 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 3250 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0623 | 0623 | yes | 0
14035293 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2112.4 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0625 | 0625 | yes | -899798
14035644 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | 182.906 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0628 | 0628 | yes | 0
14042242 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0635 | 0635 | yes | 0
14042253 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2633.14 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0636 | 0636 | yes | 0
14042309 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2633.14 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0637 | 0637 | yes | 0
14042347 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0639 | 0639 | yes | 0
14042584 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0640 | 0640 | no | 0
14042642 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2350 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0641 | 0641 | no | 0
14042654 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2350 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0642 | 0642 | no | 0
14042709 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160.037 | 0.00505381 | 80 | 160 | 90.0131 | 160-160 | TA00.02.0643 | 0643 | no | 0
14042711 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0644 | 0644 | no | 0
14042792 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2550 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0645 | 0645 | no | 0
14042836 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2350 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0646 | 0646 | no | 0
14042852 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2350 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0647 | 0647 | no | 0
14042878 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0648 | 0648 | no | 0
14042880 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0649 | 0649 | no | 0
14044341 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0650 | 0650 | yes | 0
14044345 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0651 | 0651 | yes | 0
14044461 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0652 | 0652 | yes | 0
14044469 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0653 | 0653 | yes | 0
14044471 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0654 | 0654 | yes | 0
14044507 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0655 | 0655 | yes | 0
14044511 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0656 | 0656 | yes | 0
14044624 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2450 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0657 | 0657 | yes | 0
14044632 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0658 | 0658 | yes | 0
14044634 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2650 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0659 | 0659 | yes | 0
14045100 | 4.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 4.NP_SO-101 | -850 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0660 | 0660 | yes | 0
14045104 | 3.NP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | 3.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 160 | 0.00505308 | 80 | 160 | 90 | 160-160 | TA00.02.0661 | 0661 | yes | 0
14048255 | 4.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 4.NP_SO-101 | 2200 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 125 | 0.00240949 | 62.5 | 125 | 90 | 125-125 | TA00.02.0667 | 0667 | yes | 0
14048275 | 4.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 4.NP_SO-101 | 3900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 125 | 0.00240949 | 62.5 | 125 | 90 | 125-125 | TA00.02.0669 | 0669 | yes | 0
14049936 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0671 | 0671 | yes | 0
14049938 | 3.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 3.NP_SO-101 | 3200 | Odváděný | Odváděný vzduch | ETA 30 | ETA | 250 | 0.019276 | 125 | 250 | 90 | 250-250 | TA00.02.0672 | 0672 | yes | 0
14054623 | 3.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0686 | 0686 | yes | -103177
14054798 | 3.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 3.NP_SO-101 | 3050 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0688 | 0688 | yes
14055146 | 1.NP_SO-101 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 103.553 | 0.00963785 | 125 | 250 | 45 | 250-250 | TA00.02.0694 | 0694 | yes | 0
14055251 | 1.NP_SO-101 | 125 mm-125 mm | 0 | 125 mm-125 mm | 1.NP_SO-101 | 3200 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 51.7767 | 0.00120473 | 62.5 | 125 | 45 | 125-125 | TA00.02.0696 | 0696 | yes
14055457 | -1.PP_SO-101 | 160 mm-160 mm | 0 | 160 mm-160 mm | -1.PP_SO-101 | 2153.02 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 66.2742 | 0.0025265 | 80 | 160 | 45 | 160-160 | TA00.02.0698 | 0698 | yes | -2024544
14055554 | -1.PP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | -1.PP_SO-101 | 2450 | Odváděný | Odváděný vzduch | ETA 35 | ETA | 180 | 0.00719471 | 90 | 180 | 90 | 180-180 | TA00.02.0701 | 0701 | yes | 0
14056035 | 1.NP_SO-101 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | 120.577 | 0.037471 | 225 | 450 | 30 | 450-450 | TA00.02.0702 | 0702 | yes
14056037 | 1.NP_SO-101 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 450 | 0.112416 | 225 | 450 | 90 | 450-450 | TA00.02.0703 | 0703 | yes
14061046 | 4.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 4.NP_SO-101 | 3300 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 74.5584 | 0.00359731 | 90 | 180 | 45 | 180-180 | TA00.02.0715 | 0715 |  | 0
14061087 | 4.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 4.NP_SO-101 | 3007.09 | Odváděný | Odváděný vzduch | ETA 29 | ETA | 74.5584 | 0.00359731 | 90 | 180 | 45 | 180-180 | TA00.02.0717 | 0717 |  | 0
14061575 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0718 | 0718 |  | 0
14062024 | 4.NP_SO-101 | 280 mm-280 mm | 0 | 280 mm-280 mm | 4.NP_SO-101 | 4100 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 115.98 | 0.0135405 | 140 | 280 | 45 | 280-280 | TA00.02.0719 | 0719 |  | -53965.4
14062574 | 4.NP_SO-101 | 225 mm-225 mm | 0 | 225 mm-225 mm | 4.NP_SO-101 | 3600 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 225 | 0.0140522 | 112.5 | 225 | 90 | 225-225 | TA00.02.0722 | 0722 |  | -42261.1
14062647 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0723 | 0723 |  | 0
14062961 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0724 | 0724 |  | 0
14063006 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0725 | 0725
14063008 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0726 | 0726
14063563 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0729 | 0729 |  | 0
14063565 | 4.NP_SO-101 | 400 mm-400 mm | 0 | 400 mm-400 mm | 4.NP_SO-101 | 4090 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 165.685 | 0.0394758 | 200 | 400 | 45 | 400-400 | TA00.02.0730 | 0730 |  | 0
14064711 | 4.NP_SO-101 | 180 mm-180 mm | 0 | 180 mm-180 mm | 4.NP_SO-101 | 4100 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 74.5585 | 0.00359731 | 90 | 180 | 45 | 180-180 | TA00.02.0737 | 0737 |  | 0
