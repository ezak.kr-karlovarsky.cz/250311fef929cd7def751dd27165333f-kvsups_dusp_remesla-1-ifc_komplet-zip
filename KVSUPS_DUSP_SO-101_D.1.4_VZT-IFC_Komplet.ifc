Properties of the parts of a building model (IFC4), part 19 of 21

# IfcDuctSegment: Hranaté potrubí:POZINK/vývod (84)
Name (Hranaté potrubí:POZINK/vývod:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému = Group | Plocha (m2) | Řez | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
14060131 | 4.NP_SO-101 | 400 | 0.00529075 | 0.804233 | 1000 mm × 400 mm | 4.NP_SO-101 | 2014 | 1814 | 1814 | 1614 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 19 | 0.0148141 | 335 | ETA | 5.29075 | 1000 | 1000 × 400 | 400 | PO02.06.0654 | 0654 |  | 0
14060138 | 4.NP_SO-101 | 45 | 0.4 | 0.126 | 1000 mm × 400 mm | 4.NP_SO-101 | 1459 | 1414 | 1459 | 1414 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 19 | 0.126 | 335 | ETA | 45 | 1000 | 1000 × 400 | 400 | PO02.06.0655 | 0655
14063359 | 4.NP_SO-101 | 500 | 0.106803 | 0.667008 | 500 mm × 400 mm | 4.NP_SO-101 | 4028.91 | 3698.68 | 3887.49 | 3557.26 | Odváděný | 488.12 | 444.444 | Zpětný vzduch | ETA 19 | 0.480614 | 390 | ETA | 267.008 | 500 | 500 × 400 | 400 | PO02.06.0671 | 0671 |  | 100
14069676 | 1.NP_SO-101 | 1907.93 | 0.063 | 1.96517 | 315 mm × 200 mm | 1.NP_SO-101 | 18994.6 | 17086.7 | 18994.6 | 17086.7 | Odváděný | 272.634 | 244.66 | Zpětný vzduch | ETA 5 | 1.96517 | 241 | ETA | 1907.93 | 315 | 315 × 200 | 200 | PO02.06.0679 | 0679
14071730 | 1.NP_SO-101 | 355 | 0.0129654 | 0.178941 | 355 mm × 180 mm | 1.NP_SO-101 | 7748.85 | 7685.21 | 7634.28 | 7570.64 | Odváděný | 272.454 | 238.879 | Zpětný vzduch | ETA 5 | 0.0770721 | 250 | ETA | 72.03 | 355 | 355 × 180 | 180 | PO02.06.0692 | 0692 |  | 100
14071744 | 1.NP_SO-101 | 4132.6 | 0.0639 | 4.42188 | 180 mm × 355 mm | 1.NP_SO-101 | 12046.1 | 12046.1 | 7913.46 | 7913.46 | Odváděný | 272.454 | 238.879 | Zpětný vzduch | ETA 5 | 4.42188 | 250 | ETA | 4132.6 | 180 | 180 × 355 | 355 | PO02.06.0693 | 0693
14071849 | 1.NP_SO-101 | 355 | 0.0252862 | 0.22754 | 355 mm × 180 mm | 1.NP_SO-101 | 12437.3 | 12373.6 | 12274.3 | 12210.7 | Odváděný | 272.454 | 238.879 | Zpětný vzduch | ETA 5 | 0.150312 | 250 | ETA | 140.479 | 355 | 355 × 180 | 180 | PO02.06.0694 | 0694 |  | 100
14077816 | 4.NP_SO-101 | 200 | 0.00865214 | 0.0776868 | 125 mm × 200 mm | 4.NP_SO-101 | -1138.65 | -1238.65 | -1238.65 | -1338.65 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 0.0449911 | 376 | ETA | 69.2171 | 125 | 125 × 200 | 200 | PO02.06.0715 | 0715 |  | 0
14077998 | 4.NP_SO-101 | 7173.36 | 0.025 | 4.66268 | 125 mm × 200 mm | 4.NP_SO-101 | 6705.86 | -467.5 | 6705.86 | -467.5 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 4.66268 | 398 | ETA | 7173.36 | 125 | 125 × 200 | 200 | PO02.06.0716 | 0716 | yes | Identifikační data - Komentáře: VZT9/10/11/12
14080875 | -1.PP_SO-101 | 125 | 0.0226145 | 0.076409 | 180 mm × 125 mm | -1.PP_SO-101 | 2582.5 | 2520 | 2520 | 2457.5 | Odváděný | 163.299 | 147.541 | Zpětný vzduch | ETA 4 | 0.076638 | 386 | ETA | 125.636 | 180 | 180 × 125 | 125 | PO02.06.0722 | 0722 |  | 0
14080997 | -1.PP_SO-101 | 125 | 0.00337277 | 0.0496844 | 180 mm × 125 mm | -1.PP_SO-101 | 2582.5 | 2520 | 2520 | 2457.5 | Odváděný | 163.299 | 147.541 | Zpětný vzduch | ETA 4 | 0.0114299 | 386 | ETA | 18.7376 | 180 | 180 × 125 | 125 | PO02.06.0723 | 0723 |  | 0

# IfcDuctSegment: Kulaté potrubí:HLADKÉ POZINK/T spoj (31)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: HLADKÉ POZINK/T spoj; Označení typu: 03; Popis: Potrubí kulaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Uzamknutí velikosti: no
Jiné - Rodina: Kulaté potrubí; Id typu: 8295230; Rodina a typ: Kulaté potrubí: HLADKÉ POZINK/T spoj; Typ: HLADKÉ POZINK/T spoj
Name (Kulaté potrubí:HLADKÉ POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost = Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Koeficient ztrát | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Název systému = Group | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa
12995566 | 4.NP_SO-101 | 9000.28 | 0.0397548 | 6.36192 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2902.5 | 2790 | 2790 | 2677.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 17 | Přívodní | SUP | PO02.03.0020 | 0020 | no
13417765 | 4.NP_SO-101 | 28.6025 | 0.125636 | 0.035943 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 361 | Přívodní | SUP | PO02.03.0050 | 0050 | yes
13443775 | 4.NP_SO-101 | 22.7203 | 0.0397548 | 0.01606 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2902.5 | 2790 | 2790 | 2677.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 276 | Přívodní | SUP | PO02.03.0078 | 0078 | yes
13452714 | 4.NP_SO-101 | 889.26 | 0.0397548 | 0.628581 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 10 | Přívodní | SUP | PO02.03.0087 | 0087 | no
13453004 | 4.NP_SO-101 | 5095.91 | 0.125636 | 6.4037 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 365 | Přívodní | SUP | PO02.03.0088 | 0088 | yes
13457686 | 2.NP_SO-101 | 10767.6 | 0.0201032 | 5.41241 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 0 | 160 | Přívod vzduchu | SUP 20 | 30 | Přívodní | SUP | PO02.03.0109 | 0109 | no
13513847 | 4.NP_SO-101 | 1629.89 | 0.125636 | 2.04818 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3300 | 3300 | 1670.11 | 1670.11 | 0 | 400 | Přívod vzduchu | SUP 43 | 361 | Přívodní | SUP | PO02.03.0165 | 0165 | yes
13529263 | 4.NP_SO-101 | 164.369 | 0.0397548 | 0.116186 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2902.5 | 2790 | 2790 | 2677.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 278 | Přívodní | SUP | PO02.03.0180 | 0180 | yes
13529315 | 4.NP_SO-101 | 860 | 0.0397548 | 0.607898 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3875 | 3015 | 3875 | 3015 | 0 | 225 | Přívod vzduchu | SUP 43 | 278 | Přívodní | SUP | PO02.03.0181 | 0181 | yes
13533453 | 4.NP_SO-101 | 1021.25 | 0.0397548 | 0.721883 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 11 | Přívodní | SUP | PO02.03.0183 | 0183 | no
13533470 | 4.NP_SO-101 | 6981.88 | 0.0397548 | 4.9352 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 309 | Přívodní | SUP | PO02.03.0184 | 0184 | yes
13533640 | 4.NP_SO-101 | 832.5 | 0.0397548 | 0.58846 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 3937.5 | 3105 | 3937.5 | 3105 | 0 | 225 | Přívod vzduchu | SUP 43 | 281 | Přívodní | SUP | PO02.03.0187 | 0187 | yes
13835601 | 4.NP_SO-101 | 4840.97 | 0.125636 | 6.08335 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 361 | Přívodní | SUP | PO02.03.0378 | 0378 | yes
13932664 | 4.NP_SO-101 | 33.8006 | 0.0397548 | 0.0238922 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | 0 | 225 | Přívod vzduchu | SUP 43 | 11 | Přívodní | SUP | PO02.03.0486 | 0486 | yes
13935330 | 4.NP_SO-101 | 5267.13 | 0.061566 | 4.63321 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2930 | 2790 | 2790 | 2650 | 0 | 280 | Přívod vzduchu | SUP 43 | 292 | Přívodní | SUP | PO02.03.0493 | 0493 | yes
13935468 | 4.NP_SO-101 | 743.646 | 0.0397548 | 0.525653 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2565 | 2565 | 1821.35 | 1821.35 | 0 | 225 | Přívod vzduchu | SUP 43 | 276 | Přívodní | SUP | PO02.03.0494 | 0494 | yes
13937506 | 4.NP_SO-101 | 218.865 | 0.061566 | 0.192524 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2930 | 2790 | 2790 | 2650 | 0 | 280 | Přívod vzduchu | SUP 43 | 303 | Přívodní | SUP | PO02.03.0505 | 0505 | yes
13937624 | 4.NP_SO-101 | 249.678 | 0.061566 | 0.219628 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2930 | 2790 | 2790 | 2650 | 0 | 280 | Přívod vzduchu | SUP 43 | 301 | Přívodní | SUP | PO02.03.0506 | 0506 | yes
13971331 | 1.NP_SO-101 | 200 | 0.0254431 | 0.113097 | 180 mm | 15580 | 1.03178 | 0.0333333 | 1.30992 | 0.0333425 | 0.166713 | 1.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 0.0323157 | 180 | Zpětný vzduch | ETA 30 | 394 | Odváděný | ETA | PO02.03.0551 | 0551 | yes
13971486 | 1.NP_SO-101 | 12.5 | 0.0254431 | 0.00706858 | 180 mm | 15580 | 1.03178 | 0.0333333 | 1.30992 | 0.00208391 | 0.166713 | 1.NP_SO-101 |  | 3120 | 3120 | 3107.5 | 3107.5 | 0.00201973 | 180 | Zpětný vzduch | ETA 30 | 394 | Odváděný | ETA | PO02.03.0552 | 0552 | yes
14060592 | 4.NP_SO-101 | 1546.06 | 0.125636 | 1.94284 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 217 | Přívodní | SUP | PO02.03.0657 | 0657 | yes
14060881 | 4.NP_SO-101 | 4006.67 | 0.125636 | 5.03493 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 361 | Přívodní | SUP | PO02.03.0658 | 0658
14062521 | 4.NP_SO-101 | 85 | 0.0397548 | 0.060083 | 225 mm | 12464 | 0.422616 | 0.0333333 | 0.838347 | 0.00483332 | 0.0568626 | 4.NP_SO-101 |  | 3910 | 3910 | 3825 | 3825 | 0.0114367 | 225 | Zpětný vzduch | ETA 19 | 412 | Odváděný | ETA | PO02.03.0666 | 0666
14062975 | 4.NP_SO-101 | 628.133 | 0.125636 | 0.789335 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 361 | Přívodní | SUP | PO02.03.0670 | 0670
14070367 | 4.NP_SO-101 | 914.921 | 0.125636 | 1.14972 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 365 | Přívodní | SUP | PO02.03.0684 | 0684
14070384 | 4.NP_SO-101 | 437.143 | 0.125636 | 0.549331 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 365 | Přívodní | SUP | PO02.03.0685 | 0685
14070559 | 4.NP_SO-101 | 702.081 | 0.125636 | 0.882261 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 365 | Přívodní | SUP | PO02.03.0686 | 0686
14070658 | 4.NP_SO-101 | 229.025 | 0.125636 | 0.287801 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3900 | 3700 | 3700 | 3500 | 0 | 400 | Přívod vzduchu | SUP 43 | 365 | Přívodní | SUP | PO02.03.0687 | 0687
14076452 | 2.NP_SO-101 | 146.713 | 0.04908 | 0.115228 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3405 | 3280 | 3280 | 3155 | 0 | 250 | Přívod vzduchu | SUP 20 | 238 | Přívodní | SUP | PO02.03.0712 | 0712 | no
14076543 | 2.NP_SO-101 | 5156.3 | 0.04908 | 4.04975 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3405 | 3280 | 3280 | 3155 | 0 | 250 | Přívod vzduchu | SUP 20 | 240 | Přívodní | SUP | PO02.03.0713 | 0713 | no
14076663 | 2.NP_SO-101 | 106.025 | 0.04908 | 0.0832722 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 57.735 | 3474.76 | 3366.51 | 3313.49 | 3205.24 | 0 | 250 | Přívod vzduchu | SUP 20 | 238 | Přívodní | SUP | PO02.03.0714 | 0714

# IfcDuctSegment: Kulaté potrubí:HLADKÉ POZINK/vývod (128)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: HLADKÉ POZINK/vývod; Označení typu: 05; Popis: Potrubí kulaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Uzamknutí velikosti: no
Jiné - Rodina: Kulaté potrubí; Id typu: 9070530; Rodina a typ: Kulaté potrubí: HLADKÉ POZINK/vývod; Typ: HLADKÉ POZINK/vývod
Name (Kulaté potrubí:HLADKÉ POZINK/vývod:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Koeficient ztrát | Typ systému | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Název systému = Group | Řez | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13321210 | 4.NP_SO-101 | 5881.65 | 0.125636 | 7.3911 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3650 | 3550 | 3550 | 3450 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 413 | ETA | PO02.05.0030 | 0030 | yes | Identifikační data - Komentáře: VZT3
13409983 | 1.NP_SO-101 | 11373 | 0.04908 | 8.93234 | 250 mm | 0 | 250 mm | 8413.18 | 0.155969 | 0.025 | 0.509296 | 0.0586529 | 0.020703 | 1.NP_SO-101 | 0 | 3275 | 3150 | 3150 | 3025 | 0.376055 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 111 | ETA | PO02.05.0039 | 0039 | no
13410324 | -1.PP_SO-101 | 1168.19 | 0.0397548 | 0.825744 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | 3993.19 | 2825 | 3993.19 | 2825 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 356 | SUP | PO02.05.0041 | 0041 | yes | Identifikační data - Komentáře: VZT1
13410709 | 1.NP_SO-101 | 1427.1 | 0.0397548 | 1.00876 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3112.5 | 3000 | 3000 | 2887.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 191 | SUP | PO02.05.0042 | 0042 | yes | Identifikační data - Komentáře: VZT1
13410902 | 1.NP_SO-101 | 2643.41 | 0.0201032 | 1.32872 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3080 | 3000 | 3000 | 2920 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 331 | SUP | PO02.05.0043 | 0043 | yes
13410910 | 1.NP_SO-101 | 2080 | 0.0201032 | 1.04552 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3080 | 3000 | 3000 | 2920 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 27 | 331 | SUP | PO02.05.0044 | 0044 | yes
13421915 | -1.PP_SO-101 | 459.465 | 0.0397548 | 0.324776 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2512.5 | 2400 | 2400 | 2287.5 | 0 | Odváděný | 225 | Zpětný vzduch | ETA 30 | 351 | ETA | PO02.05.0054 | 0054 | yes
13426364 | 1.NP_SO-101 | 332.673 | 0.0201032 | 0.167219 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.00855415 | 0.0257134 | 1.NP_SO-101 | 0 | 2980 | 2900 | 2900 | 2820 | 0.0828135 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 315 | ETA | PO02.05.0057 | 0057 | yes
13438941 | 1.NP_SO-101 | 9366.8 | 0.0254431 | 5.2968 | 180 mm | 0 | 180 mm | 15580 | 1.03178 | 0.0333333 | 1.30992 | 0.438711 | 0.166713 | 1.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 0.4252 | Odváděný | 180 | Zpětný vzduch | ETA 30 | 394 | ETA | PO02.05.0061 | 0061 | no
13438968 | 1.NP_SO-101 | 169.261 | 0.01227 | 0.0664687 | 125 mm | 0 | 125 mm | 5608.78 | 0.277278 | 0.00833333 | 0.679061 | 0.0141065 | 0.0833416 | 1.NP_SO-101 | 0 | 3362.5 | 3300 | 3300 | 3237.5 | 0.0508749 | Odváděný | 125 | Zpětný vzduch | ETA 30 | 195 | ETA | PO02.05.0062 | 0062 | no
13439466 | 1.NP_SO-101 | 8010.22 | 0.0201032 | 4.02637 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.177656 | 0.0257134 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 1.71991 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 185 | ETA | PO02.05.0063 | 0063 | no
13439914 | 3.NP_SO-101 | 245.548 | 0.125636 | 0.308565 | 400 mm | 0 | 400 mm | 10516.5 | 0.0951959 | 0.05 | 0.397887 | 0.0018152 | 0.00739247 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 0.0190681 | Odváděný | 400 | Zpětný vzduch | ETA 29 | 146 | ETA | PO02.05.0066 | 0066 | yes
13443207 | 3.NP_SO-101 | 5013.67 | 0.04908 | 3.93773 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3425 | 3300 | 3300 | 3175 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 43 | 192 | SUP | PO02.05.0076 | 0076 | no
13443820 | 4.NP_SO-101 | 386.802 | 0.0397548 | 0.273414 | 225 mm | 0 | 225 mm | 12464 | 0.422616 | 0.0333333 | 0.838347 | 0.0219946 | 0.0568626 | 4.NP_SO-101 | 0 | 3712.5 | 3600 | 3600 | 3487.5 | 0.0520439 | Odváděný | 225 | Zpětný vzduch | ETA 19 | 412 | ETA | PO02.05.0079 | 0079 | yes
13456323 | 1.NP_SO-101 | 93.2908 | 0.04908 | 0.0732704 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.05.0099 | 0099 | yes | Identifikační data - Komentáře: VEDENO Z 1.PP
13456346 | 1.NP_SO-101 | 1454.54 | 0.04908 | 1.14239 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.05.0100 | 0100 | yes
13456355 | 1.NP_SO-101 | 204.791 | 0.04908 | 0.160843 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3375 | 3250 | 3250 | 3125 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 438 | ETA | PO02.05.0101 | 0101 | yes | Identifikační data - Komentáře: VZT5/6
13457493 | 2.NP_SO-101 | 3554.75 | 0.0201032 | 1.78681 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.0810839 | 0.0257134 | 2.NP_SO-101 | 0 | 2720.02 | 2640.02 | 2640.02 | 2560.02 | 0.784981 | Odváděný | 160 | Zpětný vzduch | ETA 29 | 344 | ETA | PO02.05.0104 | 0104 | yes
13457565 | 2.NP_SO-101 | 12250 | 0.04908 | 9.62113 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3405 | 3280 | 3280 | 3155 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 240 | SUP | PO02.05.0105 | 0105 | no
13457574 | 2.NP_SO-101 | 3433.08 | 0.04908 | 2.69633 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3525 | 3400 | 3400 | 3275 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 236 | SUP | PO02.05.0106 | 0106 | yes
13457647 | 2.NP_SO-101 | 4224.49 | 0.04908 | 3.3179 | 250 mm | 0 | 250 mm | 2804.39 | 0.0173299 | 0.00833333 | 0.169765 | 0.0120536 | 0.0031163 | 2.NP_SO-101 | 0 | 3400 | 3275 | 3275 | 3150 | 0.69554 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0107 | 0107 | yes
13457656 | 2.NP_SO-101 | 1120 | 0.0201032 | 0.562973 | 160 mm | 0 | 160 mm | 13145.6 | 0.929647 | 0.025 | 1.2434 | 0.0678216 | 0.176364 | 2.NP_SO-101 | 0 | 3350 | 3270 | 3270 | 3190 | 0.0729542 | Odváděný | 160 | Zpětný vzduch | ETA 28 | 72 | ETA | PO02.05.0108 | 0108 | no
13457697 | 2.NP_SO-101 | 7280 | 0.0201032 | 3.65933 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 20 | 30 | SUP | PO02.05.0110 | 0110 | no
13457733 | 2.NP_SO-101 | 468.796 | 0.0201032 | 0.235643 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.0120543 | 0.0257134 | 2.NP_SO-101 | 0 | 3305 | 3225 | 3225 | 3145 | 0.116699 | Odváděný | 160 | Zpětný vzduch | ETA 28 | 74 | ETA | PO02.05.0111 | 0111 | no
13457910 | 2.NP_SO-101 | 6676.3 | 0.0201032 | 3.35587 | 160 mm | 0 | 160 mm | 8763.72 | 0.413176 | 0.0166667 | 0.828932 | 0.199139 | 0.0860334 | 2.NP_SO-101 | 0 | 3350 | 3270 | 3270 | 3190 | 0.481971 | Odváděný | 160 | Zpětný vzduch | ETA 28 | 14 | ETA | PO02.05.0112 | 0112 | no
13458114 | 2.NP_SO-101 | 4840 | 0.0201032 | 2.43285 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 275 | SUP | PO02.05.0113 | 0113 | yes | Identifikační data - Komentáře: VZT4
13479598 | 2.NP_SO-101 | 696.863 | 0.0397548 | 0.492583 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3512.5 | 3400 | 3400 | 3287.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 20 | 34 | SUP | PO02.05.0123 | 0123 | yes
13479645 | 2.NP_SO-101 | 10931.4 | 0.0397548 | 7.72696 | 225 mm | 0 | 225 mm | 18695.9 | 0.950885 | 0.05 | 1.25752 | 0.196823 | 0.116957 | 2.NP_SO-101 | 0 | 3252.5 | 3140 | 3140 | 3027.5 | 0.206989 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 43 | ETA | PO02.05.0124 | 0124 | no
13479653 | 2.NP_SO-101 | 253.134 | 0.0779194 | 0.250502 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3297.5 | 3140 | 3140 | 2982.5 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 64 | ETA | PO02.05.0125 | 0125 | yes
13479816 | 2.NP_SO-101 | 6557.58 | 0.0201032 | 3.2962 | 160 mm | 0 | 160 mm | 13145.6 | 0.929647 | 0.025 | 1.2434 | 1.15652 | 0.176364 | 2.NP_SO-101 | 0 | 3220 | 3140 | 3140 | 3060 | 1.24404 | Odváděný | 160 | Zpětný vzduch | ETA 28 | 19 | ETA | PO02.05.0126 | 0126 | no
13480246 | 2.NP_SO-101 | 1234.94 | 0.0779194 | 1.2221 | 315 mm | 0 | 315 mm | 4451.42 | 0.0275026 | -0.0166667 | 0.213864 | 0.00422409 | 0.00342047 | 2.NP_SO-101 | 0 | 3257.5 | 3100 | 3100 | 2942.5 | 0.153589 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 235 | SUP | PO02.05.0127 | 0127 | yes
13502512 | 1.NP_SO-101 | 3225 | 0.0397548 | 2.27962 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3112.5 | 3000 | 3000 | 2887.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 216 | SUP | PO02.05.0131 | 0131 | yes
13502525 | 1.NP_SO-101 | 10279 | 0.0397548 | 7.26579 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3112.5 | 3000 | 3000 | 2887.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 216 | SUP | PO02.05.0132 | 0132 | no
13505259 | 2.NP_SO-101 | 2087.7 | 0.04908 | 1.63968 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3525 | 3400 | 3400 | 3275 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 65 | SUP | PO02.05.0133 | 0133 | yes
13505409 | 2.NP_SO-101 | 213.624 | 0.0779194 | 0.211402 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 2642.5 | 2485 | 2485 | 2327.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 45 | SUP | PO02.05.0134 | 0134 | yes
13505420 | 2.NP_SO-101 | 9.22156 | 0.0779194 | 0.00912567 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 2642.5 | 2485 | 2485 | 2327.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 45 | SUP | PO02.05.0135 | 0135 | yes
13505486 | 2.NP_SO-101 | 78.4567 | 0.0779194 | 0.0776409 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | 3159.11 | 2992.26 | 3047.74 | 2880.89 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 64 | ETA | PO02.05.0136 | 0136 | yes
13505498 | 2.NP_SO-101 | 754.124 | 0.0779194 | 0.746282 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3057.5 | 2900 | 2900 | 2742.5 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 40 | ETA | PO02.05.0137 | 0137 | yes
13505507 | 2.NP_SO-101 | 172.5 | 0.0779194 | 0.170706 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3057.5 | 2900 | 2900 | 2742.5 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 29 | ETA | PO02.05.0138 | 0138 | yes
13505526 | 2.NP_SO-101 | 418.264 | 0.0779194 | 0.413915 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | 2585 | 2585 | 2166.74 | 2166.74 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 29 | ETA | PO02.05.0139 | 0139 | yes
13505760 | 2.NP_SO-101 | 3.26389 | 0.0779194 | 0.00322995 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | 2170 | 2170 | 2166.74 | 2166.74 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 45 | SUP | PO02.05.0145 | 0145 | yes
13508773 | 2.NP_SO-101 | 5372.31 | 0.0201032 | 2.70042 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3480 | 3400 | 3400 | 3320 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 195 | SUP | PO02.05.0154 | 0154 | no | Identifikační data - Komentáře: VEDENO ZE 3.NP
13508874 | 2.NP_SO-101 | 3086.07 | 0.0201032 | 1.55123 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.0721237 | 0.0257134 | 2.NP_SO-101 | 0 | 3480 | 3400 | 3400 | 3320 | 0.698236 | Odváděný | 160 | Zpětný vzduch | ETA 19 | 228 | ETA | PO02.05.0155 | 0155 | no
13509077 | 2.NP_SO-101 | 4730.75 | 0.0201032 | 2.37794 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3480 | 3400 | 3400 | 3320 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 20 | 33 | SUP | PO02.05.0156 | 0156 | no
13509215 | 2.NP_SO-101 | 1542.99 | 0.0201032 | 0.77559 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3480 | 3400 | 3400 | 3320 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 20 | 33 | SUP | PO02.05.0157 | 0157 | no
13509323 | 2.NP_SO-101 | 4561.79 | 0.0201032 | 2.29301 | 160 mm | 0 | 160 mm | 13145.6 | 0.929647 | 0.025 | 1.2434 | 0.0534946 | 0.176364 | 2.NP_SO-101 | 0 | 3220 | 3140 | 3140 | 3060 | 0.0575429 | Odváděný | 160 | Zpětný vzduch | ETA 28 | 19 | ETA | PO02.05.0158 | 0158 | no
13509393 | 2.NP_SO-101 | 1911.45 | 0.04908 | 1.50125 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3400 | 3275 | 3275 | 3150 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0159 | 0159 | yes
13509795 | 2.NP_SO-101 | 3346.24 | 0.04908 | 2.62813 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3265 | 3140 | 3140 | 3015 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0160 | 0160 | yes
13523233 | 1.NP_SO-101 | 2836.15 | 0.0201032 | 1.4256 | 160 mm | 0 | 160 mm | 8763.72 | 0.413176 | 0.0166667 | 0.828932 | 0.103665 | 0.0860334 | 1.NP_SO-101 | 0 | 2980 | 2900 | 2900 | 2820 | 0.250899 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 439 | ETA | PO02.05.0174 | 0174 | yes
13523682 | 1.NP_SO-101 | 2860 | 0.0201032 | 1.43759 | 160 mm | 0 | 160 mm | 8763.72 | 0.413176 | 0.0166667 | 0.828932 | 0.0231935 | 0.0860334 | 1.NP_SO-101 | 0 | 3230 | 3150 | 3150 | 3070 | 0.0561346 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 183 | ETA | PO02.05.0175 | 0175 | no
13527670 | 4.NP_SO-101 | 13.9514 | 0.125636 | 0.0175319 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 413 | ETA | PO02.05.0176 | 0176 | yes
13527681 | 4.NP_SO-101 | 432.304 | 0.125636 | 0.54325 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 100 | 4114.26 | 3667.16 | 3972.84 | 3525.74 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 413 | ETA | PO02.05.0177 | 0177 | yes
13528981 | 4.NP_SO-101 | 219.39 | 0.125636 | 0.275694 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 281 | ETA | PO02.05.0179 | 0179 | yes
13537851 | 1.NP_SO-101 | 1371.46 | 0.0397548 | 0.969425 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 |  | 2775 | 1403.54 | 2775 | 1403.54 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 27 | 191 | SUP | PO02.05.0189 | 0189 | yes
13538762 | -1.PP_SO-101 | 1322.89 | 0.04908 | 1.03899 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2475 | 2350 | 2350 | 2225 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 32 | 11 | ETA | PO02.05.0191 | 0191 | yes | Identifikační data - Komentáře: odtah spalin od plynové pece napojeno do stávajícího komínového tělesa
13538795 | -1.PP_SO-101 | 950 | 0.04908 | 0.746128 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | 2100 | 1150 | 2100 | 1150 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 32 | 11 | ETA | PO02.05.0192 | 0192 | yes
13624514 | -1.PP_SO-101 | 756.189 | 0.04908 | 0.59391 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2525 | 2400 | 2400 | 2275 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 385 | ETA | PO02.05.0235 | 0235 | yes
13626266 | -1.PP_SO-101 | 313.948 | 0.04908 | 0.246574 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2475 | 2350 | 2350 | 2225 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 32 | 11 | ETA | PO02.05.0242 | 0242 | yes | Identifikační data - Komentáře: stávající komínové těleso
13626638 | 2.NP_SO-101 | 3165.02 | 0.0201032 | 1.59091 | 160 mm | 0 | 160 mm | 4381.86 | 0.103294 | 0.00833333 | 0.414466 | 0.0813835 | 0.0257134 | 2.NP_SO-101 | 433206 | 2480.04 | -685 | 2480.02 | -685.019 | 0.787881 | Odváděný | 160 | Zpětný vzduch | ETA 29 | 344 | ETA | PO02.05.0244 | 0244 | yes
13626733 | 2.NP_SO-101 | 3075 | 0.0201032 | 1.54566 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | 2390 | -685 | 2390 | -685 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 275 | SUP | PO02.05.0245 | 0245 | yes
13711418 | -1.PP_SO-101 | 6.54311 | 0.0989649 | 0.0072973 | 355 mm | 0 | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | -322.5 | -500 | -500 | -677.5 | 0 | Čerstvý | 355 | Přívod vzduchu | ODA 18 | 2 | ODA | PO02.05.0271 | 0271 | no
13711420 | -1.PP_SO-101 | 185 | 0.0779194 | 0.183076 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | -850 | -1035 | -850 | -1035 | 0 | Čerstvý | 315 | Přívod vzduchu | ODA 18 | 3 | ODA | PO02.05.0272 | 0272 | no
13711558 | -1.PP_SO-101 | 225 | 0.0779194 | 0.22266 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | -342.5 | -500 | -500 | -657.5 | 0 | Čerstvý | 315 | Přívod vzduchu | ODA 18 | 3 | ODA | PO02.05.0273 | 0273 | no
13738965 | -1.PP_SO-101 | 622.058 | 0.04908 | 0.488563 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2525 | 2400 | 2400 | 2275 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 385 | ETA | PO02.05.0298 | 0298 | yes
13828398 | 2.NP_SO-101 | 6867.24 | 0.0779194 | 6.79583 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3557.5 | 3400 | 3400 | 3242.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 3 | SUP | PO02.05.0351 | 0351 | yes
13829060 | 2.NP_SO-101 | 2843.64 | 0.0989649 | 3.17141 | 355 mm | 0 | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3317.5 | 3140 | 3140 | 2962.5 | 0 | Odváděný | 355 | Zpětný vzduch | ETA 28 | 68 | ETA | PO02.05.0352 | 0352 | yes
13829432 | 2.NP_SO-101 | 13.9275 | 0.0779194 | 0.0137827 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3297.5 | 3140 | 3140 | 2982.5 | 0 | Odváděný | 315 | Zpětný vzduch | ETA 28 | 16 | ETA | PO02.05.0353 | 0353 | yes
13829856 | 2.NP_SO-101 | 219.645 | 0.04908 | 0.172509 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3525 | 3400 | 3400 | 3275 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 238 | SUP | PO02.05.0354 | 0354 | yes
13829898 | 2.NP_SO-101 | 219.645 | 0.04908 | 0.172509 | 250 mm | 0 | 250 mm | 14022 | 0.433247 | 0.0416667 | 0.848826 | 0.0111736 | 0.0508712 | 2.NP_SO-101 | 0 | 3350 | 3225 | 3225 | 3100 | 0.0257904 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 2 | ETA | PO02.05.0355 | 0355 | yes
13830117 | 2.NP_SO-101 | 49.4573 | 0.04908 | 0.0388437 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3525 | 3400 | 3400 | 3275 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 238 | SUP | PO02.05.0356 | 0356 | yes
13830167 | 2.NP_SO-101 | 54.5386 | 0.04908 | 0.0428345 | 250 mm | 0 | 250 mm | 14022 | 0.433247 | 0.0416667 | 0.848826 | 0.00277444 | 0.0508712 | 2.NP_SO-101 | 0 | 3350 | 3225 | 3225 | 3100 | 0.00640384 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 2 | ETA | PO02.05.0357 | 0357 | yes
13830385 | 2.NP_SO-101 | 460.03 | 0.0397548 | 0.325176 | 225 mm | 0 | 225 mm | 18695.9 | 0.950885 | 0.05 | 1.25752 | 0.0538036 | 0.116957 | 2.NP_SO-101 | 0 | 3252.5 | 3140 | 3140 | 3027.5 | 0.0565826 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 4 | ETA | PO02.05.0358 | 0358 | yes
13830506 | 2.NP_SO-101 | 281.958 | 0.0397548 | 0.199304 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3512.5 | 3400 | 3400 | 3287.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 20 | 54 | SUP | PO02.05.0359 | 0359 | yes
13830582 | 2.NP_SO-101 | 9309.69 | 0.0397548 | 6.58063 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3512.5 | 3400 | 3400 | 3287.5 | 0 | Přívodní | 225 | Přívod vzduchu | SUP 20 | 38 | SUP | PO02.05.0360 | 0360 | no
13830660 | 2.NP_SO-101 | 218.595 | 0.0397548 | 0.154516 | 225 mm | 0 | 225 mm | 18695.9 | 0.950885 | 0.05 | 1.25752 | 0.0255662 | 0.116957 | 2.NP_SO-101 | 0 | 3252.5 | 3140 | 3140 | 3027.5 | 0.0268867 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 36 | ETA | PO02.05.0361 | 0361 | no
13830747 | 2.NP_SO-101 | 127.316 | 0.04908 | 0.0999941 | 250 mm | 15 | 280 mm | 5608.78 | 0.0693195 | -0.0166667 | 0.339531 | 0.00130214 | 0.0102276 | 2.NP_SO-101 | 0 | 3225 | 3100 | 3100 | 2975 | 0.0187846 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 232 | SUP | PO02.05.0362 | 0362 | yes | Izolace - Typ izolace: Protipožární
13830823 | 2.NP_SO-101 | 1014.19 | 0.0397548 | 0.716889 | 225 mm | 0 | 225 mm | 9347.97 | 0.237721 | 0.025 | 0.62876 | 0.0347392 | 0.0342532 | 2.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 0.146134 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 49 | ETA | PO02.05.0363 | 0363 | no
13830846 | 2.NP_SO-101 | 11884.9 | 0.0397548 | 8.40095 | 225 mm | 0 | 225 mm | 9347.97 | 0.237721 | 0.025 | 0.62876 | 0.0524278 | 0.0342532 | 2.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 0.220543 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 49 | ETA | PO02.05.0364 | 0364 | no
13834748 | 2.NP_SO-101 | 406.053 | 0.04908 | 0.318913 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3525 | 3400 | 3400 | 3275 | 0 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 238 | SUP | PO02.05.0373 | 0373 | no
13834762 | 2.NP_SO-101 | 405.805 | 0.04908 | 0.318719 | 250 mm | 0 | 250 mm | 14022 | 0.433247 | 0.0416667 | 0.848826 | 0.0206438 | 0.0508712 | 2.NP_SO-101 | 0 | 3350 | 3225 | 3225 | 3100 | 0.047649 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 2 | ETA | PO02.05.0374 | 0374 | no
13835138 | 3.NP_SO-101 | 13660 | 0.0201032 | 6.86626 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3190.97 | 3110.97 | 3110.97 | 3030.97 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 43 | 320 | SUP | PO02.05.0376 | 0376 | no
13840979 | -1.PP_SO-101 | 200 | 0.0201032 | 0.100531 | 160 mm | 0 | 160 mm | 61346.1 | 20.2456 | 0.116667 | 5.80252 | 0.587235 | 2.93618 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 0.0290055 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 354 | ETA | PO02.05.0380 | 0380 | yes
13841135 | -1.PP_SO-101 | 3141.05 | 0.0201032 | 1.57887 | 160 mm | 0 | 160 mm | 61346.1 | 20.2456 | 0.116667 | 5.80252 | 8.1363 | 2.93618 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 0.401879 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 354 | ETA | PO02.05.0382 | 0382 | yes
13910289 | 2.NP_SO-101 | 8081.78 | 0.04908 | 6.34741 | 250 mm | 15 | 280 mm | 5608.78 | 0.0693195 | 0.0166667 | 0.339531 | 0.0257366 | 0.0102276 | 2.NP_SO-101 | 0 | 3225 | 3100 | 3100 | 2975 | 0.371274 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 232 | SUP | PO02.05.0426 | 0426 | yes | Izolace - Typ izolace: Protipožární
13916454 | 4.NP_SO-101 | 6556.76 | 0.061566 | 5.76762 | 280 mm | 0 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3980.01 | 3840.01 | 3840 | 3700 | 0 | Odváděný | 280 | Zpětný vzduch | ETA 12 | 405 | ETA | PO02.05.0429 | 0429 | yes
13918316 | 2.NP_SO-101 | 5843.03 | 0.04908 | 4.58911 | 250 mm | 0 | 250 mm | 14022 | 0.433247 | 0.0416667 | 0.848826 | 0.100944 | 0.0508712 | 2.NP_SO-101 | 0 | 3350 | 3225 | 3225 | 3100 | 0.232994 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 2 | ETA | PO02.05.0433 | 0433 | no
13918669 | 2.NP_SO-101 | 2790.4 | 0.0201032 | 1.40261 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3360 | 3280 | 3280 | 3200 | 0 | Přívodní | 160 | Přívod vzduchu | SUP 20 | 6 | SUP | PO02.05.0434 | 0434 | no
13925203 | 2.NP_SO-101 | 133.247 | 0.04908 | 0.104652 | 250 mm | 15 | 280 mm | 5608.78 | 0.0693195 | -0.0166667 | 0.339531 | 0.00136279 | 0.0102276 | 2.NP_SO-101 | 0 | 3225 | 3100 | 3100 | 2975 | 0.0196595 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 232 | SUP | PO02.05.0452 | 0452 | yes | Izolace - Typ izolace: Protipožární
13925422 | 2.NP_SO-101 | 140 | 0.04908 | 0.109956 | 250 mm | 15 | 280 mm | 5608.78 | 0.0693195 | -0.0166667 | 0.339531 | 0.00143186 | 0.0102276 | 2.NP_SO-101 | 0 | 3225 | 3100 | 3100 | 2975 | 0.0206559 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 232 | SUP | PO02.05.0453 | 0453 | yes | Izolace - Typ izolace: Protipožární
13925530 | 2.NP_SO-101 | 1113.86 | 0.0397548 | 0.787342 | 225 mm | 0 | 225 mm | 9347.97 | 0.237721 | 0.025 | 0.62876 | 0.0381532 | 0.0342532 | 2.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 0.160496 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 49 | ETA | PO02.05.0454 | 0454 | yes
13925667 | 2.NP_SO-101 | 100 | 0.0397548 | 0.0706858 | 225 mm | 0 | 225 mm | 9347.97 | 0.237721 | 0.025 | 0.62876 | 0.00342532 | 0.0342532 | 2.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 0.014409 | Odváděný | 225 | Zpětný vzduch | ETA 28 | 49 | ETA | PO02.05.0455 | 0455 | yes
13928236 | -1.PP_SO-101 | 220 | 0.0779194 | 0.217712 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 |  | -815 | -1035 | -815 | -1035 | 0 | Čerstvý | 315 | Přívod vzduchu | ODA 18 | 3 | ODA | PO02.05.0468 | 0468 | no
13928248 | -1.PP_SO-101 | 247.716 | 0.0779194 | 0.24514 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | -1192.5 | -1350 | -1350 | -1507.5 | 0 | Čerstvý | 315 | Přívod vzduchu | ODA 18 | 3 | ODA | PO02.05.0469 | 0469 | no | Identifikační data - Komentáře: přívod spalovacího vzduchu vedeno v podlaze
13931934 | 2.NP_SO-101 | 960 | 0.0779194 | 0.950018 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3557.5 | 3400 | 3400 | 3242.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 3 | SUP | PO02.05.0483 | 0483 | yes
13964191 | 2.NP_SO-101 | 25.9724 | 0.0779194 | 0.0257023 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 2642.5 | 2485 | 2485 | 2327.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 45 | SUP | PO02.05.0525 | 0525 | yes
13964597 | 2.NP_SO-101 | 530.312 | 0.04908 | 0.416506 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3105 | 2980 | 2980 | 2855 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0526 | 0526 | yes
13964606 | 2.NP_SO-101 | 19.1672 | 0.04908 | 0.0150539 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | 3155.16 | 3053.22 | 3066.78 | 2964.84 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0527 | 0527 | yes
13964619 | 2.NP_SO-101 | 1031.82 | 0.04908 | 0.810388 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3105 | 2980 | 2980 | 2855 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0528 | 0528 | yes
13964630 | 2.NP_SO-101 | 210.086 | 0.04908 | 0.165001 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 100 | 3290.17 | 3053.22 | 3201.78 | 2964.83 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 28 | 70 | ETA | PO02.05.0529 | 0529 | yes
13965701 | -1.PP_SO-101 | 233.726 | 0.0201032 | 0.117483 | 160 mm | 0 | 160 mm | 61346.1 | 20.2456 | 0.116667 | 5.80252 | 0.68626 | 2.93618 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 0.0338967 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 354 | ETA | PO02.05.0532 | 0532 | yes
13965903 | -1.PP_SO-101 | 287.452 | 0.0201032 | 0.144489 | 160 mm | 0 | 160 mm | 61346.1 | 20.2456 | 0.116667 | 5.80252 | 0.844009 | 2.93618 | -1.PP_SO-101 | 100 | 2459.71 | 2199.88 | 2403.14 | 2143.31 | 0.0416884 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 354 | ETA | PO02.05.0533 | 0533 | yes
13965917 | -1.PP_SO-101 | 191.743 | 0.0201032 | 0.0963804 | 160 mm | 0 | 160 mm | 61346.1 | 20.2456 | 0.116667 | 5.80252 | 0.56299 | 2.93618 | -1.PP_SO-101 | 0 | 2233.02 | 2153.02 | 2153.02 | 2073.02 | 0.027808 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 354 | ETA | PO02.05.0534 | 0534 | yes
13969263 | 2.NP_SO-101 | 65 | 0.0779194 | 0.0643241 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 | 0 | 3257.5 | 3100 | 3100 | 2942.5 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 227 | SUP | PO02.05.0545 | 0545 | yes
14030721 | 1.NP_SO-101 | 1651.99 | 0.01227 | 0.648735 | 125 mm | 0 | 125 mm | 5608.78 | 0.277278 | 0.00833333 | 0.679061 | 0.114369 | 0.0833416 | 1.NP_SO-101 | 0 | 3262.5 | 3200 | 3200 | 3137.5 | 0.41247 | Odváděný | 125 | Zpětný vzduch | ETA 30 | 423 | ETA | PO02.05.0582 | 0582 | yes
14033434 | 2.NP_SO-101 | 180.694 | 0.04908 | 0.141917 | 250 mm | 15 | 280 mm | 5608.78 | 0.0693195 | -0.0166667 | 0.339531 | 0.00184806 | 0.0102276 | 2.NP_SO-101 | 0 | 3225 | 3100 | 3100 | 2975 | 0.02666 | Přívodní | 250 | Přívod vzduchu | SUP 20 | 232 | SUP | PO02.05.0592 | 0592 | yes | Izolace - Typ izolace: Protipožární
14033532 | 2.NP_SO-101 | 40.9 | 0.0779194 | 0.0404747 | 315 mm | 0 | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-101 |  | 2840.9 | 2800 | 2840.9 | 2800 | 0 | Přívodní | 315 | Přívod vzduchu | SUP 20 | 45 | SUP | PO02.05.0593 | 0593 | yes
14044457 | -1.PP_SO-101 | 22.9365 | 0.0201032 | 0.0115291 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 428 | ETA | PO02.05.0612 | 0612 | yes
14052093 | 4.NP_SO-101 | 926.603 | 0.061566 | 0.815083 | 280 mm | 0 | 280 mm | 17527.4 | 0.539659 | 0.0583333 | 0.947351 | 0.0496593 | 0.0535929 | 4.NP_SO-101 | 0 | 4015 | 3875 | 3875 | 3735 | 0.0920198 | Odváděný | 280 | Zpětný vzduch | ETA 19 | 409 | ETA | PO02.05.0631 | 0631 | yes
14055242 | 1.NP_SO-101 | 1478.75 | 0.0201032 | 0.743302 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 2980 | 2900 | 2900 | 2820 | 0 | Odváděný | 160 | Zpětný vzduch | ETA 30 | 239 | ETA | PO02.05.0641 | 0641 | yes
14055448 | -1.PP_SO-101 | 1447.5 | 0.04908 | 1.13686 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2525 | 2400 | 2400 | 2275 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 385 | ETA | PO02.05.0642 | 0642 | yes
14060486 | 4.NP_SO-101 | 13.5416 | 0.125636 | 0.0170169 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0656 | 0656
14061507 | 4.NP_SO-101 | 4834.31 | 0.125636 | 6.07498 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0661 | 0661
14061565 | 4.NP_SO-101 | 10.954 | 0.125636 | 0.0137652 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0662 | 0662
14061630 | 4.NP_SO-101 | 999.508 | 0.125636 | 1.25602 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0663 | 0663
14062006 | 4.NP_SO-101 | 2200.93 | 0.061566 | 1.93604 | 280 mm | 0 | 280 mm | 7511.76 | 0.0991211 | 0.025 | 0.406008 | 0.0265453 | 0.012061 | 4.NP_SO-101 | 0 | 4240 | 4100 | 4100 | 3960 | 0.267807 | Odváděný | 280 | Zpětný vzduch | ETA 19 | 398 | ETA | PO02.05.0664 | 0664
14062017 | 4.NP_SO-101 | 86.2385 | 0.061566 | 0.0758593 | 280 mm | 0 | 280 mm | 17527.4 | 0.539659 | 0.0583333 | 0.947351 | 0.00462177 | 0.0535929 | 4.NP_SO-101 | 100 | 4116.98 | 4017.99 | 3957.01 | 3858.02 | 0.00856423 | Odváděný | 280 | Zpětný vzduch | ETA 19 | 409 | ETA | PO02.05.0665 | 0665
14062567 | 4.NP_SO-101 | 795.912 | 0.061566 | 0.700121 | 280 mm | 0 | 280 mm | 17527.4 | 0.539659 | 0.0583333 | 0.947351 | 0.0426552 | 0.0535929 | 4.NP_SO-101 | 0 | 4240 | 4100 | 4100 | 3960 | 0.079041 | Odváděný | 280 | Zpětný vzduch | ETA 19 | 409 | ETA | PO02.05.0667 | 0667
14062639 | 4.NP_SO-101 | 625.402 | 0.125636 | 0.785903 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0668 | 0668
14062799 | 4.NP_SO-101 | 5331.32 | 0.125636 | 6.69953 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4290 | 4090 | 4090 | 3890 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 395 | ETA | PO02.05.0669 | 0669
14065611 | 4.NP_SO-101 | 9.95646 | 0.061566 | 0.00875816 | 280 mm | 0 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3980.01 | 3840.01 | 3840.01 | 3700.01 | 0 | Odváděný | 280 | Zpětný vzduch | ETA 12 | 405 | ETA | PO02.05.0674 | 0674
14065632 | 4.NP_SO-101 | 275.852 | 0.061566 | 0.242652 | 280 mm | 0 | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3980 | 3840 | 3840 | 3700 | 0 | Odváděný | 280 | Zpětný vzduch | ETA 12 | 405 | ETA | PO02.05.0675 | 0675
14066450 | 4.NP_SO-101 | 80.0508 | 0.061566 | 0.0704164 | 280 mm | 0 | 280 mm | 17527.4 | 0.539659 | 0.0583333 | 0.947351 | 0.00429015 | 0.0535929 | 4.NP_SO-101 | 57.735 | 3998.76 | 3837.49 | 3877.51 | 3716.24 | 0.00794975 | Odváděný | 280 | Zpětný vzduch | ETA 19 | 409 | ETA | PO02.05.0676 | 0676
14070096 | 4.NP_SO-101 | 8428.93 | 0.0397548 | 5.95806 | 225 mm | 0 | 225 mm | 12464 | 0.422616 | 0.0333333 | 0.838347 | 0.453363 | 0.0568626 | 4.NP_SO-101 | 0 | 3712.5 | 3600 | 3600 | 3487.5 | 1.07276 | Odváděný | 225 | Zpětný vzduch | ETA 19 | 412 | ETA | PO02.05.0682 | 0682 | yes
14070201 | 4.NP_SO-101 | 302.845 | 0.0397548 | 0.214069 | 225 mm | 0 | 225 mm | 12464 | 0.422616 | 0.0333333 | 0.838347 | 0.0172206 | 0.0568626 | 4.NP_SO-101 | 0 | 3712.5 | 3600 | 3600 | 3487.5 | 0.0407476 | Odváděný | 225 | Zpětný vzduch | ETA 19 | 412 | ETA | PO02.05.0683 | 0683
14070738 | 4.NP_SO-101 | 702.081 | 0.125636 | 0.882261 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3750 | 3550 | 3550 | 3350 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 413 | ETA | PO02.05.0688 | 0688
14070847 | 4.NP_SO-101 | 207.731 | 0.125636 | 0.261042 | 400 mm | 0 | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3750 | 3550 | 3550 | 3350 | 0 | Odváděný | 400 | Zpětný vzduch | ETA 19 | 413 | ETA | PO02.05.0689 | 0689
14072107 | 1.NP_SO-101 | 66.0254 | 0.04908 | 0.0518562 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 57.735 | 3224.76 | 3083.49 | 3116.51 | 2975.24 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.05.0695 | 0695
14072125 | 1.NP_SO-101 | 880.281 | 0.04908 | 0.691371 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3175 | 3050 | 3050 | 2925 | 0 | Odváděný | 250 | Zpětný vzduch | ETA 30 | 455 | ETA | PO02.05.0696 | 0696

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (298)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.2 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: SPIRO; Název typu: SPIRO POZINK/T spoj; Označení typu: 02; Popis: Potrubí spiro pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Uzamknutí velikosti: no
Jiné - Id typu: 352285; Rodina: Kulaté potrubí; Rodina a typ: Kulaté potrubí: SPIRO POZINK/T spoj; Typ: SPIRO POZINK/T spoj
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému = Group | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa
12987202 | 4.NP_SO-101 | 266.254 | 0.0201032 | 0.133834 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0048044 | 0.0259205 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0.0465118 | ETA 29 | 232 | Odváděný | ETA | PO02.02.0005 | 0005 | no
12987255 | 4.NP_SO-101 | 135.628 | 0.01227 | 0.0532611 | 125 mm | 0 | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2537.88 | 2402.25 | 2537.88 | 2402.25 | 125 | Zpětný vzduch | 0 | ETA 29 | 313 | Odváděný | ETA | PO02.02.0006 | 0006 | no
12987265 | 4.NP_SO-101 | 158.141 | 0.0201032 | 0.0794901 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0 | ETA 29 | 232 | Odváděný | ETA | PO02.02.0007 | 0007 | no
12987277 | 4.NP_SO-101 | 3237.13 | 0.0201032 | 1.62716 | 160 mm | 0 | 160 mm | 0.929647 | 0.025 | 13145.6 | 1.2434 | 0.0281191 | 0.179304 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0.030247 | ETA 29 | 13 | Odváděný | ETA | PO02.02.0008 | 0008 | no
12987448 | 4.NP_SO-101 | 259.473 | 0.0201032 | 0.130426 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2790.13 | 2710.13 | 2710.13 | 2630.13 | 160 | Zpětný vzduch | 0 | ETA 29 | 315 | Odváděný | ETA | PO02.02.0009 | 0009 | no
12987496 | 4.NP_SO-101 | 636.893 | 0.0201032 | 0.320138 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0144116 | 0.0259205 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0.13952 | ETA 29 | 242 | Odváděný | ETA | PO02.02.0010 | 0010 | no
12987509 | 4.NP_SO-101 | 190.126 | 0.0201032 | 0.0955676 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 |  | 2550.13 | 2360 | 2550.13 | 2360 | 160 | Zpětný vzduch | 0 | ETA 29 | 315 | Odváděný | ETA | PO02.02.0011 | 0011 | no
12987519 | 4.NP_SO-101 | 100.031 | 0.0201032 | 0.0502812 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0 | ETA 29 | 242 | Odváděný | ETA | PO02.02.0012 | 0012 | no
12987529 | 4.NP_SO-101 | 1938.58 | 0.0201032 | 0.974436 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.0260373 | 0.0871367 | 4.NP_SO-101 | 0 | 2280 | 2200 | 2200 | 2120 | 160 | Zpětný vzduch | 0.0630173 | ETA 29 | 15 | Odváděný | ETA | PO02.02.0013 | 0013 | no
12987657 | 4.NP_SO-101 | 820 | 0.01227 | 0.322013 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.0541508 | 0.0843391 | 4.NP_SO-101 | 0 | 3962.5 | 3900 | 3900 | 3837.5 | 125 | Zpětný vzduch | 0.195294 | ETA 19 | 311 | Odváděný | ETA | PO02.02.0014 | 0014 | yes
12988176 | 4.NP_SO-101 | 424.655 | 0.01227 | 0.166762 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.035815 | 0.0843391 | 4.NP_SO-101 | 0 | 3962.5 | 3900 | 3900 | 3837.5 | 125 | Zpětný vzduch | 0.129167 | ETA 19 | 309 | Odváděný | ETA | PO02.02.0015 | 0015 | yes
12988186 | 4.NP_SO-101 | 1155 | 0.01227 | 0.453567 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.0813394 | 0.0843391 | 4.NP_SO-101 | 0 | 3962.5 | 3900 | 3900 | 3837.5 | 125 | Zpětný vzduch | 0.29335 | ETA 19 | 309 | Odváděný | ETA | PO02.02.0016 | 0016 | yes
12988259 | 4.NP_SO-101 | 953.913 | 0.01227 | 0.374601 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.0402261 | 0.0843391 | 4.NP_SO-101 | 0 | 2262.5 | 2200 | 2200 | 2137.5 | 125 | Zpětný vzduch | 0.145075 | ETA 19 | 384 | Odváděný | ETA | PO02.02.0017 | 0017 | yes
12995168 | 3.NP_SO-101 | 6120.05 | 0.0201032 | 3.07627 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.324855 | 0.0871367 | 3.NP_SO-101 | 0 | 3280 | 3200 | 3200 | 3120 | 160 | Zpětný vzduch | 0.786237 | ETA 19 | 294 | Odváděný | ETA | PO02.02.0019 | 0019 | yes
12995967 | 4.NP_SO-101 | 12300.4 | 0.0254431 | 6.95569 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2880 | 2790 | 2790 | 2700 | 180 | Přívod vzduchu | 0 | SUP 43 | 284 | Přívodní | SUP | PO02.02.0021 | 0021 | no
12996019 | 4.NP_SO-101 | 4601.04 | 0.0201032 | 2.31273 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2870 | 2790 | 2790 | 2710 | 160 | Přívod vzduchu | 0 | SUP 43 | 285 | Přívodní | SUP | PO02.02.0022 | 0022 | no
12996436 | 3.NP_SO-101 | 2000 | 0.0201032 | 1.00531 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0320892 | 0.0259205 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Zpětný vzduch | 0.310659 | ETA 29 | 270 | Odváděný | ETA | PO02.02.0023 | 0023 | no
12996920 | 4.NP_SO-101 | 2810.62 | 0.0254431 | 1.58937 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.284801 | 0.10133 | 4.NP_SO-101 | 0 | 3990.03 | 3900.02 | 3900.03 | 3810.02 | 180 | Zpětný vzduch | 0.49072 | ETA 19 | 397 | Odváděný | ETA | PO02.02.0024 | 0024 | yes
12998163 | 4.NP_SO-101 | 3938.76 | 0.0397548 | 2.78415 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 4212.5 | 4100 | 4100 | 3987.5 | 225 | Přívod vzduchu | 0 | SUP 43 | 278 | Přívodní | SUP | PO02.02.0025 | 0025 | yes
13118589 | -1.PP_SO-101 | 3943.31 | 0.0201032 | 1.98212 | 160 mm | 0 | 160 mm | 1.65271 | 0.0333333 | 17527.4 | 1.65786 | 0.275027 | 0.300947 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.16641 | ETA 30 | 269 | Odváděný | ETA | PO02.02.0026 | 0026 | no
13119322 | -1.PP_SO-101 | 2362.96 | 0.0201032 | 1.18775 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0027 | 0027 | no
13119331 | -1.PP_SO-101 | 1514.38 | 0.0201032 | 0.761211 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2530 | 2450 | 2450 | 2370 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0028 | 0028 | no
13322446 | 4.NP_SO-101 | 169.998 | 0.01227 | 0.0667582 | 125 mm | 0 | 125 mm | 0.277278 | 0.00833333 | 5608.78 | 0.679061 | 0.0143375 | 0.0843391 | 4.NP_SO-101 | 0 | 2262.5 | 2200 | 2200 | 2137.5 | 125 | Zpětný vzduch | 0.0517081 | ETA 19 | 384 | Odváděný | ETA | PO02.02.0031 | 0031 | yes
13407843 | 4.NP_SO-101 | 3766.19 | 0.0201032 | 1.8931 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 3810 | 3730 | 3730 | 3650 | 160 | Přívod vzduchu | 0 | SUP 43 | 279 | Přívodní | SUP | PO02.02.0032 | 0032 | yes
13407866 | -1.PP_SO-101 | 65.575 | 0.0201032 | 0.0329616 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 252 | Odváděný | ETA | PO02.02.0033 | 0033 | yes
13407868 | -1.PP_SO-101 | 890 | 0.0201032 | 0.447363 | 160 mm | 0 | 160 mm | 2.24952 | 0.0388889 | 20448.7 | 1.93417 | 0.108907 | 0.398018 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.0484136 | ETA 4 | 327 | Odváděný | ETA | PO02.02.0034 | 0034 | no
13407876 | -1.PP_SO-101 | 2441.96 | 0.0201032 | 1.22746 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Zpětný vzduch | 0 | ETA 30 | 428 | Odváděný | ETA | PO02.02.0035 | 0035 | no
13407883 | -1.PP_SO-101 | 34.441 | 0.0201032 | 0.017312 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0 | ETA 4 | 385 | Odváděný | ETA | PO02.02.0036 | 0036 | yes
13407931 | 3.NP_SO-101 | 1213.67 | 0.0314112 | 0.762571 | 200 mm | 0 | 200 mm | 1.52313 | 0.05 | 21032.9 | 1.59155 | 0.0906338 | 0.210783 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Zpětný vzduch | 0.0595048 | ETA 29 | 376 | Odváděný | ETA | PO02.02.0037 | 0037 | no
13410991 | 1.NP_SO-101 | 95.1487 | 0.0397548 | 0.0672567 | 225 mm | 0 | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3012.5 | 2900 | 2900 | 2787.5 | 225 | Zpětný vzduch | 0 | ETA 30 | 398 | Odváděný | ETA | PO02.02.0045 | 0045 | yes | Identifikační data - Komentáře: OSAZENY REGULÁTORY PRŮTOKU NA STOUPAČCE
13413980 | -1.PP_SO-101 | 2615.4 | 0.0201032 | 1.31464 | 160 mm | 0 | 160 mm | 1.65271 | 0.0333333 | 17527.4 | 1.65786 | 0.102787 | 0.300947 | -1.PP_SO-101 | 0 | 2600 | 2520 | 2520 | 2440 | 160 | Zpětný vzduch | 0.062193 | ETA 30 | 125 | Odváděný | ETA | PO02.02.0048 | 0048 | no
13417411 | 4.NP_SO-101 | 9453.42 | 0.0201032 | 4.75181 | 160 mm | 0 | 160 mm | 0.413176 | 0.0166667 | 8763.72 | 0.828932 | 0.347849 | 0.0871367 | 4.NP_SO-101 | 0 | 3680 | 3600 | 3600 | 3520 | 160 | Zpětný vzduch | 0.84189 | ETA 19 | 377 | Odváděný | ETA | PO02.02.0049 | 0049 | no
13420243 | -1.PP_SO-101 | 3511.36 | 0.0201032 | 1.765 | 160 mm | 0 | 160 mm | 3.31689 | 0.0472222 | 24830.6 | 2.34864 | 1.87331 | 0.567211 | -1.PP_SO-101 | 0 | 2580 | 2500 | 2500 | 2420 | 160 | Přívod vzduchu | 0.56478 | SUP 27 | 311 | Přívodní | SUP | PO02.02.0051 | 0051 | no
13425859 | -1.PP_SO-101 | 1356.87 | 0.0201032 | 0.682037 | 160 mm | 0 | 160 mm | 0.103294 | 0.00833333 | 4381.86 | 0.414466 | 0.0265427 | 0.0259205 | -1.PP_SO-101 | 0 | 1780 | 1700 | 1700 | 1620 | 160 | Zpětný vzduch | 0.256962 | ETA 30 | 338 | Odváděný | ETA | PO02.02.0056 | 0056 | no
13435227 | 1.NP_SO-101 | 664.358 | 0.159008 | 0.939214 | 450 mm | 0 | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-101 | 0 | 3375 | 3150 | 3150 | 2925 | 450 | Zpětný vzduch | 0 | ETA 30 | 375 | Odváděný | ETA | PO02.02.0058 | 0058 | yes
13442113 | 4.NP_SO-101 | 4601.04 | 0.0201032 | 2.31273 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-101 | 0 | 2960 | 2880 | 2880 | 2800 | 160 | Přívod vzduchu | 0 | SUP 43 | 7 | Přívodní | SUP | PO02.02.0067 | 0067 | no
13442437 | 3.NP_SO-101 | 80.5275 | 0.0254431 | 0.0455372 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.00815988 | 0.10133 | 3.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Zpětný vzduch | 0.0140597 | ETA 29 | 157 | Odváděný | ETA | PO02.02.0070 | 0070 | no
13443017 | 3.NP_SO-101 | 1684.75 | 0.0201032 | 0.84685 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3380 | 3300 | 3300 | 3220 | 160 | Přívod vzduchu | 0 | SUP 43 | 236 | Přívodní | SUP | PO02.02.0072 | 0072 | no | Identifikační data - Komentáře: VEDENO DO 2.NP
13443019 | 3.NP_SO-101 | 1730.02 | 0.04908 | 1.35876 | 250 mm | 0 | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3425 | 3300 | 3300 | 3175 | 250 | Přívod vzduchu | 0 | SUP 43 | 241 | Přívodní | SUP | PO02.02.0073 | 0073 | no
13443023 | 3.NP_SO-101 | 288.768 | 0.0254431 | 0.163294 | 180 mm | 0 | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3390 | 3300 | 3300 | 3210 | 180 | Přívod vzduchu | 0 | SUP 43 | 157 | Přívodní | SUP | PO02.02.0074 | 0074 | no
13443025 | 3.NP_SO-101 | 33.5434 | 0.0314112 | 0.021076 | 200 mm | 0 | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-101 | 0 | 3400 | 3300 | 3300 | 3200 | 200 | Přívod vzduchu | 0 | SUP 43 | 159 | Přívodní | SUP | PO02.02.0075 | 0075 | no
13443564 | 4.NP_SO-101 | 4815.91 | 0.0254431 | 2.72333 | 180 mm | 0 | 180 mm | 0.580374 | 0.025 | 11685 | 0.982438 | 0.418941 | 0.10133 | 4.NP_SO-101 | 0 | 3690 | 3600 | 3600 | 3510 | 180 | Zpětný vzduch | 0.721846 | ETA 19 | 376 | Odváděný | ETA | PO02.02.0077 | 0077 | no
13452280 | -1.PP_SO-101 | 680 | 0.0201032 | 0.341805 | 160 mm | 0 | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-101 | 0 | 2630 | 2550 | 2550 | 2470 | 160 | Přívod vzduchu | 0 | SUP 27 | 362 | Přívodní | SUP | PO02.02.0084 | 0084 | no
