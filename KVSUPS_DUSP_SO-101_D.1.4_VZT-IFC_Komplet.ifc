Properties of the parts of a building model (IFC4), part 13 of 21

# IfcDistributionPort (3839)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_14042576_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042642_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042642_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042634_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042634_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042654_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042654_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042646_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042646_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042711_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042784_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042792_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042836_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042784_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042828_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042836_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042852_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042828_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042840_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042852_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14042880_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042840_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044332_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044345_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044469_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044332_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044339_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044341_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044345_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044339_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044407_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044469_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044471_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044407_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044457_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044461_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044461_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044458_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044458_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14044471_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044511_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044498_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044498_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044632_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044507_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044505_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044505_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044511_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044632_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044548_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044548_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044634_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044622_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044624_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14044634_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044622_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14045100_2 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14044953_0 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_14044953_1 | SINK | DUCT | VENTILATION | ETA 1
OutPort_14045104_2 | SOURCE | DUCT | VENTILATION | ETA 1
Port_14047348_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047359_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047348_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047392_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047383_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047392_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
Port_14047383_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 13
InPort_14047960_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14047786_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14047940_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14047931_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14047931_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14047960_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048273_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14048149_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048149_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14048275_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048253_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14048255_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048275_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14048253_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048563_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071598_2 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071879_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14048563_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14049126_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071741_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14049136_0 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14049126_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14050509_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14067683_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_14050732_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14050721_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14050721_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14050747_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14050734_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14051704_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14050747_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14050734_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14071598_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14051166_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14051166_2 | SINK | DUCT | VENTILATION | ETA 5
InPort_14051718_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14051708_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14051708_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14051731_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14051731_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14051719_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14066545_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14052093_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14052093_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14066550_2 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14052894_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14063969_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14052894_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14053415_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14053012_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 1
Port_14053012_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 1
Port_14053300_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 1
Port_14053300_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 1
Port_14053406_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14053415_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14053406_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
InPort_14054126_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054065_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054263_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054126_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054187_0 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054263_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054264_2 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14054187_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14054625_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14054623_2 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14054655_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14054798_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14054798_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14054881_4 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_14055076_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14055089_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14055108_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14055076_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14055107_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14055092_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14055092_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14055108_2 | SOURCE | DUCT | EXHAUST | EHA 8
Port_14055136_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14055137_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14055137_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075349_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_14055762_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14055137_2 | SOURCE | DUCT | VENTILATION | SUP 27
Port_14055241_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_14055242_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_14055448_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14055447_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14055447_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072222_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14055553_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055526_0 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14055526_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055554_2 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14055550_1 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055549_1 | SOURCE | DUCT | EXHAUST | ETA 35
InPort_14055549_3 | SINK | DUCT | EXHAUST | ETA 35
OutPort_14055553_0 | SOURCE | DUCT | EXHAUST | ETA 35
Port_14056035_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14056037_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
InPort_14057012_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14070024_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14070028_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14057012_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14068508_2 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14057560_0 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14057560_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068509_2 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14057710_2 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14057696_1 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14058078_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063362_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058133_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058078_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058113_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058114_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058221_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058472_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058252_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058303_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058471_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058252_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058329_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058471_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058472_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058329_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060003_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14059104_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060054_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060003_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060070_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060054_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060131_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060070_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060145_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060131_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060138_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060145_2 | SOURCE | DUCT | VENTILATION | ETA 19
OutPort_14060138_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14060486_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14061505_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14061575_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14060486_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14060591_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14060881_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14060592_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14060591_2 | SOURCE | DUCT | VENTILATION | SUP 43
Port_14060591_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070384_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14060881_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14063006_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14061046_2 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14061032_0 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14061032_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14061087_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14061084_1 | SINK | DUCT | EXHAUST | ETA 29
OutPort_14061082_1 | SOURCE | DUCT | EXHAUST | ETA 29
InPort_14061505_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14061507_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14061507_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062647_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14061565_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14061575_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063563_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14061565_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14061630_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063563_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063565_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14061630_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062566_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062006_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062006_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064709_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14066550_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062017_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062017_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062024_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062024_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062567_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14070096_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062497_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062521_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062574_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062566_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062521_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062567_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062566_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062647_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062639_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062639_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062961_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14062961_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14062799_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14062975_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14063006_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14062975_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14063008_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14063357_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063360_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063362_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063357_3 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063359_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063567_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063360_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063359_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14063567_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14063565_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14063966_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14065040_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14063969_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14065041_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
InPort_14064709_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064705_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14064705_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064711_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14064711_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064706_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14064706_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14064724_2 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14065611_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065628_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065611_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065645_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065632_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065645_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14065632_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14066467_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
OutPort_14066450_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14066450_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14066545_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14066467_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 12
Port_14067023_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 9
Port_14067023_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 9
Port_14067405_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 11
Port_14067405_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 11
InPort_14067664_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14067680_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_14067696_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14067664_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_14067683_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14067696_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_14068416_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068415_2 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14068507_2 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14068508_1 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_14069676_1 | SINK | DUCT | EXHAUST | ETA 5
OutPort_14069685_2 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14069685_1 | SINK | DUCT | VENTILATION | ETA 5
InPort_14069993_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14069765_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14069765_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14069851_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14069851_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14069784_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14069784_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14069853_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14070264_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14070096_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14070201_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14070264_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14070266_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14070201_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_14070313_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_14070367_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070381_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070367_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070394_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070384_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070394_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070559_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070572_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070559_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070664_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070658_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070664_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070658_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070738_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070746_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070738_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070853_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070847_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070853_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070847_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_14075547_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14071500_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14071500_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075575_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14071572_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071558_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071741_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071730_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071730_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071757_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071757_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071744_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071744_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071856_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071856_2 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071849_0 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14071849_1 | SINK | DUCT | VENTILATION | ETA 5
OutPort_14071879_1 | SOURCE | DUCT | VENTILATION | ETA 5
InPort_14072121_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072107_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072107_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072140_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072140_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072125_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072171_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072181_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072197_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072171_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14072185_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072197_2 | SOURCE | DUCT | VENTILATION | ETA 30
Port_14073610_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073619_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073610_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073629_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073621_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14073629_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14074050_1 | SOURCEANDSINK | DUCT
Port_14074050_2 | SOURCEANDSINK | DUCT
InPort_14074921_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14074929_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075929_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14074921_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14074931_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075929_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075932_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14074931_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_14075248_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075347_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075248_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075366_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075347_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075349_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075354_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075366_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_14075354_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_14075575_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075567_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075567_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14076180_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075754_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075577_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075577_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075729_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14076184_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075588_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075588_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075617_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075615_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075750_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075617_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075615_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075729_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075697_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075697_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075731_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075748_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075754_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075752_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075748_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14075750_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14075752_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14076180_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14076166_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14076166_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14076196_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14076196_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14076184_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14076542_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076452_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14076452_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076673_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14076543_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076542_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14076673_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076663_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14076663_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076701_1 | SOURCE | DUCT | VENTILATION | SUP 20
Port_14076842_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 15
Port_14076842_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 15
Port_14077816_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080656_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14077816_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080659_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_14081962_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14077998_0 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14077998_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081940_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14079138_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079186_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079184_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079138_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079182_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079184_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079474_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14079669_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14079671_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080203_3 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080170_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080203_2 | SOURCE | DUCT | VENTILATION | ETA 4
Port_14080203_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080273_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_14080203_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14081033_1 | SOURCE | DUCT | VENTILATION | ETA 4
Port_14080273_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080323_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080323_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080403_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080396_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080403_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080396_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_14080656_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_14080875_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080979_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14081032_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080875_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080979_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080887_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14080997_0 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14081032_2 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14081034_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14080997_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14081033_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14081034_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_14081693_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081704_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081761_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081693_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081751_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081763_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081763_1 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081761_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081802_0 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081884_2 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081886_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081802_1 | SOURCE | DUCT | EXHAUST | ETA 4
InPort_14081960_2 | SINK | DUCT | EXHAUST | ETA 4
OutPort_14081962_1 | SOURCE | DUCT | EXHAUST | ETA 4

# IfcDistributionSystem: Odváděný (24)
PredefinedType: VENTILATION
Name
ETA 29
ETA 19
ETA 13
ETA 30
ETA 4
ETA 28
ETA 14
ETA 32
ETA 35
ETA 22
ETA 31
ETA 1
ETA 8
ETA 3
ETA 2
ETA 12
ETA 10
ETA 6
ETA 5
ETA 16
ETA 7
ETA 9
ETA 11
ETA 15

# IfcDistributionSystem: Přívodní (5)
PredefinedType: VENTILATION
Name
SUP 43
SUP 27
SUP 20
SUP 2
SUP 1

# IfcDistributionSystem: Znehodnocený (5)
PredefinedType: EXHAUST
Name
EHA 14
EHA 8
EHA 10
EHA 3
EHA 1

# IfcDistributionSystem: Čerstvý (5)
PredefinedType: VENTILATION
Name
ODA 1
ODA 11
ODA 10
ODA 3
ODA 18

# IfcDuctFitting: Hranaté zakončení:Standardní, Hranaté zakončení:Standardní:13998998
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: Z; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 13; Popis: Zakončení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Hranaté zakončení
Classification: TA00 Uniformat (Uniformat); Group: ETA 19
Qto_DuctFittingBaseQuantities - Length: 180 mm; GrossCrossSectionArea: 0.02 m2; NetCrossSectionArea: 0.02 m2; OuterSurfaceArea: 0.108 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm × 180 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm × 180 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 2340 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - x: 0 mm; a: 180 mm; b: 200 mm; Objem: 0.0036 m3; Velikost: 200 × 180
Identifikační data - Kód prvku: TA00.13.0509; Označení: 0509
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1154122; Max ab: 200 mm; Rodina: Hranaté zakončení; Rodina a typ: Hranaté zakončení: Standardní; x1: 100 mm; x2: 100 mm

# IfcDuctFitting: M_Hranaté odbočení:Standardní (10)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: S; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 06; Popis: Spojení; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka Násobitel: 0.25
Jiné - Typ: Standardní; Id typu: 1559781; Rodina: M_Hranaté odbočení; Rodina a typ: M_Hranaté odbočení: Standardní
Name (M_Hranaté odbočení:Standardní:...) | In | Length (mm) = Výška potrubí 1 (mm) = Výška potrubí 2 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka odbočení | Objem (m3) | Pevná délka odbočení | Projekce délky odbočení | Šířka potrubí 1 (mm) = Šířka potrubí 2 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13442092 | 4.NP_SO-101 | 225 | 0.0160226 | 0.113931 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2677.52 | SUP 43 | 122.085 | 0.00360508 | 101.6 | 6.096 | 125 | 125 × 225-125 × 225 | TA04.06.0019 | 0019 | no
13442125 | 4.NP_SO-101 | 225 | 0.0166171 | 0.116072 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2790 | SUP 43 | 101.6 | 0.00373885 | 101.6 | 31.3368 | 125 | 125 × 225-125 × 225 | TA04.06.0023 | 0023 | no
13442133 | 4.NP_SO-101 | 225 | 0.0166171 | 0.116072 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2790 | SUP 43 | 101.6 | 0.00373885 | 101.6 | 31.3368 | 125 | 125 × 225-125 × 225 | TA04.06.0024 | 0024 | no
13442136 | 4.NP_SO-101 | 225 | 0.0158318 | 0.113245 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2767.5 | SUP 43 | 101.6 | 0.00356216 | 101.6 | 25.0546 | 125 | 125 × 225-125 × 225 | TA04.06.0025 | 0025 | no
13525869 | 4.NP_SO-101 | 225 | 0.0166171 | 0.116072 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2700 | SUP 43 | 101.6 | 0.00373885 | 101.6 | 31.3368 | 125 | 125 × 225-125 × 225 | TA04.06.0097 | 0097 | no
13525893 | 4.NP_SO-101 | 225 | 0.0166171 | 0.116072 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2700 | SUP 43 | 101.6 | 0.00373885 | 101.6 | 31.3368 | 125 | 125 × 225-125 × 225 | TA04.06.0098 | 0098 | no
13937292 | 4.NP_SO-101 | 225 | 0.0160226 | 0.113931 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2677.52 | SUP 43 | 122.085 | 0.00360508 | 101.6 | 6.096 | 125 | 125 × 225-125 × 225 | TA04.06.0436 | 0436 | yes
13939065 | 4.NP_SO-101 | 180 | 0.0215392 | 0.110771 | 200 mm × 180 mm-200 mm × 180 mm | 4.NP_SO-101 | 1585.11 | SUP 43 | 101.6 | 0.00387706 | 101.6 | 6.096 | 200 | 200 × 180-200 × 180 | TA04.06.0447 | 0447 | yes
13961971 | 4.NP_SO-101 | 225 | 0.0162136 | 0.114619 | 125 mm × 225 mm-125 mm × 225 mm | 4.NP_SO-101 | 2767.59 | SUP 43 | 101.6 | 0.00364807 | 101.6 | 28.1091 | 125 | 125 × 225-125 × 225 | TA04.06.0464 | 0464 | yes
14074289 | -1.PP_SO-101 | 400 | 0.0818138 | 0.564877 | 560 mm × 400 mm-560 mm × 400 mm | -1.PP_SO-101 | 2262.59 | SUP 27 | 140 | 0.0327255 | 140 | 6.096 | 560 | 560 × 400-560 × 400 | TA04.06.0790 | 0790

# IfcDuctFitting: M_Hranaté odbočení:Standardní (4)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: S; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 06; Popis: Spojení; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka Násobitel: 0.25; Pevná délka odbočení: 101.6
Jiné - Typ: Standardní; Id typu: 1559781; Rodina: M_Hranaté odbočení; Rodina a typ: M_Hranaté odbočení: Standardní
Name (M_Hranaté odbočení:Standardní:...) | In | Length (mm) = Výška potrubí 1 (mm) = Výška potrubí 2 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka odbočení | Objem (m3) | Projekce délky odbočení | Šířka potrubí 1 (mm) = Šířka potrubí 2 (mm) | Velikost | Kód prvku | Označení
13936057 | 4.NP_SO-101 | 280 | 0.0301549 | 0.21711 | 280 mm × 280 mm-280 mm × 280 mm | 4.NP_SO-101 | 1776.9 | ETA 19 | 101.6 | 0.00844337 | 6.096 | 280 | 280 × 280-280 × 280 | TA04.06.0430 | 0430 | Jiné - Páteřní trasa: yes
13937010 | 4.NP_SO-101 | 180 | 0.0215392 | 0.110771 | 200 mm × 180 mm-200 mm × 180 mm | 4.NP_SO-101 | 1776.9 | ETA 19 | 101.6 | 0.00387706 | 6.096 | 200 | 200 × 180-200 × 180 | TA04.06.0435 | 0435 | Jiné - Páteřní trasa: yes
14079671 | 1.NP_SO-101 | 200 | 0.013462 | 0.0930784 | 125 mm × 200 mm-125 mm × 200 mm | 1.NP_SO-101 | 3350 | ETA 4 | 101.6 | 0.0026924 | 6.096 | 125 | 125 × 200-125 × 200 | TA04.06.0815 | 0815
14080170 | 2.NP_SO-101 | 200 | 0.0134632 | 0.0930821 | 125 mm × 200 mm-125 mm × 200 mm | 2.NP_SO-101 | 3350 | ETA 4 | 101.605 | 0.00269263 | 6.10064 | 125 | 125 × 200-125 × 200 | TA04.06.0817 | 0817

# IfcDuctFitting: M_Hranaté spojení:Standardní, M_Hranaté spojení:Standardní:13968053
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: S; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 12; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté spojení
Classification: TA00 Uniformat (Uniformat); Group: SUP 43
Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.0024 m2; NetCrossSectionArea: 0.0024 m2; OuterSurfaceArea: 0.51156 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 400 mm × 630 mm-400 mm × 630 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 400 mm × 630 mm-400 mm × 630 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 1270.11 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm; Objem: 0.001512 m3; Šířka potrubí: 400 mm; Velikost: 400 × 630-400 × 630; Výška potrubí: 630 mm
Identifikační data - Kód prvku: TA00.12.0483; Označení: 0483
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559790; Rodina: M_Hranaté spojení; Rodina a typ: M_Hranaté spojení: Standardní

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (10)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 09; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Šířkové odsazení: 3048 mm; Výškové odsazení: 3048 mm
Jiné - Typ: 45 stupňů; Delta 1: 0 mm; Delta 2: 0 mm; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Length (mm) = Výška potrubí 1 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Rozdíl výšek (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka = Poloviční šířka 1 (mm) | Odskok – výška = Poloviční výška 1 (mm) | Plocha (m2) | Poloviční šířka 2 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Čís.5 = Čís.6 = Čís.8 | Čís.7 | Čís.1 = Čís.2 = Čís.4 | Čís.3 | Délka 1 (mm) | Délka 2 (mm)
13738023 | -1.PP_SO-101 | 400 | 0.106467 | 0.650335 | 700 mm × 400 mm-560 mm × 400 mm | 0 | -1.PP_SO-101 | 1392 | SUP 27 | 0 | 168.995 | 0.0425867 | 350 | 200 | 0.269051 | 280 | 200 | 140 | 700 | 560 | 700 × 400-560 × 400 | 400 | TA00.09.0203 | 0203 | yes | 1 | 1 | 2.8 | 7.84 | 60.3553 | 168.995
13739401 | -1.PP_SO-101 | 355 | 0.050276 | 0.487386 | 630 mm × 355 mm-560 mm × 355 mm |  | -1.PP_SO-101 | 2119.92 | SUP 27 | 0 | 84.4975 | 0.017848 | 280 | 177.5 | 0.172123 | 315 | 177.5 | 70 | 560 | 630 | 630 × 355-560 × 355 | 355 | TA00.09.0206 | 0206 | yes | 1 | 1 | 1.4 | 1.96 | 60.3553 | 84.4975
13739851 | -1.PP_SO-101 | 355 | 0.0222711 | 0.46448 | 630 mm × 355 mm-600 mm × 355 mm |  | -1.PP_SO-101 | 1900.01 | SUP 1 | 0 | 36.2132 | 0.00790625 | 315 | 177.5 | 0.138391 | 300 | 177.5 | 30 | 630 | 600 | 630 × 355-600 × 355 | 355 | TA00.09.0209 | 0209 | yes | 1 | 1 | 0.6 | 0.36 | 60.3553 | 36.2132
13739853 | -1.PP_SO-101 | 355 | 0.0222711 | 0.46448 | 630 mm × 355 mm-600 mm × 355 mm |  | -1.PP_SO-101 | 1900.01 | SUP 1 | 0 | 36.2132 | 0.00790625 | 315 | 177.5 | 0.138391 | 300 | 177.5 | 30 | 630 | 600 | 630 × 355-600 × 355 | 355 | TA00.09.0210 | 0210 | yes | 1 | 1 | 0.6 | 0.36 | 60.3553 | 36.2132
13740345 | -1.PP_SO-101 | 250 | 0.0588465 | 0.260492 | 250 mm × 400 mm-250 mm × 250 mm | 0 | -1.PP_SO-101 | 2265 | SUP 27 | 150 | 181.066 | 0.0147116 | 125 | 125 | 0.11718 | 125 | 200 | 0 | 250 | 250 | 250 × 400-250 × 250 | 400 | TA00.09.0212 | 0212 | yes | 3 | 9 | 1 | 1 | 181.066 | 60.3553
13909443 | 3.NP_SO-101 | 315 | 0.012569 | 0.216235 | 315 mm × 315 mm-280 mm × 315 mm |  | 3.NP_SO-101 | 3913.54 | SUP 43 | 0 | 42.2487 | 0.00395923 | 157.5 | 157.5 | 0.0666277 | 140 | 157.5 | 35 | 315 | 280 | 315 × 315-280 × 315 | 315 | TA00.09.0353 | 0353 | yes | 1 | 1 | 0.7 | 0.49 | 60.3553 | 42.2487
14039446 | 4.NP_SO-101 | 225 | 0.00603553 | 0.0743977 | 125 mm × 225 mm-75 mm × 225 mm | 0 | 4.NP_SO-101 | 2613.97 | SUP 43 | 0 | 60.3553 | 0.001358 | 37.5 | 112.5 | 0.024635 | 62.5 | 112.5 | 50 | 75 | 125 | 125 × 225-75 × 225 | 225 | TA00.09.0631 | 0631 | no | 1 | 1 | 1 | 1 | 60.3553 | 60.3553
14039447 | 4.NP_SO-101 | 225 | 0.00603553 | 0.0743977 | 125 mm × 225 mm-75 mm × 225 mm | 0 | 4.NP_SO-101 | 2618.29 | SUP 43 | 0 | 60.3553 | 0.001358 | 37.5 | 112.5 | 0.024635 | 62.5 | 112.5 | 50 | 75 | 125 | 125 × 225-75 × 225 | 225 | TA00.09.0632 | 0632 | no | 1 | 1 | 1 | 1 | 60.3553 | 60.3553
14039448 | 4.NP_SO-101 | 225 | 0.00603553 | 0.0743977 | 125 mm × 225 mm-75 mm × 225 mm | 0 | 4.NP_SO-101 | 2653.97 | SUP 43 | 0 | 60.3553 | 0.001358 | 37.5 | 112.5 | 0.024635 | 62.5 | 112.5 | 50 | 75 | 125 | 125 × 225-75 × 225 | 225 | TA00.09.0633 | 0633 | no | 1 | 1 | 1 | 1 | 60.3553 | 60.3553
14039449 | 4.NP_SO-101 | 225 | 0.00603553 | 0.0743977 | 125 mm × 225 mm-75 mm × 225 mm | 0 | 4.NP_SO-101 | 2593.97 | SUP 43 | 0 | 60.3553 | 0.001358 | 37.5 | 112.5 | 0.024635 | 62.5 | 112.5 | 50 | 75 | 125 | 125 × 225-75 × 225 | 225 | TA00.09.0634 | 0634 | no | 1 | 1 | 1 | 1 | 60.3553 | 60.3553

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (9)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 09; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Šířkové odsazení (mm) | Výškové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Delta 1 (mm) | Delta 2 (mm) | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Čís.5 = Čís.6 = Čís.8 | Čís.7 | Délka 1 (mm) | Délka 2 (mm)
13740716 | -1.PP_SO-101 | 700 mm × 400 mm-315 mm × 560 mm | -1.PP_SO-101 | 1392 | ODA 3 | 3048 | 3048 | 464.736 | 0.110824 | 350 | 200 | 0.472414 | 350 | 157.5 | 200 | 280 | 385 | 160 | 700 | 315 | 700 × 400-315 × 560 | 400 | 560 | TA00.09.0213 | 0213 | yes | 0 | 0 | 7.7 | 7.7 | 59.29 | 7.7 | 3.2 | 10.24 | 193.137 | 464.736
13826466 | 2.NP_SO-101 | 500 mm × 400 mm-400 mm × 315 mm | 2.NP_SO-101 | 3100 | ODA 11 | 3048 | 3048 | 120.711 | 0.0195048 | 250 | 200 | 0.160809 | 250 | 200 | 200 | 157.5 | 100 | 85 | 500 | 400 | 500 × 400-400 × 315 | 400 | 315 | TA00.09.0246 | 0246 | yes | 0 | 0 | 2 | 2 | 4 | 2 | 1.7 | 2.89 | 102.604 | 120.711
13826467 | 2.NP_SO-101 | 600 mm × 300 mm-400 mm × 315 mm | 2.NP_SO-101 | 3100 | ODA 11 | 2949.63 | 3048 | 201.601 | 0.0309458 | 101.627 | 157.5 | 0.214577 | 200 | 300 | 157.5 | 150 | 200 | 15 | 400 | 600 | 600 × 300-400 × 315 | 315 | 300 | TA00.09.0247 | 0247 | yes | 98.3728 | 0 | 7.93491 | 0.0650892 | 16 | 4 | 0.3 | 0.09 | 18.1066 | 201.601
13826567 | 2.NP_SO-101 | 600 mm × 300 mm-315 mm × 315 mm | 2.NP_SO-101 | 3100 | ODA 11 | 3146.37 | 3048 | 318.384 | 0.0446773 | 398.373 | 150 | 0.270888 | 300 | 157.5 | 150 | 157.5 | 285 | 15 | 600 | 315 | 600 × 300-315 × 315 | 300 | 315 | TA00.09.0248 | 0248 | yes | 98.3728 | 0 | 9.63491 | 1.76509 | 32.49 | 5.7 | 0.3 | 0.09 | 18.1066 | 318.384
14034910 | -1.PP_SO-101 | 560 mm × 560 mm-560 mm × 315 mm | -1.PP_SO-101 | 1612.5 | ODA 3 | 3048 | 3048 | 295.741 | 0.0724566 | 280 | 280 | 0.359631 | 280 | 280 | 280 | 157.5 | 0 | 245 | 560 | 560 | 560 × 560-560 × 315 | 560 | 315 | TA00.09.0619 | 0619 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 4.9 | 24.01 | 295.741 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 0.129387 m2; NetCrossSectionArea: 0.129387 m2; OuterSurfaceArea: 0.848521 m2
14035581 | -1.PP_SO-101 | 315 mm × 560 mm-560 mm × 315 mm | -1.PP_SO-101 | 1300 | ODA 3 | 3048.1 | 3048 | 295.741 | 0.0551274 | 157.598 | 280 | 0.292941 | 157.5 | 280 | 280 | 157.5 | 245 | 245 | 315 | 560 | 315 × 560-560 × 315 | 560 | 315 | TA00.09.0627 | 0627 | yes | 0.0978315 | 0 | 4.90391 | 4.89609 | 24.01 | 4.9 | 4.9 | 24.01 | 295.741 | 295.741
14068416 | 4.NP_SO-101 | 710 mm × 400 mm-560 mm × 400 mm | 4.NP_SO-101 | 965 | ODA 1 | 3048 | 3048 | 181.066 | 0.0459908 | 355 | 200 | 0.281174 | 355 | 280 | 200 | 200 | 150 | 0 | 710 | 560 | 710 × 400-560 × 400 | 400 | 400 | TA00.09.0752 | 0752 |  | 0.000167258 | 0 | 3.00001 | 2.99999 | 9 | 3 | 1 | 1 | 60.3553 | 181.066 | Qto_DuctFittingBaseQuantities - Length: 400 mm; GrossCrossSectionArea: 0.114977 m2; NetCrossSectionArea: 0.114977 m2; OuterSurfaceArea: 0.664788 m2
14068508 | 4.NP_SO-101 | 560 mm × 450 mm-560 mm × 400 mm | 4.NP_SO-101 | 1034 | ODA 1 | 3048 | 3048 | 60.3553 | 0.0143646 | 280 | 225 | 0.167017 | 280 | 280 | 225 | 200 | 0 | 50 | 560 | 560 | 560 × 450-560 × 400 | 450 | 400 | TA00.09.0755 | 0755 |  | 0 | 0 | 1 | 1 | 1 | 1 | 1 | 1 | 60.3553 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 0.025651 m2; NetCrossSectionArea: 0.025651 m2; OuterSurfaceArea: 0.549168 m2
14068509 | 4.NP_SO-101 | 560 mm × 400 mm-560 mm × 400 mm | 4.NP_SO-101 | 965 | ODA 1 | 3048 | 3117 | 25 | 0.0056 | 280 | 269 | 0.158098 | 280 | 280 | 200 | 200 | 0 | 0 | 560 | 560 | 560 × 400-560 × 400 | 400 | 400 | TA00.09.0756 | 0756 |  | 0 | 69 | 1 | 1 | 1 | 1 | 1 | 1 | 60.3553 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 0.01 m2; NetCrossSectionArea: 0.01 m2; OuterSurfaceArea: 0.530196 m2

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (12)
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 09; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Šířkové odsazení (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Výškové odsazení (mm) | Kód prvku | Označení | Páteřní trasa | Delta 1 (mm) | Delta 2 (mm) | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm)
13736023 | -1.PP_SO-101 | 700 mm × 400 mm-560 mm × 315 mm | 0 | -1.PP_SO-101 | 1392 | EHA 3 | 168.995 | 0.0382295 | 350 | 200 | 0.254921 | 350 | 280 | 200 | 157.5 | 140 | 85 | 700 | 560 | 3048 | 700 × 400-560 × 315 | 400 | 315 | 3048 | TA00.09.0193 | 0193 | yes | 0 | 0 | 2.8 | 2.8 | 7.84 | 2.8 | 1.7 | 1.7 | 2.89 | 1.7 | 102.604 | 168.995
13760619 | -1.PP_SO-101 | 600 mm × 600 mm-315 mm × 560 mm | 0 | -1.PP_SO-101 | 600 | EHA 3 | 344.025 | 0.091614 | 157.5 | 280 | 0.399612 | 157.5 | 300 | 280 | 300 | 285 | 40 | 315 | 600 | 3048 | 600 × 600-315 × 560 | 560 | 600 | 3048 | TA00.09.0215 | 0215 | yes | 0 | 0 | 5.7 | 5.7 | 32.49 | 5.7 | 0.8 | 0.8 | 0.64 | 0.8 | 48.2843 | 344.025
13760985 | -1.PP_SO-101 | 500 mm × 560 mm-560 mm × 315 mm | 0 | -1.PP_SO-101 | 1930.15 | EHA 3 | 295.741 | 0.0682127 | 280 | 157.35 | 0.34231 | 280 | 250 | 157.5 | 280 | 60 | 245 | 560 | 500 | 3048 | 500 × 560-560 × 315 | 315 | 560 | 3047.85 | TA00.09.0216 | 0216 | yes | 0 | 0.149548 | 1.2 | 1.2 | 1.44 | 1.2 | 4.90598 | 4.89402 | 24.01 | 4.9 | 295.741 | 72.4264
13827507 | 2.NP_SO-101 | 600 mm × 300 mm-315 mm × 315 mm | 0 | 2.NP_SO-101 | 2750 | EHA 8 | 285 | 0.0399926 | 15 | 157.5 | 0.25311 | 157.5 | 300 | 157.5 | 150 | 285 | 15 | 315 | 600 | 2905.5 | 600 × 300-315 × 315 | 315 | 300 | 3048 | TA00.09.0256 | 0256 | yes | 142.5 | 0 | 11.4 | 0 | 32.49 | 5.7 | 0.3 | 0.3 | 0.09 | 0.3 | 18.1066 | 285
13827747 | 2.NP_SO-101 | 600 mm × 300 mm-315 mm × 315 mm | 0 | 2.NP_SO-101 | 2750 | EHA 8 | 285 | 0.0399926 | 442.5 | 150 | 0.25311 | 300 | 157.5 | 150 | 157.5 | 285 | 15 | 600 | 315 | 3190.5 | 600 × 300-315 × 315 | 300 | 315 | 3048 | TA00.09.0257 | 0257 | yes | 142.5 | 0 | 11.4 | 0 | 32.49 | 5.7 | 0.3 | 0.3 | 0.09 | 0.3 | 18.1066 | 285
13844722 | 4.NP_SO-101 | 500 mm × 600 mm-355 mm × 500 mm |  | 4.NP_SO-101 | 800 | EHA 14 | 175.03 | 0.0413655 | 177.5 | 250 | 0.247796 | 177.5 | 250 | 250 | 300 | 145 | 100 | 355 | 500 | 3048 | 500 × 600-355 × 500 | 500 | 600 | 3048 | TA00.09.0315 | 0315 | yes | 0 | 0 | 2.9 | 2.9 | 8.41 | 2.9 | 2 | 2 | 4 | 2 | 120.711 | 175.03
13844724 | 4.NP_SO-101 | 500 mm × 600 mm-355 mm × 500 mm |  | 4.NP_SO-101 | 800 | EHA 14 | 175.03 | 0.0413655 | 177.5 | 250 | 0.247796 | 177.5 | 250 | 250 | 300 | 145 | 100 | 355 | 500 | 3048 | 500 × 600-355 × 500 | 500 | 600 | 3048 | TA00.09.0316 | 0316 | yes | 0 | 0 | 2.9 | 2.9 | 8.41 | 2.9 | 2 | 2 | 4 | 2 | 120.711 | 175.03
14003222 | 2.NP_SO-101 | 355 mm × 315 mm-315 mm × 315 mm | 0 | 2.NP_SO-101 | 2750 | EHA 8 | 48.2843 | 0.0050952 | 177.5 | 157.5 | 0.0771691 | 177.5 | 157.5 | 157.5 | 157.5 | 40 | 0 | 355 | 315 | 3048 | 355 × 315-315 × 315 | 315 | 315 | 3048 | TA00.09.0576 | 0576 | yes | 0 | 0 | 0.8 | 0.8 | 0.64 | 0.8 | 1 | 1 | 1 | 1 | 60.3553 | 48.2843 | Qto_DuctFittingBaseQuantities - Length: 315 mm; GrossCrossSectionArea: 0.0161752 m2; NetCrossSectionArea: 0.0161752 m2; OuterSurfaceArea: 0.243975 m2
14034826 | -1.PP_SO-101 | 500 mm × 560 mm-500 mm × 500 mm | 0 | -1.PP_SO-101 | 1495 | EHA 3 | 72.4264 | 0.019193 | 250 | 250 | 0.189398 | 250 | 250 | 250 | 280 | 0 | 60 | 500 | 500 | 3048 | 500 × 560-500 × 500 | 500 | 560 | 3048 | TA00.09.0615 | 0615 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 1.2 | 1.2 | 1.44 | 1.2 | 72.4264 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 500 mm; GrossCrossSectionArea: 0.038386 m2; NetCrossSectionArea: 0.038386 m2; OuterSurfaceArea: 0.608394 m2
14034833 | -1.PP_SO-101 | 600 mm × 600 mm-500 mm × 560 mm | 0 | -1.PP_SO-101 | 600 | EHA 3 | 120.711 | 0.0385469 | 300 | 300 | 0.264734 | 300 | 250 | 300 | 280 | 100 | 40 | 600 | 500 | 3048 | 600 × 600-500 × 560 | 600 | 560 | 3048 | TA00.09.0616 | 0616 | yes | 0 | 0 | 2 | 2 | 4 | 2 | 0.8 | 0.8 | 0.64 | 0.8 | 48.2843 | 120.711
14065040 | 4.NP_SO-101 | 355 mm × 450 mm-355 mm × 400 mm |  | 4.NP_SO-101 | 504 | EHA 14 | 60.3553 | 0.00910611 | 177.5 | 225 | 0.110572 | 177.5 | 177.5 | 225 | 200 | 0 | 50 | 355 | 355 | 3048 | 355 × 450-355 × 400 | 450 | 400 | 3048 | TA00.09.0739 | 0739 |  | 0 | 0 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 60.3553 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 355 mm; GrossCrossSectionArea: 0.025651 m2; NetCrossSectionArea: 0.025651 m2; OuterSurfaceArea: 0.348133 m2
14065041 | 4.NP_SO-101 | 355 mm × 450 mm-355 mm × 400 mm |  | 4.NP_SO-101 | 504 | EHA 14 | 60.3553 | 0.00910611 | 177.5 | 225 | 0.110572 | 177.5 | 177.5 | 225 | 200 | 0 | 50 | 355 | 355 | 3048 | 355 × 450-355 × 400 | 450 | 400 | 3048 | TA00.09.0740 | 0740 |  | 0 | 0 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 60.3553 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 355 mm; GrossCrossSectionArea: 0.025651 m2; NetCrossSectionArea: 0.025651 m2; OuterSurfaceArea: 0.348133 m2

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (16)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 09; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Šířkové odsazení: 3048 mm
Jiné - Typ: 45 stupňů; Delta 1: 0 mm; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Výškové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka = Poloviční šířka 1 (mm) | Odskok – výška | Plocha (m2) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Delta 2 (mm) | Čís.1 = Čís.2 = Čís.4 | Čís.3 | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm)
13737332 | -1.PP_SO-101 | 400 | 0.0927058 | 0.55124 | 560 mm × 400 mm-400 mm × 400 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 193.137 | 0.0370823 | 200 | 200 | 0.230516 | 280 | 200 | 200 | 160 | 0 | 400 | 560 | 560 × 400-400 × 400 | 400 | 400 | TA00.09.0195 | 0195 | yes | 0 | 3.2 | 10.24 | 1 | 1 | 1 | 1 | 60.3553 | 193.137
13737730 | -1.PP_SO-101 |  |  |  | 560 mm × 400 mm-630 mm × 355 mm | 0 | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 84.4975 | 0.018957 | 280 | 200 | 0.180327 | 315 | 200 | 177.5 | 70 | 45 | 560 | 630 | 560 × 400-630 × 355 | 400 | 355 | TA00.09.0199 | 0199 | yes | 0 | 1.4 | 1.96 | 0.9 | 0.9 | 0.81 | 0.9 | 54.3198 | 84.4975
13737731 | -1.PP_SO-101 | 630 | 0.0161752 | 0.487951 | 630 mm × 355 mm-630 mm × 315 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 48.2843 | 0.0101904 | 315 | 177.5 | 0.145285 | 315 | 177.5 | 157.5 | 0 | 40 | 630 | 630 | 630 × 355-630 × 315 | 355 | 315 | TA00.09.0200 | 0200 | yes | 0 | 1 | 1 | 0.8 | 0.8 | 0.64 | 0.8 | 48.2843 | 60.3553
13737799 | -1.PP_SO-101 | 630 | 0.0161752 | 0.487951 | 630 mm × 355 mm-630 mm × 315 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 48.2843 | 0.0101904 | 315 | 157.5 | 0.145285 | 315 | 157.5 | 177.5 | 0 | 40 | 630 | 630 | 630 × 355-630 × 315 | 315 | 355 | TA00.09.0201 | 0201 | yes | 0 | 1 | 1 | 0.8 | 0.8 | 0.64 | 0.8 | 48.2843 | 60.3553
13737801 | -1.PP_SO-101 | 630 | 0.0161752 | 0.487951 | 630 mm × 355 mm-630 mm × 315 mm |  | -1.PP_SO-101 | 2450 | Odváděný | Zpětný vzduch | ETA 30 | ETA | 3048 | 48.2843 | 0.0101904 | 315 | 157.5 | 0.145285 | 315 | 157.5 | 177.5 | 0 | 40 | 630 | 630 | 630 × 355-630 × 315 | 315 | 355 | TA00.09.0202 | 0202 | yes | 0 | 1 | 1 | 0.8 | 0.8 | 0.64 | 0.8 | 48.2843 | 60.3553
13936229 | 4.NP_SO-101 | 280 | 0.012569 | 0.192209 | 315 mm × 280 mm-280 mm × 280 mm | 0 | 4.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 42.2487 | 0.00351932 | 157.5 | 140 | 0.0606212 | 140 | 140 | 140 | 35 | 0 | 315 | 280 | 315 × 280-280 × 280 | 280 | 280 | TA00.09.0433 | 0433 | yes | 0 | 0.7 | 0.49 | 1 | 1 | 1 | 1 | 60.3553 | 42.2487
14028662 | 4.NP_SO-101 | 450 | 0.126746 | 1.06259 | 1100 mm × 450 mm-1000 mm × 450 mm | 0 | 4.NP_SO-101 | 1034 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 120.711 | 0.0570358 | 500 | 225 | 0.392394 | 550 | 225 | 225 | 100 | 0 | 1000 | 1100 | 1100 × 450-1000 × 450 | 450 | 450 | TA00.09.0588 | 0588 | yes | 0 | 2 | 4 | 1 | 1 | 1 | 1 | 60.3553 | 120.711
14028670 | 4.NP_SO-101 | 450 | 0.126746 | 1.06259 | 1100 mm × 450 mm-1000 mm × 450 mm |  | 4.NP_SO-101 | 384 | Přívodní | Přívod vzduchu | SUP 43 | SUP | 3048 | 120.711 | 0.0570358 | 500 | 225 | 0.392394 | 550 | 225 | 225 | 100 | 0 | 1000 | 1100 | 1100 × 450-1000 × 450 | 450 | 450 | TA00.09.0589 | 0589 | yes | 0 | 2 | 4 | 1 | 1 | 1 | 1 | 60.3553 | 120.711
14047905 | 3.NP_SO-101 | 315 | 0.0221655 | 0.231479 | 315 mm × 315 mm-315 mm × 250 mm | 0 | 3.NP_SO-101 | 3835.08 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 78.4619 | 0.00698213 | 157.5 | 125 | 0.0813102 | 157.5 | 125 | 157.5 | 0 | 65 | 315 | 315 | 315 × 315-315 × 250 | 250 | 315 | TA00.09.0664 | 0664 | yes | 0 | 1 | 1 | 1.3 | 1.3 | 1.69 | 1.3 | 78.4619 | 60.3553
14058114 | 4.NP_SO-101 | 500 | 0.0543198 | 0.580656 | 500 mm × 500 mm-500 mm × 400 mm | 0 | 4.NP_SO-101 | 1931.9 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048.01 | 120.711 | 0.0271599 | 250 | 250.009 | 0.202501 | 250 | 250 | 200 | 0 | 100 | 500 | 500 | 500 × 500-500 × 400 | 500 | 400 | TA00.09.0706 | 0706 |  | 0.00856288 | 1 | 1 | 2.00034 | 1.99966 | 4 | 2 | 120.711 | 60.3553
14058472 | 4.NP_SO-101 |  |  |  | 500 mm × 500 mm-280 mm × 280 mm | 0 | 4.NP_SO-101 | 2271.11 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 3048 | 265.563 | 0.0414633 | 250 | 250 | 0.245988 | 140 | 250 | 140 | 220 | 220 | 500 | 280 | 500 × 500-280 × 280 | 500 | 280 | TA00.09.0710 | 0710 |  | 0 | 4.4 | 19.36 | 4.4 | 4.4 | 19.36 | 4.4 | 265.563 | 265.563
