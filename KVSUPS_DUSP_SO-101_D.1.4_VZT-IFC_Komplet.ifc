Properties of the parts of a building model (IFC4), part 18 of 21

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (62)
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) = a (mm) = c (mm) = Výš. (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 5 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) = Délka 8 (mm) | Délka 6 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
14060070 | 4.NP_SO-101 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 4.NP_SO-101 | 1814 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 30 | 400 | 400 | 0.106832 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.01.0712 | 0712 |  | 150 | 43.3013 | 4.33013 | 116.025 | 0 | 259.808 | 10080.4 | 25 | 2.5 | 338.675 | 300 | 258.819 | 250 | 300 | 133.975 | 500 | 400 | 600 | 300 | 80.3848 | 9930.38 | 130.385 | 1000 | 1000 | 400 | 1000 | 200 | 133.975 | 1000 | 800
14060145 | 4.NP_SO-101 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 4.NP_SO-101 | 1814 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.01.0713 | 0713 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10300 | 50 | 5 | 550 | 550 | 707.107 | 500 | 300 | 500 | 500 | 400 | 600 | 300 | 300 | 10000 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14064294 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm | 0 | 4.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 280 | 280 | 0.023402 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0734 | 0734 |  | 135 | 35.3553 | 3.53553 | 111.299 | 0 | 169.706 | 10099.4 | 35.3553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 149.411 | 280 | 280 | 280 | 280 | 140 | 157.401 | 880 | 620
14064295 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm | 0 | 4.NP_SO-101 | 2900 | Odváděný | Zpětný vzduch | ETA 19 | ETA | 45 | 280 | 280 | 0.023402 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0735 | 0735 |  | 135 | 35.3553 | 3.53553 | 111.299 | 0 | 169.706 | 10099.4 | 35.3553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 149.411 | 280 | 280 | 280 | 280 | 140 | 157.401 | 880 | 620
14067023 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm |  | 4.NP_SO-101 | 3720 | Odváděný | Zpětný vzduch | ETA 9 | ETA | 30 | 280 | 280 | 0.018476 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0746 | 0746 |  | 150 | 43.3013 | 4.33013 | 88.1793 | 0 | 207.846 | 10064.3 | 25 | 2.5 | 269.393 | 240 | 196.702 | 190 | 240 | 101.821 | 380 | 280 | 480 | 240 | 64.3078 | 9944.31 | 114.308 | 280 | 280 | 280 | 280 | 140 | 101.821 | 880 | 620
14067405 | 4.NP_SO-101 | 280 | 0.0154 | 0.1876 | 280 mm × 280 mm-280 mm × 280 mm |  | 4.NP_SO-101 | 3839.31 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 30 | 280 | 280 | 0.018476 | 340 | 340 | 340 | 280 × 280-280 × 280 | TA00.01.0747 | 0747 |  | 150 | 43.3013 | 4.33013 | 88.1793 | 0 | 207.846 | 10064.3 | 25 | 2.5 | 269.393 | 240 | 196.702 | 190 | 240 | 101.821 | 380 | 280 | 480 | 240 | 64.3078 | 9944.31 | 114.308 | 280 | 280 | 280 | 280 | 140 | 101.821 | 880 | 620
14069685 | 1.NP_SO-101 | 315 | 0.011 | 0.16065 | 200 mm × 315 mm-200 mm × 315 mm | 0 | 1.NP_SO-101 | 16831.7 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 90 | 200 | 200 | 0.0267219 | 375 | 260 | 260 | 200 × 315-200 × 315 | TA00.01.0758 | 0758 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 315 | 315 | 200 | 315 | 100 | 300 | 800 | 500
14070313 | 4.NP_SO-101 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm |  | 4.NP_SO-101 | 3700 | Přívodní | Přívod vzduchu | SUP 2 | SUP | 90 | 200 | 200 | 0.0339325 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.01.0766 | 0766 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 400 | 400 | 200 | 400 | 100 | 300 | 800 | 500
14071741 | 1.NP_SO-101 | 355 | 0.0099 | 0.16685 | 180 mm × 355 mm-180 mm × 355 mm | 0 | 1.NP_SO-101 | 7539.74 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 45 | 180 | 180 | 0.0165644 | 415 | 240 | 240 | 180 × 355-180 × 355 | TA00.01.0775 | 0775 |  | 135 | 35.3553 | 3.53553 | 82.0101 | 0 | 134.35 | 10078.7 | 35.3553 | 3.53553 | 330 | 247.99 | 214.303 | 197.99 | 190 | 115.98 | 280 | 180 | 380 | 190 | 78.7006 | 9944.35 | 128.701 | 355 | 355 | 180 | 355 | 90 | 115.98 | 780 | 470
14071757 | 1.NP_SO-101 | 355 | 0.0099 | 0.16685 | 180 mm × 355 mm-180 mm × 355 mm | 0 | 1.NP_SO-101 | 7779.76 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 45 | 180 | 180 | 0.0165644 | 415 | 240 | 240 | 180 × 355-180 × 355 | TA00.01.0776 | 0776 |  | 135 | 35.3553 | 3.53553 | 82.0101 | 0 | 134.35 | 10078.7 | 35.3553 | 3.53553 | 330 | 247.99 | 214.303 | 197.99 | 190 | 115.98 | 280 | 180 | 380 | 190 | 78.7006 | 9944.35 | 128.701 | 355 | 355 | 180 | 355 | 90 | 115.98 | 780 | 470
14071856 | 1.NP_SO-101 | 355 | 0.0099 | 0.16685 | 180 mm × 355 mm-180 mm × 355 mm | 0 | 1.NP_SO-101 | 12179.8 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 45 | 180 | 180 | 0.0165644 | 415 | 240 | 240 | 180 × 355-180 × 355 | TA00.01.0777 | 0777 |  | 135 | 35.3553 | 3.53553 | 82.0101 | 0 | 134.35 | 10078.7 | 35.3553 | 3.53553 | 330 | 247.99 | 214.303 | 197.99 | 190 | 115.98 | 280 | 180 | 380 | 190 | 78.7006 | 9944.35 | 128.701 | 355 | 355 | 180 | 355 | 90 | 115.98 | 780 | 470
14071879 | 1.NP_SO-101 | 355 | 0.0099 | 0.16685 | 180 mm × 355 mm-180 mm × 355 mm | 0 | 1.NP_SO-101 | 12468.2 | Odváděný | Zpětný vzduch | ETA 5 | ETA | 45 | 180 | 180 | 0.0165644 | 415 | 240 | 240 | 180 × 355-180 × 355 | TA00.01.0778 | 0778 |  | 135 | 35.3553 | 3.53553 | 82.0101 | 0 | 134.35 | 10078.7 | 35.3553 | 3.53553 | 330 | 247.99 | 214.303 | 197.99 | 190 | 115.98 | 280 | 180 | 380 | 190 | 78.7006 | 9944.35 | 128.701 | 355 | 355 | 180 | 355 | 90 | 115.98 | 780 | 470
14073619 | -1.PP_SO-101 | 355 | 0.03465 | 0.48635 | 630 mm × 355 mm-630 mm × 355 mm |  | -1.PP_SO-101 | 1900.01 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 45 | 630 | 630 | 0.0974978 | 415 | 690 | 690 | 630 × 355-630 × 355 | TA00.01.0786 | 0786 |  | 135 | 35.3553 | 3.53553 | 213.812 | 0 | 293.449 | 10171.9 | 35.3553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 9878.45 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
14073629 | -1.PP_SO-101 | 355 | 0.03465 | 0.48635 | 630 mm × 355 mm-630 mm × 355 mm |  | -1.PP_SO-101 | 1900.01 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 45 | 630 | 630 | 0.0974978 | 415 | 690 | 690 | 630 × 355-630 × 355 | TA00.01.0787 | 0787 |  | 135 | 35.3553 | 3.53553 | 213.812 | 0 | 293.449 | 10171.9 | 35.3553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 9878.45 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
14080273 | 4.NP_SO-101 | 125 | 0.011 | 0.06375 | 200 mm × 125 mm-200 mm × 125 mm |  | 4.NP_SO-101 | -4442.27 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 45 | 200 | 200 | 0.00667695 | 185 | 260 | 260 | 200 × 125-200 × 125 | TA00.01.0818 | 0818 |  | 135 | 35.3553 | 3.53553 | 87.868 | 0 | 141.421 | 10082.8 | 35.3553 | 3.53553 | 350 | 262.132 | 229.61 | 212.132 | 200 | 124.264 | 300 | 200 | 400 | 200 | 82.8427 | 9941.42 | 132.843 | 200 | 200 | 200 | 200 | 100 | 124.264 | 800 | 500
14080403 | 4.NP_SO-101 | 125 | 0.011 | 0.06375 | 200 mm × 125 mm-200 mm × 125 mm |  | 4.NP_SO-101 | -4242.45 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 45 | 200 | 200 | 0.00667695 | 185 | 260 | 260 | 200 × 125-200 × 125 | TA00.01.0819 | 0819 |  | 135 | 35.3553 | 3.53553 | 87.868 | 0 | 141.421 | 10082.8 | 35.3553 | 3.53553 | 350 | 262.132 | 229.61 | 212.132 | 200 | 124.264 | 300 | 200 | 400 | 200 | 82.8427 | 9941.42 | 132.843 | 200 | 200 | 200 | 200 | 100 | 124.264 | 800 | 500
14080656 | 4.NP_SO-101 | 125 | 0.011 | 0.06375 | 200 mm × 125 mm-200 mm × 125 mm |  | 4.NP_SO-101 | -1238.65 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 90 | 200 | 200 | 0.0106039 | 185 | 260 | 260 | 200 × 125-200 × 125 | TA00.01.0820 | 0820 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 200 | 200 | 200 | 200 | 100 | 300 | 800 | 500
14080659 | 4.NP_SO-101 | 125 | 0.011 | 0.06375 | 200 mm × 125 mm-200 mm × 125 mm |  | 4.NP_SO-101 | -1238.65 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 90 | 200 | 200 | 0.0106039 | 185 | 260 | 260 | 200 × 125-200 × 125 | TA00.01.0821 | 0821 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10200 | 50 | 5 | 350 | 350 | 424.264 | 300 | 200 | 300 | 300 | 200 | 400 | 200 | 200 | 10000 | 250 | 200 | 200 | 200 | 200 | 100 | 300 | 800 | 500
14081032 | -1.PP_SO-101 | 125 | 0.0099 | 0.05875 | 180 mm × 125 mm-180 mm × 125 mm | 0 | -1.PP_SO-101 | 2520 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 45 | 180 | 180 | 0.00583254 | 185 | 240 | 240 | 180 × 125-180 × 125 | TA00.01.0825 | 0825 |  | 135 | 35.3553 | 3.53553 | 82.0101 | 0 | 134.35 | 10078.7 | 35.3553 | 3.53553 | 330 | 247.99 | 214.303 | 197.99 | 190 | 115.98 | 280 | 180 | 380 | 190 | 78.7006 | 9944.35 | 128.701 | 180 | 180 | 180 | 180 | 90 | 115.98 | 780 | 470
14081033 | 4.NP_SO-101 | 200 | 0.006875 | 0.072 | 125 mm × 200 mm-125 mm × 200 mm | 0 | 4.NP_SO-101 | -12630 | Odváděný | Zpětný vzduch | ETA 4 | ETA | 90 | 125 | 125 | 0.00913085 | 260 | 185 | 185 | 125 × 200-125 × 200 | TA00.01.0826 | 0826 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10162.5 | 50 | 5 | 275 | 275 | 318.198 | 225 | 162.5 | 225 | 225 | 125 | 325 | 162.5 | 162.5 | 10000 | 212.5 | 200 | 200 | 125 | 200 | 62.5 | 225 | 725 | 387.5
14081960 | 4.NP_SO-101 | 180 | 0.0099 | 0.0846 | 180 mm × 180 mm-125 mm × 180 mm | 0 | 4.NP_SO-101 | 6975 | Odváděný | Odváděný vzduch | ETA 4 | ETA | 90 | 180 | 125 | 0.0109902 | 240 | 240 | 185 | 180 × 180-125 × 180 | TA00.01.0836 | 0836 |  | 90 | 0 | 0 | 0 | 27.5 | 0 | 10162.5 | 50 | 5 | 275 | 330 | 359.201 | 225 | 190 | 225 | 225 | 125 | 325 | 162.5 | 190 | 10000 | 212.5 | 180 | 180 | 180 | 180 | 90 | 225 | 725 | 470

# IfcDuctFitting: Pravoúhlý spoj T, přímý, přírubový:Standardní, Pravoúhlý spoj T, přímý, přírubový:Standardní:13520640
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: O; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 07; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý spoj T, přímý, přírubový
Classification: TA00 Uniformat (Uniformat); Group: ETA 19
Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 0.0023 m2; NetCrossSectionArea: 0.0023 m2; OuterSurfaceArea: 0.5208 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 500 mm-400 mm × 500 mm-400 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 500 mm-400 mm × 500 mm-400 mm × 500 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 1576.9 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; a: 500 mm; b: 400 mm; d: 400 mm; h: 500 mm; l: 0 mm; Objem: 0.203146 m3; Příruba a: 560 mm; Příruba b: 460 mm; Příruba d: 460 mm; Příruba h: 560 mm; r: 0 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm; Velikost: 500 × 500-400 × 500-400 × 500; x: 0 mm
Identifikační data - Kód prvku: TA00.07.0095; Označení: 0095
Jiné - Páteřní trasa: yes; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; d12: 400 mm; Délka 1: 50 mm; Délka x3: 55 mm; e1: 151 mm; e2: 0 mm; e3: 0 mm; e4: 0 mm; f1: 151.6 mm; f2: 378.3 mm; Id typu: 1170298; l1: 500 mm; l2: 800 mm; m: 0 mm; m1: 2000 mm; m2: 2200 mm; Max abdh: 500 mm; Max bdh: 500 mm; Min abdh: 500 mm; Min bdh: 500 mm; Min bh: 400 mm; Min dh: 400 mm; Odsazení 1: 200 mm; Odsazení 2: 400 mm; r1: 100 mm; Rodina: Pravoúhlý spoj T, přímý, přírubový; Rodina a typ: Pravoúhlý spoj T, přímý, přírubový: Standardní; Viditelnost 3: yes; Viditelnost 4: no; x1: 50 mm; x2: 150 mm

# IfcDuctSegment: Hranaté potrubí:POZINK/T spoj (81)
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: POZINK/T spoj; Označení typu: 01; Popis: Potrubí hranaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Hranaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Uzamknutí velikosti: no
Jiné - Id typu: 352284; Rodina: Hranaté potrubí; Rodina a typ: Hranaté potrubí: POZINK/T spoj; Typ: POZINK/T spoj
Name (Hranaté potrubí:POZINK/T spoj:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Koeficient ztrát | Název systému = Group | Plocha (m2) | Řez | Typ systému | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa
12979067 | 4.NP_SO-101 | 400 | 0.0739517 | 0.553645 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1165 | 965 | 965 | 4.NP_SO-101 | 0 | 765 | 515.562 | 466.667 | Přívod vzduchu | 0 | ODA 1 | 0.253549 | 3 | Čerstvý | ODA | 132.057 | 560 | 560 × 400 | 400 | PO02.01.0001 | 0001 | yes
12980876 | 4.NP_SO-101 | 500 | 0.180692 | 0.863991 | 355 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1050 | 800 | 800 | 4.NP_SO-101 | 0 | 550 | 458.882 | 415.205 | Odváděný vzduch | 0 | EHA 14 | 0.870375 | 15 | Znehodnocený | EHA | 508.991 | 355 | 355 × 500 | 500 | PO02.01.0002 | 0002 | yes
12981055 | 4.NP_SO-101 | 630 | 0.493523 | 1.77043 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1115 | 800 | 800 | 4.NP_SO-101 | 0 | 485 | 730.788 | 667.612 | Odváděný vzduch | 0 | EHA 14 | 1.86287 | 5 | Znehodnocený | EHA | 695.102 | 710 | 710 × 630 | 630 | PO02.01.0003 | 0003 | yes
12981196 | 4.NP_SO-101 | 290 | 0.4473 | 0.7772 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1560 | 1560 | 1270 | 4.NP_SO-101 |  | 1270 | 730.788 | 667.612 | Odváděný vzduch | 0 | EHA 14 | 0.7772 | 5 | Znehodnocený | EHA | 290 | 710 | 710 × 630 | 630 | PO02.01.0004 | 0004 | yes
12990711 | 4.NP_SO-101 | 3113.73 | 0.08 | 3.73648 | 200 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 181.269 | 3295 | 4.NP_SO-101 |  | 181.269 | 304.675 | 266.667 | Zpětný vzduch | 0 | ETA 13 | 3.73648 | 373 | Odváděný | ETA | 3113.73 | 200 | 200 × 400 | 400 | PO02.01.0018 | 0018 | yes | Identifikační data - Komentáře: VEDENO DO 4.NP
13442767 | 4.NP_SO-101 | 3890 | 0.08 | 4.668 | 200 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3445 | -445 | 3445 | 4.NP_SO-101 |  | -445 | 304.675 | 266.667 | Přívod vzduchu | 0 | SUP 2 | 4.668 | 161 | Přívodní | SUP | 3890 | 200 | 200 × 400 | 400 | PO02.01.0071 | 0071 | yes
13480777 | 4.NP_SO-101 | 500 | 0.212975 | 0.954929 | 355 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 754 | 504 | 504 | 4.NP_SO-101 | 0 | 254 | 458.882 | 415.205 | Odváděný vzduch | 0 | EHA 14 | 1.02588 | 23 | Znehodnocený | EHA | 599.929 | 355 | 355 × 500 | 500 | PO02.01.0129 | 0129 | yes
13512748 | 4.NP_SO-101 | 450 | 0.3927 | 1.3113 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 609 | 384 | 384 | 4.NP_SO-101 | 0 | 159 | 750.738 | 638.71 | Přívod vzduchu | 0 | SUP 43 | 1.1067 | 341 | Přívodní | SUP | 357 | 1100 | 1100 × 450 | 450 | PO02.01.0163 | 0163 | yes
13512794 | 4.NP_SO-101 | 630 | 0.0988 | 0.81522 | 400 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1585.11 | 1270.11 | 1270.11 | 4.NP_SO-101 | 0 | 955.11 | 545.267 | 489.32 | Přívod vzduchu | 0 | SUP 43 | 0.50882 | 311 | Přívodní | SUP | 247 | 400 | 400 × 630 | 630 | PO02.01.0164 | 0164 | yes
13518474 | 4.NP_SO-101 | 246.101 | 0.5041 | 0.698928 | 710 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1566.1 | 1566.1 | 1320 | 4.NP_SO-101 |  | 1320 | 776.147 | 710 | Přívod vzduchu | 0 | ODA 1 | 0.698928 | 1 | Čerstvý | ODA | 246.101 | 710 | 710 × 710 | 710 | PO02.01.0166 | 0166 | yes
13519402 | 4.NP_SO-101 | 355 | 0.00932886 | 0.368247 | 355 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 835.373 | 658.597 | 645.403 | 4.NP_SO-101 | 100 | 468.627 | 458.882 | 415.205 | Odváděný vzduch | 0 | EHA 14 | 0.0319047 | 23 | Znehodnocený | EHA | 18.6577 | 355 | 355 × 500 | 500 | PO02.01.0167 | 0167 | yes
13519413 | 4.NP_SO-101 | 500 | 0.0173223 | 0.403795 | 355 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1050 | 800 | 800 | 4.NP_SO-101 | 0 | 550 | 458.882 | 415.205 | Odváděný vzduch | 0 | EHA 14 | 0.0834398 | 23 | Znehodnocený | EHA | 48.7952 | 355 | 355 × 500 | 500 | PO02.01.0168 | 0168 | yes
13520138 | 4.NP_SO-101 | 400 | 0.0192586 | 0.815407 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1776.9 | 1576.9 | 1576.9 | 4.NP_SO-101 | 0 | 1376.9 | 674.06 | 571.429 | Zpětný vzduch | 0 | ETA 19 | 0.0539242 | 335 | Odváděný | ETA | 19.2586 | 1000 | 1000 × 400 | 400 | PO02.01.0169 | 0169 | yes
13520551 | 4.NP_SO-101 | 400 | 0.0117091 | 0.418735 | 500 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1776.9 | 1576.9 | 1576.9 | 4.NP_SO-101 | 0 | 1376.9 | 488.12 | 444.444 | Zpětný vzduch | 0 | ETA 19 | 0.0421529 | 362 | Odváděný | ETA | 23.4183 | 500 | 500 × 400 | 400 | PO02.01.0170 | 0170 | yes
13520641 | 4.NP_SO-101 | 400 | 0.307684 | 0.892294 | 500 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1776.9 | 1576.9 | 1576.9 | 4.NP_SO-101 | 0 | 1376.9 | 488.12 | 444.444 | Zpětný vzduch | 0 | ETA 19 | 1.10766 | 357 | Odváděný | ETA | 615.367 | 500 | 500 × 400 | 400 | PO02.01.0171 | 0171 | yes
13612709 | -1.PP_SO-101 | 670.198 | 0.2835 | 1.44763 | 630 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2902.76 | 2902.71 | 2232.51 | -1.PP_SO-101 | 417476 | 2232.46 | 580.007 | 525 | Přívod vzduchu | 0 | SUP 1 | 1.44763 | 229 | Přívodní | SUP | 670.198 | 630 | 630 × 450 | 450 | PO02.01.0222 | 0222 | yes | Identifikační data - Komentáře: VZT1
13613386 | -1.PP_SO-101 | 355 | 0.233152 | 0.710058 | 630 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2077.51 | 1900.01 | 1900.01 | -1.PP_SO-101 | 0 | 1722.51 | 511.758 | 454.112 | Přívod vzduchu | 0 | SUP 1 | 0.729062 | 230 | Přívodní | SUP | 370.082 | 630 | 630 × 355 | 355 | PO02.01.0224 | 0224 | yes
13735974 | -1.PP_SO-101 | 56.6546 | 0.1764 | 0.0991455 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1617.65 | 1617.65 | 1560.99 | -1.PP_SO-101 |  | 1560.99 | 454.468 | 403.2 | Odváděný vzduch | 0 | EHA 3 | 0.0991455 | 2 | Znehodnocený | EHA | 56.6546 | 560 | 560 × 315 | 315 | PO02.01.0286 | 0286 | yes
13736064 | -1.PP_SO-101 | 270.764 | 0.1764 | 0.473837 | 315 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2127.5 | 2127.5 | 1856.74 | -1.PP_SO-101 |  | 1856.74 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.473837 | 2 | Čerstvý | ODA | 270.764 | 315 | 315 × 560 | 560 | PO02.01.0287 | 0287 | yes
13736728 | -1.PP_SO-101 | 315 | 0.256186 | 0.641009 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2597.5 | 2440 | 2440 | -1.PP_SO-101 | 0 | 2282.5 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.800581 | 2 | Čerstvý | ODA | 457.475 | 560 | 560 × 315 | 315 | PO02.01.0288 | 0288 | yes
13737316 | -1.PP_SO-101 | 400 | 0.0226032 | 0.48029 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2650 | 2450 | 2450 | -1.PP_SO-101 | 0 | 2250 | 515.562 | 466.667 | Zpětný vzduch | 0 | ETA 30 | 0.0774968 | 3 | Odváděný | ETA | 40.3629 | 560 | 560 × 400 | 400 | PO02.01.0289 | 0289 | yes
13737329 | -1.PP_SO-101 | 703 | 0.28 | 1.5466 | 700 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2095 | 2095 | 1392 | -1.PP_SO-101 |  | 1392 | 572.887 | 509.091 | Zpětný vzduch | 0 | ETA 30 | 1.5466 | 245 | Odváděný | ETA | 703 | 700 | 700 × 400 | 400 | PO02.01.0290 | 0290 | yes
13738044 | -1.PP_SO-101 | 400 | 0.860703 | 1.67758 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2462.59 | 2262.59 | 2262.59 | -1.PP_SO-101 | 0 | 2062.59 | 515.562 | 466.667 | Přívod vzduchu | 0 | SUP 27 | 2.95098 | 371 | Přívodní | SUP | 1536.97 | 560 | 560 × 400 | 400 | PO02.01.0295 | 0295 | yes
13739200 | -1.PP_SO-101 | 355 | 0.134254 | 0.598602 | 630 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2077.51 | 1900.01 | 1900.01 | -1.PP_SO-101 | 0 | 1722.51 | 511.758 | 454.112 | Přívod vzduchu | 0 | SUP 1 | 0.41981 | 233 | Přívodní | SUP | 213.101 | 630 | 630 × 355 | 355 | PO02.01.0299 | 0299 | yes
13739321 | -1.PP_SO-101 | 355 | 0.00403538 | 0.451848 | 630 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2077.51 | 1900 | 1900.01 | -1.PP_SO-101 | 0 | 1722.5 | 511.758 | 454.112 | Přívod vzduchu | 0 | SUP 1 | 0.0126186 | 230 | Přívodní | SUP | 6.40537 | 630 | 630 × 355 | 355 | PO02.01.0300 | 0300 | yes
13739394 | -1.PP_SO-101 | 400 | 0.225219 | 0.769742 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2462.59 | 2262.59 | 2262.59 | -1.PP_SO-101 | 0 | 2062.59 | 515.562 | 466.667 | Přívod vzduchu | 0 | SUP 27 | 0.77218 | 369 | Přívodní | SUP | 402.177 | 560 | 560 × 400 | 400 | PO02.01.0301 | 0301 | yes
13760009 | -1.PP_SO-101 | 560 | 0.0286605 | 0.454704 | 315 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 880 | 600 | 600 | -1.PP_SO-101 | 0 | 320 | 454.468 | 403.2 | Odváděný vzduch | 0 | EHA 3 | 0.159225 | 7 | Znehodnocený | EHA | 90.9857 | 315 | 315 × 560 | 560 | PO02.01.0305 | 0305 | yes
13760030 | -1.PP_SO-101 | 560 | 0.510083 | 1.70259 | 500 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 880 | 600 | 600 | -1.PP_SO-101 | 0 | 320 | 578.217 | 528.302 | Odváděný vzduch | 0 | EHA 3 | 2.16275 | 8 | Znehodnocený | EHA | 1020.17 | 500 | 500 × 560 | 560 | PO02.01.0306 | 0306 | yes
13760616 | -1.PP_SO-101 | 560 | 0.413019 | 1.48516 | 500 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 880 | 600 | 600 | -1.PP_SO-101 | 0 | 320 | 578.217 | 528.302 | Odváděný vzduch | 0 | EHA 3 | 1.7512 | 5 | Znehodnocený | EHA | 826.039 | 500 | 500 × 560 | 560 | PO02.01.0307 | 0307 | yes
13844721 | 4.NP_SO-101 | 500 | 0.0173223 | 0.403795 | 355 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1050 | 800 | 800 | 4.NP_SO-101 | 0 | 550 | 458.882 | 415.205 | Odváděný vzduch | 0 | EHA 14 | 0.0834398 | 15 | Znehodnocený | EHA | 48.7952 | 355 | 355 × 500 | 500 | PO02.01.0393 | 0393 | yes
13849405 | 3.NP_SO-101 | 526.567 | 0.0882 | 0.626615 | 280 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3871.29 | 3344.72 | 3871.29 | 3.NP_SO-101 |  | 3344.72 | 324.513 | 296.471 | Přívod vzduchu | 0 | SUP 43 | 0.626615 | 204 | Přívodní | SUP | 526.567 | 280 | 280 × 315 | 315 | PO02.01.0396 | 0396 | yes | Identifikační data - Komentáře: VEDENO DO 3.NP
13849437 | 3.NP_SO-101 | 442.116 | 0.07875 | 0.499591 | 315 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3835.08 | 3835.08 | 3392.96 | 3.NP_SO-101 |  | 3392.96 | 306.258 | 278.761 | Zpětný vzduch | 0 | ETA 19 | 0.499591 | 230 | Odváděný | ETA | 442.116 | 315 | 315 × 250 | 250 | PO02.01.0397 | 0397 | yes | Identifikační data - Komentáře: VZT3
13849509 | 4.NP_SO-101 | 36.11 | 0.4 | 0.101108 | 400 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 800.11 | 764 | 800.11 | 4.NP_SO-101 |  | 764 | 674.06 | 571.429 | Přívod vzduchu | 0 | SUP 43 | 0.101108 | 211 | Přívodní | SUP | 36.11 | 400 | 400 × 1000 | 1000 | PO02.01.0398 | 0398 | yes
13916764 | 4.NP_SO-101 | 280 | 0.0465656 | 0.249931 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3860 | 3720 | 3720 | 4.NP_SO-101 | 0 | 3580 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.186262 | 319 | Odváděný | ETA | 166.306 | 280 | 280 × 280 | 280 | PO02.01.0430 | 0430 | yes
13917228 | 4.NP_SO-101 | 280 | 0.0472851 | 0.25137 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3860 | 3720 | 3720 | 4.NP_SO-101 | 0 | 3580 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.189141 | 319 | Odváděný | ETA | 168.876 | 280 | 280 × 280 | 280 | PO02.01.0431 | 0431 | yes
13917464 | 4.NP_SO-101 | 400 | 0.286806 | 0.85889 | 500 mm × 400 mm | 0.00104394 | 0.00833333 | 1223.65 | 0.0416667 | 0.0000327132 | 0.000122852 | 1776.9 | 1576.9 | 1576.9 | 4.NP_SO-101 | 0 | 1376.9 | 488.12 | 444.444 | Zpětný vzduch | 0.0313363 | ETA 19 | 1.0325 | 361 | Odváděný | ETA | 573.612 | 500 | 500 × 400 | 400 | PO02.01.0432 | 0432 | yes
13935471 | 4.NP_SO-101 | 630 | 0.429966 | 1.85839 | 400 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1585.11 | 1270.11 | 1270.11 | 4.NP_SO-101 | 0 | 955.11 | 545.267 | 489.32 | Přívod vzduchu | 0 | SUP 43 | 2.21432 | 345 | Přívodní | SUP | 1074.91 | 400 | 400 × 630 | 630 | PO02.01.0495 | 0495 | yes
13935974 | 4.NP_SO-101 | 180 | 0.0559481 | 0.172707 | 200 mm × 180 mm | 0.0322204 | 0.00833333 | 2898.11 | 0.231481 | 0.00212553 | 0.00759823 | 2430 | 2340 | 2340 | 4.NP_SO-101 | 0 | 2250 | 207.342 | 189.474 | Zpětný vzduch | 0.0659686 | ETA 19 | 0.212603 | 363 | Odváděný | ETA | 279.74 | 200 | 200 × 180 | 180 | PO02.01.0496 | 0496 | yes
13935975 | 4.NP_SO-101 | 180 | 0.0140201 | 0.0972362 | 200 mm × 180 mm | 0.0322204 | 0.00833333 | 2898.11 | 0.231481 | 0.000532639 | 0.00759823 | 2430 | 2340 | 2340 | 4.NP_SO-101 | 0 | 2250 | 207.342 | 189.474 | Zpětný vzduch | 0.0165312 | ETA 19 | 0.0532764 | 363 | Odváděný | ETA | 70.1005 | 200 | 200 × 180 | 180 | PO02.01.0497 | 0497 | yes
13936046 | 4.NP_SO-101 | 280 | 0.00687984 | 0.17056 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3040 | 2900 | 2900 | 4.NP_SO-101 | 0 | 2760 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.0275194 | 358 | Odváděný | ETA | 24.5709 | 280 | 280 × 280 | 280 | PO02.01.0498 | 0498 | yes
13936056 | 4.NP_SO-101 | 726.503 | 0.0784 | 0.813683 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2605 | 2605 | 1878.5 | 4.NP_SO-101 |  | 1878.5 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.813683 | 358 | Odváděný | ETA | 726.503 | 280 | 280 × 280 | 280 | PO02.01.0499 | 0499 | yes
13936186 | 4.NP_SO-101 | 280 | 0.08067 | 0.31814 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3040 | 2900 | 2900 | 4.NP_SO-101 | 0 | 2760 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.32268 | 358 | Odváděný | ETA | 288.107 | 280 | 280 × 280 | 280 | PO02.01.0500 | 0500 | yes
13936214 | 4.NP_SO-101 | 280 | 0.0217533 | 0.200307 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3040 | 2900 | 2900 | 4.NP_SO-101 | 0 | 2760 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.087013 | 358 | Odváděný | ETA | 77.6902 | 280 | 280 × 280 | 280 | PO02.01.0501 | 0501 | yes
13936226 | 4.NP_SO-101 | 1448.34 | 0.099225 | 1.82491 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2605 | 1156.66 | 2605 | 4.NP_SO-101 |  | 1156.66 | 344.347 | 315 | Zpětný vzduch | 0 | ETA 19 | 1.82491 | 359 | Odváděný | ETA | 1448.34 | 315 | 315 × 315 | 315 | PO02.01.0502 | 0502 | yes
13936267 | 4.NP_SO-101 | 280 | 0.117756 | 0.392313 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3040 | 2900 | 2900 | 4.NP_SO-101 | 0 | 2760 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.471025 | 358 | Odváděný | ETA | 420.558 | 280 | 280 × 280 | 280 | PO02.01.0503 | 0503 | yes
13936810 | 4.NP_SO-101 | 216.503 | 0.036 | 0.164542 | 200 mm × 180 mm | 0.0322204 | 0.00833333 | 2898.11 | 0.231481 | 0.00164504 | 0.00759823 | 2095 | 1878.5 | 2095 | 4.NP_SO-101 |  | 1878.5 | 207.342 | 189.474 | Zpětný vzduch | 0.0510558 | ETA 19 | 0.164542 | 363 | Odváděný | ETA | 216.503 | 200 | 200 × 180 | 180 | PO02.01.0504 | 0504 | yes
13939056 | 4.NP_SO-101 | 180 | 0.148 | 0.3384 | 200 mm × 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2340 | 2340 | 4.NP_SO-101 | 0 | 2250 | 207.342 | 189.474 | Přívod vzduchu | 0 | SUP 43 | 0.5624 | 306 | Přívodní | SUP | 740 | 200 | 200 × 180 | 180 | PO02.01.0509 | 0509 | yes
13939064 | 4.NP_SO-101 | 408.29 | 0.036 | 0.3103 | 200 mm × 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2095 | 2095 | 1686.71 | 4.NP_SO-101 |  | 1686.71 | 207.342 | 189.474 | Přívod vzduchu | 0 | SUP 43 | 0.3103 | 306 | Přívodní | SUP | 408.29 | 200 | 200 × 180 | 180 | PO02.01.0510 | 0510 | yes
13939123 | 4.NP_SO-101 | 180 | 0.0619797 | 0.183563 | 200 mm × 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2340 | 2340 | 4.NP_SO-101 | 0 | 2250 | 207.342 | 189.474 | Přívod vzduchu | 0 | SUP 43 | 0.235523 | 306 | Přívodní | SUP | 309.898 | 200 | 200 × 180 | 180 | PO02.01.0511 | 0511 | yes
13939323 | 4.NP_SO-101 | 180 | 0.417 | 0.8226 | 200 mm × 180 mm | 0.0322204 | 0.00833333 | 2898.11 | 0.231481 | 0.0141951 | 0.00759823 | 2430 | 2340 | 2340 | 4.NP_SO-101 | 0 | 2250 | 207.342 | 189.474 | Zpětný vzduch | 0.440563 | ETA 19 | 1.5846 | 363 | Odváděný | ETA | 2085 | 200 | 200 × 180 | 180 | PO02.01.0512 | 0512 | yes
13968215 | 4.NP_SO-101 | 630 | 0.0303095 | 0.599475 | 400 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1585.11 | 1270.11 | 1270.11 | 4.NP_SO-101 | 0 | 955.11 | 545.267 | 489.32 | Přívod vzduchu | 0 | SUP 43 | 0.156094 | 304 | Přívodní | SUP | 75.7737 | 400 | 400 × 630 | 630 | PO02.01.0542 | 0542 | yes
14028816 | 4.NP_SO-101 | 400 | 0.0855053 | 0.57015 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1165 | 965 | 965 | 4.NP_SO-101 | 0 | 765 | 515.562 | 466.667 | Přívod vzduchu | 0 | ODA 1 | 0.293161 | 3 | Čerstvý | ODA | 152.688 | 560 | 560 × 400 | 400 | PO02.01.0576 | 0576 | yes
14028864 | 4.NP_SO-101 | 400 | 0.00377523 | 0.453393 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1165 | 965 | 965 | 4.NP_SO-101 | 0 | 765 | 515.562 | 466.667 | Přívod vzduchu | 0 | ODA 1 | 0.0129436 | 3 | Čerstvý | ODA | 6.74148 | 560 | 560 × 400 | 400 | PO02.01.0577 | 0577 | yes
14029041 | 4.NP_SO-101 | 450 | 0.227188 | 1.17588 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1259 | 1034 | 1034 | 4.NP_SO-101 | 0 | 809 | 750.738 | 638.71 | Přívod vzduchu | 0 | ODA 1 | 0.640256 | 6 | Čerstvý | ODA | 206.534 | 1100 | 1100 × 450 | 450 | PO02.01.0578 | 0578 | yes
14029262 | 4.NP_SO-101 | 400 | 0.277616 | 0.909613 | 355 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 704 | 504 | 504 | 4.NP_SO-101 | 0 | 304 | 411.753 | 376.159 | Odváděný vzduch | 0 | EHA 14 | 1.18084 | 22 | Znehodnocený | EHA | 782.016 | 355 | 355 × 400 | 400 | PO02.01.0579 | 0579 | yes
14031321 | 4.NP_SO-101 | 4.88173 | 0.099225 | 0.00615098 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 418.419 | 418.419 | 413.537 | 4.NP_SO-101 |  | 413.537 | 344.347 | 315 | Přívod vzduchu | 0 | SUP 43 | 0.00615098 | 274 | Přívodní | SUP | 4.88173 | 315 | 315 × 315 | 315 | PO02.01.0585 | 0585 | yes
14031456 | 4.NP_SO-101 | 315 | 0.00915019 | 0.21675 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 826.299 | 714.93 | 694.39 | 4.NP_SO-101 | 100 | 583.02 | 344.347 | 315 | Přívod vzduchu | 0 | SUP 43 | 0.0366008 | 274 | Přívodní | SUP | 29.0482 | 315 | 315 × 315 | 315 | PO02.01.0586 | 0586 | yes
14031929 | -1.PP_SO-101 | 315 | 0.923487 | 1.39172 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1457.5 | 1300 | 1300 | -1.PP_SO-101 | 0 | 1142.5 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 2.8859 | 4 | Čerstvý | ODA | 1649.08 | 560 | 560 × 315 | 315 | PO02.01.0587 | 0587 | yes
14032075 | -1.PP_SO-101 | 315 | 0.240268 | 0.623102 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2597.5 | 2440 | 2440 | -1.PP_SO-101 | 0 | 2282.5 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.750839 | 2 | Čerstvý | ODA | 429.051 | 560 | 560 × 315 | 315 | PO02.01.0588 | 0588 | yes
14032193 | -1.PP_SO-101 | 315 | 0.0421107 | 0.400175 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2597.5 | 2440 | 2440 | -1.PP_SO-101 | 0 | 2282.5 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.131596 | 2 | Čerstvý | ODA | 75.1977 | 560 | 560 × 315 | 315 | PO02.01.0589 | 0589 | yes
14032204 | -1.PP_SO-101 | 315 | 0.00972844 | 0.363744 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2597.5 | 2440 | 2440 | -1.PP_SO-101 | 0 | 2282.5 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.0304014 | 2 | Čerstvý | ODA | 17.3722 | 560 | 560 × 315 | 315 | PO02.01.0590 | 0590 | yes
14033967 | -1.PP_SO-101 | 560 | 0.179616 | 0.962339 | 500 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2210 | 1930 | 1930 | -1.PP_SO-101 | 0 | 1650 | 578.217 | 528.302 | Odváděný vzduch | 0 | EHA 3 | 0.76157 | 3 | Znehodnocený | EHA | 359.231 | 500 | 500 × 560 | 560 | PO02.01.0594 | 0594 | yes
14034823 | -1.PP_SO-101 | 387.574 | 0.28 | 0.821656 | 500 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1422.57 | 1035 | 1422.57 | -1.PP_SO-101 |  | 1035 | 578.217 | 528.302 | Odváděný vzduch | 0 | EHA 3 | 0.821656 | 5 | Znehodnocený | EHA | 387.574 | 500 | 500 × 560 | 560 | PO02.01.0595 | 0595 | yes
14034907 | -1.PP_SO-101 | 219.259 | 0.1764 | 0.383703 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2127.5 | 2127.5 | 1908.24 | -1.PP_SO-101 |  | 1908.24 | 454.468 | 403.2 | Přívod vzduchu | 0 | ODA 3 | 0.383703 | 2 | Čerstvý | ODA | 219.259 | 560 | 560 × 315 | 315 | PO02.01.0596 | 0596 | yes
14047348 | 4.NP_SO-101 | 400 | 0.000564065 | 0.162256 | 400 mm × 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 28.6379 | -23.8045 | -21.3621 | 4.NP_SO-101 | 173.205 | -73.8045 | 304.675 | 266.667 | Zpětný vzduch | 0 | ETA 13 | 0.00338439 | 373 | Odváděný | ETA | 2.82032 | 400 | 400 × 200 | 200 | PO02.01.0619 | 0619
14047383 | 4.NP_SO-101 | 218.564 | 0.08 | 0.262277 | 400 mm × 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | -226.436 | -445 | -226.436 | 4.NP_SO-101 |  | -445 | 304.675 | 266.667 | Zpětný vzduch | 0 | ETA 13 | 0.262277 | 373 | Odváděný | ETA | 218.564 | 400 | 400 × 200 | 200 | PO02.01.0620 | 0620 | yes
14047786 | 4.NP_SO-101 | 56.7393 | 0.099225 | 0.0714915 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 470.276 | 470.276 | 413.537 | 4.NP_SO-101 |  | 413.537 | 344.347 | 315 | Zpětný vzduch | 0 | ETA 19 | 0.0714915 | 359 | Odváděný | ETA | 56.7393 | 315 | 315 × 315 | 315 | PO02.01.0621 | 0621 | yes
14047931 | 4.NP_SO-101 | 315 | 0.0598908 | 0.318232 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 992.058 | 746.247 | 880.689 | 4.NP_SO-101 | 100 | 634.878 | 344.347 | 315 | Zpětný vzduch | 0 | ETA 19 | 0.239563 | 359 | Odváděný | ETA | 190.13 | 315 | 315 × 315 | 315 | PO02.01.0622 | 0622 | yes
14052894 | 4.NP_SO-101 | 450 | 0.0264208 | 1.01162 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 729 | 504 | 504 | 4.NP_SO-101 | 0 | 279 | 750.738 | 638.71 | Odváděný vzduch | 0 | EHA 14 | 0.0744587 | 19 | Znehodnocený | EHA | 24.0189 | 1100 | 1100 × 450 | 450 | PO02.01.0632 | 0632 | yes
14053012 | 4.NP_SO-101 | 450 | 0.00320816 | 0.992625 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 609 | 384 | 384 | 4.NP_SO-101 | 0 | 159 | 750.738 | 638.71 | Odváděný vzduch | 0 | EHA 1 | 0.00904119 | 21 | Znehodnocený | EHA | 2.91651 | 1100 | 1100 × 450 | 450 | PO02.01.0633 | 0633
14053406 | 4.NP_SO-101 | 1100 | 0.00887014 | 1.03337 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 627.814 | 423.103 | 432.958 | 4.NP_SO-101 | 57.735 | 228.247 | 750.738 | 638.71 | Odváděný vzduch | 0 | EHA 14 | 0.0611054 | 19 | Znehodnocený | EHA | 19.7114 | 1100 | 1100 × 450 | 450 | PO02.01.0634 | 0634
14057560 | 4.NP_SO-101 | 400 | 0.1813 | 0.707 | 560 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1234 | 1034 | 1034 | 4.NP_SO-101 | 0 | 834 | 515.562 | 466.667 | Přívod vzduchu | 0 | ODA 1 | 0.621601 | 4 | Čerstvý | ODA | 323.75 | 560 | 560 × 400 | 400 | PO02.01.0646 | 0646
14057696 | 4.NP_SO-101 | 710 | 0.384674 | 1.77755 | 710 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2449.82 | 2077.63 | 2095 | 4.NP_SO-101 | 3.20751 | 1722.81 | 776.147 | 710 | Přívod vzduchu | 0 | ODA 1 | 1.5387 | 1 | Čerstvý | ODA | 541.795 | 710 | 710 × 710 | 710 | PO02.01.0647 | 0647 | Identifikační data - Komentáře: VZT3
14058221 | 4.NP_SO-101 | 338.213 | 0.25 | 0.676426 | 500 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2271.11 | 2271.11 | 1932.9 | 4.NP_SO-101 |  | 1932.9 | 546.583 | 500 | Zpětný vzduch | 0 | ETA 19 | 0.676426 | 374 | Odváděný | ETA | 338.213 | 500 | 500 × 500 | 500 | PO02.01.0649 | 0649
14058252 | 4.NP_SO-101 | 517.053 | 0.0784 | 0.5791 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3709.81 | 3245.2 | 3610.81 | 4.NP_SO-101 | 100 | 3146.21 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.5791 | 319 | Odváděný | ETA | 517.053 | 280 | 280 × 280 | 280 | PO02.01.0650 | 0650
14058329 | 4.NP_SO-101 | 444.932 | 0.0784 | 0.498324 | 280 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2981.61 | 2536.67 | 2981.61 | 4.NP_SO-101 |  | 2536.67 | 306.086 | 280 | Zpětný vzduch | 0 | ETA 19 | 0.498324 | 319 | Odváděný | ETA | 444.932 | 280 | 280 × 280 | 280 | PO02.01.0651 | 0651
14073610 | -1.PP_SO-101 | 355 | 0.134734 | 0.599143 | 630 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2077.51 | 1900.01 | 1900.01 | -1.PP_SO-101 | 0 | 1722.51 | 511.758 | 454.112 | Přívod vzduchu | 0 | SUP 1 | 0.42131 | 233 | Přívodní | SUP | 213.863 | 630 | 630 × 355 | 355 | PO02.01.0699 | 0699
14073621 | -1.PP_SO-101 | 355 | 0.209823 | 0.683768 | 630 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2077.51 | 1900.01 | 1900.01 | -1.PP_SO-101 | 0 | 1722.51 | 511.758 | 454.112 | Přívod vzduchu | 0 | SUP 1 | 0.656115 | 233 | Přívodní | SUP | 333.053 | 630 | 630 × 355 | 355 | PO02.01.0700 | 0700
14080203 | 4.NP_SO-101 | 7832.39 | 0.025 | 5.09105 | 125 mm × 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | -4580.11 | -12412.5 | -4580.11 | 4.NP_SO-101 |  | -12412.5 | 171.666 | 153.846 | Zpětný vzduch | 0 | ETA 4 | 5.09105 | 376 | Odváděný | ETA | 7832.39 | 125 | 125 × 200 | 200 | PO02.01.0719 | 0719
14080323 | 4.NP_SO-101 | 125 | 0.00137952 | 0.0517244 | 125 mm × 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | -4269.21 | -4339.92 | -4344.8 | 4.NP_SO-101 | 100 | -4415.51 | 171.666 | 153.846 | Zpětný vzduch | 0 | ETA 4 | 0.00448345 | 376 | Odváděný | ETA | 6.89761 | 125 | 125 × 200 | 200 | PO02.01.0720 | 0720
14080396 | 4.NP_SO-101 | 2610.96 | 0.025 | 1.69712 | 200 mm × 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1493.65 | -1493.65 | -4104.61 | 4.NP_SO-101 |  | -4104.61 | 171.666 | 153.846 | Zpětný vzduch | 0 | ETA 4 | 1.69712 | 376 | Odváděný | ETA | 2610.96 | 200 | 200 × 125 | 125 | PO02.01.0721 | 0721

# IfcDuctSegment: Hranaté potrubí:POZINK/vývod (84)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: POZINK/vývod; Označení typu: 06; Popis: Potrubí hranaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Hranaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Reynoldsovo číslo: 0; Doplňkový průtok: 0 m3/s; Dynamický tlak: 0 Pa; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa; Tření: 0 kg/m2/s2
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Koeficient ztrát: 0; Uzamknutí velikosti: no
Jiné - Rodina: Hranaté potrubí; Id typu: 9070482; Rodina a typ: Hranaté potrubí: POZINK/vývod; Typ: POZINK/vývod
Name (Hranaté potrubí:POZINK/vývod:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému = Group | Plocha (m2) | Řez | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
13442124 | 4.NP_SO-101 | 9.75332 | 0.028125 | 0.00682733 | 125 mm × 225 mm | 4.NP_SO-101 | 2688.4 | 2678.65 | 2688.4 | 2678.65 | Přívodní | 181.388 | 160.714 | Přívod vzduchu | SUP 43 | 0.00682733 | 352 | SUP | 9.75332 | 125 | 125 × 225 | 225 | PO02.06.0068 | 0068 | no
13442127 | 4.NP_SO-101 | 11.5783 | 0.028125 | 0.00810482 | 125 mm × 225 mm | 4.NP_SO-101 | 2665.9 | 2654.32 | 2665.9 | 2654.32 | Přívodní | 181.388 | 160.714 | Přívod vzduchu | SUP 43 | 0.00810482 | 350 | SUP | 11.5783 | 125 | 125 × 225 | 225 | PO02.06.0069 | 0069 | no
13505560 | 2.NP_SO-101 | 315 | 0.102013 | 0.402476 | 315 mm × 315 mm | 2.NP_SO-101 | 2657.5 | 2500 | 2500 | 2342.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.408052 | 3 | EHA | 323.851 | 315 | 315 × 315 | 315 | PO02.06.0140 | 0140 | yes | 0
13505671 | 2.NP_SO-101 | 315 | 0.00567897 | 0.209808 | 315 mm × 315 mm | 2.NP_SO-101 | 3257.5 | 3100 | 3100 | 2942.5 | Čerstvý | 344.347 | 315 | Přívod vzduchu | ODA 11 | 0.0227159 | 3 | ODA | 18.0285 | 315 | 315 × 315 | 315 | PO02.06.0142 | 0142 | yes | 0
13505689 | 2.NP_SO-101 | 315 | 0.213795 | 0.588727 | 400 mm × 315 mm | 2.NP_SO-101 | 3257.5 | 3100 | 3100 | 2942.5 | Čerstvý | 387.345 | 352.448 | Přívod vzduchu | ODA 11 | 0.764317 | 6 | ODA | 534.487 | 400 | 400 × 315 | 315 | PO02.06.0144 | 0144 | yes | 0
13506285 | 2.NP_SO-101 | 315 | 0.728319 | 1.65509 | 315 mm × 315 mm | 2.NP_SO-101 | 2907.5 | 2750 | 2750 | 2592.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 2.91328 | 5 | EHA | 2312.12 | 315 | 315 × 315 | 315 | PO02.06.0146 | 0146 | yes | 0 | Identifikační data - Komentáře: VEDENO POD STROPEM
13506825 | 2.NP_SO-101 | 315 | 0.440586 | 1.07962 | 315 mm × 315 mm | 2.NP_SO-101 | 2657.5 | 2500 | 2500 | 2342.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 1.76234 | 3 | EHA | 1398.68 | 315 | 315 × 315 | 315 | PO02.06.0147 | 0147 | yes | 0
13506888 | 2.NP_SO-101 | 315 | 0.00952352 | 0.217497 | 315 mm × 315 mm | 2.NP_SO-101 | 2747.06 | 2635.69 | 2614.31 | 2502.94 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.0380941 | 3 | EHA | 30.2334 | 315 | 315 × 315 | 315 | PO02.06.0148 | 0148 | yes | 100
13507138 | 3.NP_SO-101 | 2881.77 | 0.08875 | 3.48695 | 250 mm × 355 mm | 3.NP_SO-101 | 1944.27 | 1944.27 | -937.5 | -937.5 | Znehodnocený | 324.422 | 293.388 | Odváděný vzduch | EHA 8 | 3.48695 | 7 | EHA | 2881.77 | 250 | 250 × 355 | 355 | PO02.06.0151 | 0151 | yes | Identifikační data - Komentáře: VZT2
13520757 | 4.NP_SO-101 | 396.259 | 0.2 | 0.713267 | 500 mm × 400 mm | 4.NP_SO-101 | 2448.87 | 2448.87 | 2052.61 | 2052.61 | Odváděný | 488.12 | 444.444 | Zpětný vzduch | ETA 19 | 0.713267 | 400 | ETA | 396.259 | 500 | 500 × 400 | 400 | PO02.06.0172 | 0172 | yes
13533515 | 4.NP_SO-101 | 46.6224 | 0.028125 | 0.0326357 | 125 mm × 225 mm | 4.NP_SO-101 | 2665.99 | 2665.99 | 2619.37 | 2619.37 | Přívodní | 181.388 | 160.714 | Přívod vzduchu | SUP 43 | 0.0326357 | 310 | SUP | 46.6224 | 125 | 125 × 225 | 225 | PO02.06.0185 | 0185 | yes
13547198 | 2.NP_SO-101 | 7352.5 | 0.0504 | 6.98487 | 315 mm × 160 mm | 2.NP_SO-101 | 2887.5 | 2887.5 | -4465 | -4465 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 6.98487 | 246 | ETA | 7352.5 | 315 | 315 × 160 | 160 | PO02.06.0215 | 0215 | yes | Identifikační data - Komentáře: VZT7/8
13595310 | -1.PP_SO-101 | 160 | 0.105177 | 0.207646 | 315 mm × 160 mm | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.317201 | 246 | ETA | 333.895 | 315 | 315 × 160 | 160 | PO02.06.0221 | 0221 | yes | 0 | Identifikační data - Komentáře: VZT7/8
13613016 | -1.PP_SO-101 | 133.094 | 0.19845 | 0.251548 | 315 mm × 630 mm | -1.PP_SO-101 | 2895.59 | 2762.5 | 2895.59 | 2762.5 | Odváděný | 479.863 | 420 | Zpětný vzduch | ETA 30 | 0.251548 | 244 | ETA | 133.094 | 315 | 315 × 630 | 630 | PO02.06.0223 | 0223 | yes
13613662 | -1.PP_SO-101 | 315 | 0.54274 | 0.93964 | 630 mm × 315 mm | -1.PP_SO-101 | 2607.5 | 2450 | 2450 | 2292.5 | Odváděný | 479.863 | 420 | Zpětný vzduch | ETA 30 | 1.62822 | 244 | ETA | 861.492 | 630 | 630 × 315 | 315 | PO02.06.0225 | 0225 | yes | 0
13613742 | -1.PP_SO-101 | 315 | 0.18958 | 0.58648 | 630 mm × 315 mm | -1.PP_SO-101 | 2607.5 | 2450 | 2450 | 2292.5 | Odváděný | 479.863 | 420 | Zpětný vzduch | ETA 30 | 0.568739 | 244 | ETA | 300.92 | 630 | 630 × 315 | 315 | PO02.06.0226 | 0226 | yes | 0
13615030 | -1.PP_SO-101 | 560 | 0.164253 | 0.936811 | 315 mm × 560 mm | -1.PP_SO-101 | 1580 | 1300 | 1300 | 1020 | Čerstvý | 454.468 | 403.2 | Přívod vzduchu | ODA 3 | 0.912518 | 5 | ODA | 521.439 | 315 | 315 × 560 | 560 | PO02.06.0228 | 0228 | yes | 0
13620385 | -1.PP_SO-101 | 560 | 0.0725114 | 0.610618 | 315 mm × 560 mm | -1.PP_SO-101 | 1580 | 1300 | 1300 | 1020 | Čerstvý | 454.468 | 403.2 | Přívod vzduchu | ODA 3 | 0.402841 | 5 | ODA | 230.195 | 315 | 315 × 560 | 560 | PO02.06.0232 | 0232 | yes | 0
13716488 | 2.NP_SO-101 | 125 | 0.109693 | 0.187117 | 200 mm × 125 mm | 2.NP_SO-101 | 3412.5 | 3350 | 3350 | 3287.5 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 0.356503 | 363 | ETA | 548.466 | 200 | 200 × 125 | 125 | PO02.06.0279 | 0279 | yes | 0 | Identifikační data - Komentáře: VZT9/10/11
13716867 | 3.NP_SO-101 | 125 | 0.0408131 | 0.101016 | 200 mm × 125 mm | 3.NP_SO-101 | 3507.5 | 3445 | 3445 | 3382.5 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 0.132643 | 397 | ETA | 204.066 | 200 | 200 × 125 | 125 | PO02.06.0282 | 0282 | yes | 0 | Identifikační data - Komentáře: VZT9/10/11/12
13717200 | 4.NP_SO-101 | 341.149 | 0.025 | 0.221747 | 125 mm × 200 mm | 4.NP_SO-101 | -642.5 | -983.649 | -642.5 | -983.649 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 0.221747 | 376 | ETA | 341.149 | 125 | 125 × 200 | 200 | PO02.06.0285 | 0285 | yes | Identifikační data - Komentáře: VZT9/10/11/12
13737589 | -1.PP_SO-101 | 315 | 0.0213449 | 0.418245 | 630 mm × 315 mm | -1.PP_SO-101 | 2607.5 | 2450 | 2450 | 2292.5 | Odváděný | 479.863 | 420 | Zpětný vzduch | ETA 30 | 0.0640348 | 247 | ETA | 33.8808 | 630 | 630 × 315 | 315 | PO02.06.0291 | 0291 | yes | 0
13737640 | -1.PP_SO-101 | 355 | 0.785271 | 1.33229 | 630 mm × 355 mm | -1.PP_SO-101 | 2627.5 | 2450 | 2450 | 2272.5 | Odváděný | 511.758 | 454.112 | Zpětný vzduch | ETA 30 | 2.45553 | 447 | ETA | 1246.46 | 630 | 630 × 355 | 355 | PO02.06.0292 | 0292 | yes | 0
13737798 | -1.PP_SO-101 | 315 | 0.0213449 | 0.418245 | 630 mm × 315 mm | -1.PP_SO-101 | 2607.5 | 2450 | 2450 | 2292.5 | Odváděný | 479.863 | 420 | Zpětný vzduch | ETA 30 | 0.0640348 | 244 | ETA | 33.8808 | 630 | 630 × 315 | 315 | PO02.06.0293 | 0293 | yes | 0
13737948 | -1.PP_SO-101 | 346.591 | 0.224 | 0.665455 | 560 mm × 400 mm | -1.PP_SO-101 | 1907.59 | 1907.59 | 1560.99 | 1560.99 | Přívodní | 515.562 | 466.667 | Přívod vzduchu | SUP 27 | 0.665455 | 360 | SUP | 346.591 | 560 | 560 × 400 | 400 | PO02.06.0294 | 0294 | yes
13738627 | -1.PP_SO-101 | 250 | 0.020625 | 0.16625 | 250 mm × 250 mm | -1.PP_SO-101 | 2387.59 | 2262.59 | 2262.59 | 2137.59 | Přívodní | 273.291 | 250 | Přívod vzduchu | SUP 27 | 0.0825 | 246 | SUP | 82.5 | 250 | 250 × 250 | 250 | PO02.06.0296 | 0296 | yes | 0
13740211 | -1.PP_SO-101 | 400 | 0.124443 | 0.598217 | 250 mm × 400 mm | -1.PP_SO-101 | 2462.59 | 2262.59 | 2262.59 | 2062.59 | Přívodní | 343.333 | 307.692 | Přívod vzduchu | SUP 27 | 0.647103 | 252 | SUP | 497.772 | 250 | 250 × 400 | 400 | PO02.06.0302 | 0302 | yes | 0
13759720 | -1.PP_SO-101 | 560 | 0.17899 | 0.989209 | 315 mm × 560 mm | -1.PP_SO-101 | 1580 | 1300 | 1300 | 1020 | Čerstvý | 454.468 | 403.2 | Přívod vzduchu | ODA 3 | 0.99439 | 5 | ODA | 568.223 | 315 | 315 × 560 | 560 | PO02.06.0304 | 0304 | yes | 0
13764550 | 2.NP_SO-101 | 315 | 0.0102831 | 0.14129 | 160 mm × 315 mm | 2.NP_SO-101 | 3357.5 | 3200 | 3200 | 3042.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0610557 | 246 | ETA | 64.2691 | 160 | 160 × 315 | 315 | PO02.06.0325 | 0325 | yes | 0 | Identifikační data - Komentáře: VZT7/8
13764562 | 3.NP_SO-101 | 2914.35 | 0.0504 | 2.76863 | 160 mm × 315 mm | 3.NP_SO-101 | 3167.5 | 253.151 | 3167.5 | 253.151 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 2.76863 | 246 | ETA | 2914.35 | 160 | 160 × 315 | 315 | PO02.06.0326 | 0326 | yes
13764742 | 3.NP_SO-101 | 315 | 0.00557565 | 0.122754 | 160 mm × 315 mm | 3.NP_SO-101 | 3637.5 | 3480 | 3480 | 3322.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0331054 | 246 | ETA | 34.8478 | 160 | 160 × 315 | 315 | PO02.06.0327 | 0327 | yes | 0 | Identifikační data - Komentáře: VZT7/8
13764751 | 4.NP_SO-101 | 1695 | 0.0504 | 1.61025 | 160 mm × 315 mm | 4.NP_SO-101 | 1487.5 | 1487.5 | -207.5 | -207.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 1.61025 | 246 | ETA | 1695 | 160 | 160 × 315 | 315 | PO02.06.0328 | 0328 | yes | Identifikační data - Komentáře: VEDENO NAD STŘECHU
13764760 | 4.NP_SO-101 | 315 | 0.126 | 0.596925 | 160 mm × 315 mm | 4.NP_SO-101 | 1957.5 | 1800 | 1800 | 1642.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.748125 | 246 | ETA | 787.5 | 160 | 160 × 315 | 315 | PO02.06.0329 | 0329 | yes | 0 | Identifikační data - Komentáře: VZT7/8
13790913 | 4.NP_SO-101 | 160 | 0.0352 | 0.1216 | 160 mm × 160 mm | 4.NP_SO-101 | 3655 | 3575 | 3575 | 3495 | Odváděný | 174.906 | 160 | Zpětný vzduch | ETA 29 | 0.1408 | 1 | ETA | 220 | 160 | 160 × 160 | 160 | PO02.06.0338 | 0338 | yes | 0 | Identifikační data - Komentáře: VZT13
13826461 | 2.NP_SO-101 | 300 | 0.00552043 | 0.36552 | 600 mm × 300 mm | 2.NP_SO-101 | 3250 | 3100 | 3100 | 2950 | Čerstvý | 457.012 | 400 | Přívod vzduchu | ODA 11 | 0.0165613 | 7 | ODA | 9.20072 | 600 | 600 × 300 | 300 | PO02.06.0340 | 0340 | yes | 0
13826501 | 2.NP_SO-101 | 300 | 0.0101848 | 0.370185 | 600 mm × 300 mm | 2.NP_SO-101 | 3250 | 3100 | 3100 | 2950 | Čerstvý | 457.012 | 400 | Přívod vzduchu | ODA 11 | 0.0305545 | 4 | ODA | 16.9747 | 600 | 600 × 300 | 300 | PO02.06.0341 | 0341 | yes | 0
13826534 | 2.NP_SO-101 | 315 | 0.0082608 | 0.214972 | 315 mm × 315 mm | 2.NP_SO-101 | 3257.5 | 3100 | 3100 | 2942.5 | Čerstvý | 344.347 | 315 | Přívod vzduchu | ODA 11 | 0.0330432 | 3 | ODA | 26.2248 | 315 | 315 × 315 | 315 | PO02.06.0342 | 0342 | yes | 0
13826754 | 2.NP_SO-101 | 315 | 0.0713786 | 0.341207 | 315 mm × 315 mm | 2.NP_SO-101 | 3257.5 | 3100 | 3100 | 2942.5 | Čerstvý | 344.347 | 315 | Přívod vzduchu | ODA 11 | 0.285514 | 3 | ODA | 226.599 | 315 | 315 × 315 | 315 | PO02.06.0343 | 0343 | yes | 0
13827216 | 2.NP_SO-101 | 315 | 0.0479443 | 0.294339 | 315 mm × 315 mm | 2.NP_SO-101 | 2657.5 | 2500 | 2500 | 2342.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.191777 | 3 | EHA | 152.204 | 315 | 315 × 315 | 315 | PO02.06.0344 | 0344 | yes | 0
13827357 | 2.NP_SO-101 | 315 | 0.0747191 | 0.347888 | 315 mm × 315 mm | 2.NP_SO-101 | 2907.5 | 2750 | 2750 | 2592.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.298876 | 3 | EHA | 237.204 | 315 | 315 × 315 | 315 | PO02.06.0345 | 0345 | yes | 0 | Identifikační data - Komentáře: VEDENO POD STROPEM
13827499 | 2.NP_SO-101 | 300 | 0.0112892 | 0.371289 | 600 mm × 300 mm | 2.NP_SO-101 | 2900 | 2750 | 2750 | 2600 | Znehodnocený | 457.012 | 400 | Odváděný vzduch | EHA 8 | 0.0338677 | 4 | EHA | 18.8154 | 600 | 600 × 300 | 300 | PO02.06.0346 | 0346 | yes | 0
13827581 | 2.NP_SO-101 | 300 | 0.0110925 | 0.371093 | 600 mm × 300 mm | 2.NP_SO-101 | 2900 | 2750 | 2750 | 2600 | Znehodnocený | 457.012 | 400 | Odváděný vzduch | EHA 8 | 0.0332775 | 4 | EHA | 18.4875 | 600 | 600 × 300 | 300 | PO02.06.0347 | 0347 | yes | 0
13827750 | 2.NP_SO-101 | 315 | 0.0869718 | 0.372394 | 315 mm × 315 mm | 2.NP_SO-101 | 2907.5 | 2750 | 2750 | 2592.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.347887 | 5 | EHA | 276.101 | 315 | 315 × 315 | 315 | PO02.06.0348 | 0348 | yes | 0
13919906 | 1.NP_SO-101 | 200 | 0.0297244 | 0.163745 | 315 mm × 200 mm | 1.NP_SO-101 | 19349.6 | 19249.6 | 19249.6 | 19149.6 | Odváděný | 272.634 | 244.66 | Zpětný vzduch | ETA 5 | 0.0971939 | 241 | ETA | 94.363 | 315 | 315 × 200 | 200 | PO02.06.0436 | 0436 | yes | 0 | Identifikační data - Komentáře: VZT15c
13933895 | 1.NP_SO-101 | 125 | 0.0144426 | 0.0680533 | 200 mm × 125 mm | 1.NP_SO-101 | 3412.5 | 3350 | 3350 | 3287.5 | Odváděný | 171.666 | 153.846 | Zpětný vzduch | ETA 4 | 0.0469385 | 357 | ETA | 72.213 | 200 | 200 × 125 | 125 | PO02.06.0489 | 0489 | yes | 0 | Identifikační data - Komentáře: VZT9/10
13967105 | 4.NP_SO-101 | 180 | 0.0237554 | 0.112311 | 180 mm × 180 mm | 4.NP_SO-101 | 7065 | 6975 | 6975 | 6885 | Odváděný | 196.77 | 180 | Zpětný vzduch | ETA 4 | 0.0950218 | 322 | ETA | 131.975 | 180 | 180 × 180 | 180 | PO02.06.0538 | 0538 | yes | 0
13967178 | 4.NP_SO-101 | 315 | 0.0590625 | 0.316575 | 315 mm × 315 mm | 4.NP_SO-101 | 7432.5 | 7275 | 7275 | 7117.5 | Znehodnocený | 344.347 | 315 | Odváděný vzduch | EHA 8 | 0.23625 | 9 | EHA | 187.5 | 315 | 315 × 315 | 315 | PO02.06.0539 | 0539 | yes | 0
13967224 | 4.NP_SO-101 | 250 | 0.018368 | 0.161736 | 250 mm × 250 mm | 4.NP_SO-101 | 7100 | 6975 | 6975 | 6850 | Odváděný | 273.291 | 250 | Zpětný vzduch | ETA 30 | 0.0734722 | 1 | ETA | 73.4722 | 250 | 250 × 250 | 250 | PO02.06.0540 | 0540 | yes | 0
13967283 | 4.NP_SO-101 | 160 | 0.0128 | 0.0768 | 160 mm × 160 mm | 4.NP_SO-101 | 7355 | 7275 | 7275 | 7195 | Odváděný | 174.906 | 160 | Zpětný vzduch | ETA 1 | 0.0512 | 1 | ETA | 80 | 160 | 160 × 160 | 160 | PO02.06.0541 | 0541 | yes | 0
13968504 | 2.NP_SO-101 | 600 | 0.00420752 | 0.37683 | 300 mm × 600 mm | 2.NP_SO-101 | 3557.5 | 3257.5 | 3257.5 | 2957.5 | Přívodní | 457.012 | 400 | Přívod vzduchu | SUP 20 | 0.0252451 | 44 | SUP | 14.0251 | 300 | 300 × 600 | 600 | PO02.06.0543 | 0543 | yes | 0
13968655 | 2.NP_SO-101 | 600 | 0.00907581 | 0.396303 | 300 mm × 600 mm | 2.NP_SO-101 | 3557.5 | 3257.5 | 3257.5 | 2957.5 | Přívodní | 457.012 | 400 | Přívod vzduchu | SUP 20 | 0.0544548 | 44 | SUP | 30.2527 | 300 | 300 × 600 | 600 | PO02.06.0544 | 0544 | yes | 0
14004335 | -1.PP_SO-101 | 150 | 0.0533165 | 0.141125 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Odváděný | 221.364 | 195.349 | Zpětný vzduch | ETA 30 | 0.163758 | 414 | ETA | 190.416 | 280 | 280 × 150 | 150 | PO02.06.0570 | 0570 | yes | 0
14004390 | -1.PP_SO-101 | 150 | 0.99751 | 1.15276 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Odváděný | 221.364 | 195.349 | Zpětný vzduch | ETA 30 | 3.06378 | 414 | ETA | 3562.54 | 280 | 280 × 150 | 150 | PO02.06.0571 | 0571 | yes | 0
14004397 | -1.PP_SO-101 | 150 | 0.278226 | 0.382099 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Odváděný | 221.364 | 195.349 | Zpětný vzduch | ETA 30 | 0.85455 | 414 | ETA | 993.663 | 280 | 280 × 150 | 150 | PO02.06.0572 | 0572 | yes | 0
14004434 | -1.PP_SO-101 | 150 | 0.0320501 | 0.118339 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Přívodní | 221.364 | 195.349 | Přívod vzduchu | SUP 27 | 0.0984396 | 358 | SUP | 114.465 | 280 | 280 × 150 | 150 | PO02.06.0573 | 0573 | yes | 0
14004486 | -1.PP_SO-101 | 150 | 1.0133 | 1.16968 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Přívodní | 221.364 | 195.349 | Přívod vzduchu | SUP 27 | 3.11229 | 358 | SUP | 3618.94 | 280 | 280 × 150 | 150 | PO02.06.0574 | 0574 | yes | 0
14004494 | -1.PP_SO-101 | 150 | 0.371 | 0.4815 | 280 mm × 150 mm | -1.PP_SO-101 | 2675 | 2600 | 2600 | 2525 | Přívodní | 221.364 | 195.349 | Přívod vzduchu | SUP 27 | 1.1395 | 358 | SUP | 1325 | 280 | 280 × 150 | 150 | PO02.06.0575 | 0575 | yes | 0
14032738 | 4.NP_SO-101 | 450 | 0.555815 | 1.44476 | 1100 mm × 450 mm | 4.NP_SO-101 | 1259 | 1034 | 1034 | 809 | Odváděný | 750.738 | 638.71 | Zpětný vzduch | ETA 14 | 1.56639 | 1 | ETA | 505.287 | 1100 | 1100 × 450 | 450 | PO02.06.0591 | 0591 | yes | 0
14035523 | -1.PP_SO-101 | 560 | 0.0496125 | 0.5292 | 315 mm × 560 mm | -1.PP_SO-101 | 1580 | 1300 | 1300 | 1020 | Čerstvý | 454.468 | 403.2 | Přívod vzduchu | ODA 3 | 0.275625 | 5 | ODA | 157.5 | 315 | 315 × 560 | 560 | PO02.06.0597 | 0597 | yes | 0
14048563 | 1.NP_SO-101 | 3926.52 | 0.0639 | 4.20137 | 355 mm × 180 mm | 1.NP_SO-101 | 16528.4 | 12601.9 | 16528.4 | 12601.9 | Odváděný | 272.454 | 238.879 | Zpětný vzduch | ETA 5 | 4.20137 | 250 | ETA | 3926.52 | 355 | 355 × 180 | 180 | PO02.06.0625 | 0625 | yes | Identifikační data - Komentáře: VZT15c
14049126 | 1.NP_SO-101 | 4167.65 | 0.0639 | 4.45938 | 180 mm × 355 mm | 1.NP_SO-101 | 7406.04 | 3238.39 | 7406.04 | 3238.39 | Odváděný | 272.454 | 238.879 | Zpětný vzduch | ETA 5 | 4.45938 | 250 | ETA | 4167.65 | 180 | 180 × 355 | 355 | PO02.06.0626 | 0626 | yes | Identifikační data - Komentáře: VZT15c
14050721 | 3.NP_SO-101 | 315 | 0.0117661 | 0.147129 | 315 mm × 160 mm | 3.NP_SO-101 | 100.52 | -3.16614 | 60.5199 | -43.1661 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0698614 | 246 | ETA | 73.5383 | 315 | 315 × 160 | 160 | PO02.06.0627 | 0627 | yes | 173.205
14050734 | 3.NP_SO-101 | 291.702 | 0.0504 | 0.277117 | 315 mm × 160 mm | 3.NP_SO-101 | -195.798 | -195.798 | -487.5 | -487.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.277117 | 246 | ETA | 291.702 | 315 | 315 × 160 | 160 | PO02.06.0628 | 0628 | yes
14051708 | 2.NP_SO-101 | 315 | 0.0117661 | 0.147129 | 160 mm × 315 mm | 2.NP_SO-101 | 3357.5 | 3200 | 3200 | 3042.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0698614 | 246 | ETA | 73.5383 | 160 | 160 × 315 | 315 | PO02.06.0629 | 0629 | yes | 0
14051719 | 2.NP_SO-101 | 315 | 0.00682818 | 0.127686 | 160 mm × 315 mm | 2.NP_SO-101 | 3357.5 | 3200 | 3200 | 3042.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0405423 | 246 | ETA | 42.6761 | 160 | 160 × 315 | 315 | PO02.06.0630 | 0630 | yes | 0
14054126 | 3.NP_SO-101 | 315 | 0.000644887 | 0.103339 | 160 mm × 315 mm | 3.NP_SO-101 | 3637.5 | 3480 | 3480 | 3322.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.00382902 | 246 | ETA | 4.03054 | 160 | 160 × 315 | 315 | PO02.06.0635 | 0635 | yes | 0
14054187 | 3.NP_SO-101 | 315 | 0.00275526 | 0.111649 | 160 mm × 315 mm | 3.NP_SO-101 | 3637.5 | 3480 | 3480 | 3322.5 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.0163593 | 246 | ETA | 17.2204 | 160 | 160 × 315 | 315 | PO02.06.0636 | 0636 | yes | 0
14055076 | 3.NP_SO-101 | 422.018 | 0.08875 | 0.510642 | 250 mm × 355 mm | 3.NP_SO-101 | 2577.8 | 2531.86 | 2124.22 | 2078.28 | Znehodnocený | 324.422 | 293.388 | Odváděný vzduch | EHA 8 | 0.510642 | 7 | EHA | 422.018 | 250 | 250 × 355 | 355 | PO02.06.0638 | 0638 | yes | 373.205
14055092 | 3.NP_SO-101 | 439.729 | 0.08875 | 0.532072 | 250 mm × 355 mm | 3.NP_SO-101 | 3151.54 | 2711.81 | 3151.54 | 2711.81 | Znehodnocený | 324.422 | 293.388 | Odváděný vzduch | EHA 8 | 0.532072 | 7 | EHA | 439.729 | 250 | 250 × 355 | 355 | PO02.06.0639 | 0639 | yes
14055550 | -1.PP_SO-101 | 160 | 0.141963 | 0.245016 | 315 mm × 160 mm | -1.PP_SO-101 | 2530 | 2450 | 2450 | 2370 | Odváděný | 241.985 | 212.211 | Zpětný vzduch | ETA 35 | 0.428141 | 248 | ETA | 450.675 | 315 | 315 × 160 | 160 | PO02.06.0644 | 0644 | yes | 0 | Identifikační data - Komentáře: VZT7/8
14058078 | 4.NP_SO-101 | 500 | 0.0333221 | 0.483305 | 500 mm × 400 mm | 4.NP_SO-101 | 2955.22 | 2754.89 | 2813.8 | 2613.47 | Odváděný | 488.12 | 444.444 | Zpětný vzduch | ETA 19 | 0.149949 | 400 | ETA | 83.3053 | 500 | 500 × 400 | 400 | PO02.06.0648 | 0648 |  | 100
14059104 | 4.NP_SO-101 | 400 | 0.034994 | 0.827995 | 1000 mm × 400 mm | 4.NP_SO-101 | 1776.9 | 1576.9 | 1576.9 | 1376.9 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 19 | 0.0979831 | 335 | ETA | 34.994 | 1000 | 1000 × 400 | 400 | PO02.06.0652 | 0652 |  | 0
14060054 | 4.NP_SO-101 | 1000 | 0.0813742 | 1.20687 | 1000 mm × 400 mm | 4.NP_SO-101 | 1919.51 | 1746.31 | 1644.59 | 1471.38 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 19 | 0.56962 | 335 | ETA | 203.436 | 1000 | 1000 × 400 | 400 | PO02.06.0653 | 0653 |  | 57.735
