Properties of the parts of a building model (IFC4), part 8 of 21

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:200x180, Regulátor průtoku vzduchu hranatý.LH:200x180:13939121
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2340 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.018575 m3; Plocha: 0.3782 m2; Velikost: 200 × 180-200 × 180
Identifikační data - Kód prvku: RG04.33.0142; Označení: 0142
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 13935603; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 200x180; Typ: 200x180

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:200x180, Regulátor průtoku vzduchu hranatý.LH:200x180:13935973
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 200 mm; Jmenovitá velikost vstupu - výška: 180 mm; Jmenovitá velikost výstupu - šířka: 200 mm; Jmenovitá velikost výstupu - výška: 180 mm; Šířka: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 180 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 200x180; Označení typu: 33; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.6916 m2; NetVolume: 0.018575 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm × 180 mm-200 mm × 180 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm × 180 mm-200 mm × 180 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.00833333 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2340 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.018575 m3; Plocha: 0.3782 m2; Velikost: 200 × 180-200 × 180
Identifikační data - Kód prvku: RG04.33.0138; Označení: 0138
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 13935603; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 200x180; Typ: 200x180

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:280x280, Regulátor průtoku vzduchu hranatý.LH:280x280:13937598
In: 4.NP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 280 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 280 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 280 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 280x280; Označení typu: 25; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: SUP 43
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.1656 m2; NetVolume: 0.040289 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 280 mm × 280 mm-280 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 280 mm × 280 mm-280 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2790 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 43; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.040289 m3; Plocha: 0.6216 m2; Velikost: 280 × 280-280 × 280
Identifikační data - Kód prvku: RG04.25.0141; Označení: 0141
Jiné - Páteřní trasa: yes; Id typu: 13916676; Rodina: Regulátor průtoku vzduchu hranatý.LH; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 280x280; Typ: 280x280

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:280x280 (2)
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 280 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 280 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 280 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 280x280; Označení typu: 25; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.1656 m2; NetVolume: 0.040289 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 280 mm × 280 mm-280 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 280 mm × 280 mm-280 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.040289 m3; Plocha: 0.6216 m2; Velikost: 280 × 280-280 × 280
Jiné - Páteřní trasa: yes; Id typu: 13916676; Rodina: Regulátor průtoku vzduchu hranatý.LH; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 280x280; Typ: 280x280
Name (Regulátor průtoku vzduchu hranatý.LH:280x280:...) | Průtok vzduchu (m3/s) | Výška od podlaží (mm) | Kód prvku | Označení
13916742 | 0.0583333 | 3720 | RG04.25.0121 | 0121
13936265 | 0.0333333 | 2900 | RG04.25.0139 | 0139

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:500x400, Regulátor průtoku vzduchu hranatý.LH:500x400:13917462
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 500 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 500x400; Označení typu: 27; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.31 m2; NetVolume: 0.102475 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 400 mm-500 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 400 mm-500 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 1576.9 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.102475 m3; Plocha: 1.2114 m2; Velikost: 500 × 400-500 × 400
Identifikační data - Kód prvku: RG04.27.0123; Označení: 0123
Jiné - Páteřní trasa: yes; Typ: 500x400; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 13916143; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 500x400

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:125x500 (2)
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 125 mm; Jmenovitá velikost výstupu: 125 mm; Průměr: 125 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 125x500; Označení typu: 21; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.22089 m2; NetVolume: 0.00613563 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 125 mm-125 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 125 mm-125 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.00613563 m3; Plocha: 0.136845 m2; Velikost: 125-125
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13622358; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 125x500; Typ: 125x500
Name (Regulátor průtoku vzduchu kruhový.LH:125x500:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13844019 | 5441.91 | Přívodní | Přívod vzduchu | SUP 43 | SUP | RG04.21.0108 | 0108
13844037 | 6321.91 | Odváděný | Zpětný vzduch | ETA 10 | ETA | RG04.21.0109 | 0109

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:160x500, Regulátor průtoku vzduchu kruhový.LH:160x500:13840855
In: -1.PP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Průměr: 160 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 160x500; Označení typu: 19; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat); Group: SUP 27
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.291534 m2; NetVolume: 0.0100526 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.0472222 m3/s; Tlaková ztráta: 0.796053 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 27; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0100526 m3; Plocha: 0.174967 m2; Velikost: 160-160
Identifikační data - Kód prvku: RG04.19.0099; Označení: 0099
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866723; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 160x500; Typ: 160x500

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:160x500, Regulátor průtoku vzduchu kruhový.LH:160x500:13840963
In: -1.PP_SO-101
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Průměr: 160 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 160x500; Označení typu: 19; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 30
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.291534 m2; NetVolume: 0.0100526 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.116667 m3/s; Tlaková ztráta: 4.85896 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 30; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0100526 m3; Plocha: 0.174967 m2; Velikost: 160-160
Identifikační data - Kód prvku: RG04.19.0100; Označení: 0100
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866723; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 160x500; Typ: 160x500

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:225x500, Regulátor průtoku vzduchu kruhový.LH:225x500:13926734
In: -1.PP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 225 mm; Jmenovitá velikost výstupu: 225 mm; Průměr: 225 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 225x500; Označení typu: 30; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat); Group: SUP 27
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.43294 m2; NetVolume: 0.0198794 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm-225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 27; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0198794 m3; Plocha: 0.25087 m2; Velikost: 225-225
Identifikační data - Kód prvku: RG04.30.0132; Označení: 0132
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13840784; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 225x500; Typ: 225x500

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:225x500 (2)
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 225 mm; Jmenovitá velikost výstupu: 225 mm; Průměr: 225 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 225x500; Označení typu: 30; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.43294 m2; NetVolume: 0.0198794 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm-225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0198794 m3; Plocha: 0.25087 m2; Velikost: 225-225
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13840784; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 225x500; Typ: 225x500
Name (Regulátor průtoku vzduchu kruhový.LH:225x500:...) | In | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13925506 | 2.NP_SO-101 | 0.025 | 0.0570531 | 2.NP_SO-101 | 2900 | ETA 28 | RG04.30.0129 | 0129
13926545 | -1.PP_SO-101 | 0.05 | 0.228212 | -1.PP_SO-101 | 2400 | ETA 30 | RG04.30.0131 | 0131

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:250x500, Regulátor průtoku vzduchu kruhový.LH:250x500:13925193
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Průměr: 250 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 250x500; Označení typu: 29; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat); Group: SUP 20
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.490861 m2; NetVolume: 0.0245425 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Celková velikost: 280 mm-280 mm; Tloušťka izolace: 15 mm; Typ izolace: Protipožární
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: -0.0166667 m3/s; Tlaková ztráta: 0.0166367 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 3100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0245425 m3; Plocha: 0.28183 m2; Velikost: 250-250
Identifikační data - Kód prvku: RG04.29.0127; Označení: 0127
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866578; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 250x500; Typ: 250x500

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:Průměr × Délka (9)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 200 mm; Jmenovitá velikost výstupu: 200 mm; Průměr: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: Průměr × Délka; Označení typu: 02; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.376983 m2; NetVolume: 0.0157072 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm-200 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm-200 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF; Servopohon: no
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Objem: 0.0157072 m3; Plocha: 0.220891 m2; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Velikost: 200-200; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm
Jiné - Id typu: 13537818; Rodina: Regulátor průtoku vzduchu kruhový.LH; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: Průměr × Délka; Typ: Průměr × Délka
Name (Regulátor průtoku vzduchu kruhový.LH:Průměr × Délka:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13537849 | -1.PP_SO-101 | -1.PP_SO-101 | 4273.37 | Přívodní | Přívod vzduchu | SUP 27 | SUP | RG04.02.0022 | 0022 | yes
13539663 | 1.NP_SO-101 | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | RG04.02.0025 | 0025 | yes
13539786 | 1.NP_SO-101 | 1.NP_SO-101 | 3250 | Přívodní | Přívod vzduchu | SUP 27 | SUP | RG04.02.0026 | 0026 | yes
13829830 | 2.NP_SO-101 | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | RG04.02.0079 | 0079 | yes
13829884 | 2.NP_SO-101 | 2.NP_SO-101 | 3275 | Odváděný | Zpětný vzduch | ETA 3 | ETA | RG04.02.0080 | 0080 | yes
13830484 | 2.NP_SO-101 | 2.NP_SO-101 | 3400 | Přívodní | Přívod vzduchu | SUP 20 | SUP | RG04.02.0084 | 0084 | yes
13834141 | 1.NP_SO-101 | 1.NP_SO-101 | 2880 | Přívodní | Přívod vzduchu | SUP 27 | SUP | RG04.02.0093 | 0093 | yes
13843130 | 1.NP_SO-101 | 1.NP_SO-101 | 3250 | Odváděný | Zpětný vzduch | ETA 30 | ETA | RG04.02.0105 | 0105 | yes
14075748 | 1.NP_SO-101 | 1.NP_SO-101 | 3150 | Odváděný | Zpětný vzduch | ETA 30 | ETA | RG04.02.0161 | 0161

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:Průměr × Délka (3)
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 200 mm; Jmenovitá velikost výstupu: 200 mm; Průměr: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: Průměr × Délka; Označení typu: 02; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.376983 m2; NetVolume: 0.0157072 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm-200 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm-200 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0157072 m3; Plocha: 0.220891 m2; Velikost: 200-200
Jiné - Id typu: 13537818; Rodina: Regulátor průtoku vzduchu kruhový.LH; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: Průměr × Délka; Typ: Průměr × Délka
Name (Regulátor průtoku vzduchu kruhový.LH:Průměr × Délka:...) | In | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení | Páteřní trasa
13537888 | -1.PP_SO-101 | 0.05 | 0.365552 | -1.PP_SO-101 | 4273.37 | ETA 30 | RG04.02.0023 | 0023 | yes
13830365 | 2.NP_SO-101 | 0.05 | 0.365552 | 2.NP_SO-101 | 3140 | ETA 28 | RG04.02.0083 | 0083
13970488 | 1.NP_SO-101 | 0.0166667 | 0.0406169 | 1.NP_SO-101 | 3250 | ETA 30 | RG04.02.0155 | 0155 | yes

# IfcBuildingElementProxy: Servopohon:Servopohon, Servopohon:Servopohon:13506026
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace – zatížení - PŘÍKON: 0 W; TYP ZAŘÍZENÍ: Další
Type - Vazby - Výchozí výška: 1219.2 mm
Type - Elektrotechnika - NAPĚTÍ: 24 V; POČET FÁZÍ: 1
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.14.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: LV02; Komentáře k typům: Servopohon; Model: Model; Nadpis OmniClass: Break-Glass Detection; Název typu: Servopohon; Označení typu: 01; Popis: Servopohon; Popis sestavy: Uzavírací; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Servopohon
Classification: LV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.015 m2; NetVolume: 0.000125 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 24 V/1-0 VA
Obecné - Umístění: Terasa A209
Text - CCI Funkční systém: J; CCI Komponenta: MAA; CCI Technický systém: HF; KOMENTÁŘE K TYPŮM: Komentáře k typům; MODEL: Model; POPIS: Protidešťová žaluzie; VÝROBCE: Výrobce
Vazby - Podlaží: 2.NP_SO-101; Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 2100 mm; Výška od podlaží: 2100 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Geometrie: yes; S_viditelnost: yes
Kóty - DÉLKA: 50 mm; Objem: 0.000125 m3; S_x posun doprava: 215 mm; S_x posun nahoru: 0 mm; S_y posun doprava: 170 mm; S_y posun nahoru: 25 mm; S_z posun doprava: 0 mm; S_z posun nahoru: 365 mm; ŠÍŘKA: 50 mm; VÝŠKA: 50 mm
Identifikační data - Kód prvku: LV02.01.0001; Označení: 0001
Jiné - Id typu: 13451485; Rodina: Servopohon; Rodina a typ: Servopohon: Servopohon; S_x posun doprava 2: 1215 mm; S_x posun nahoru 2: 1000 mm; S_y posun doprava 2: 1170 mm; S_y posun nahoru 2: 1025 mm; S_z posun doprava 2: 1000 mm; S_z posun nahoru 2: 1365 mm; Typ: Servopohon

# IfcBuildingElementProxy: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 315-3-2,5, Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 315-3-2,5:13964159
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - QmdConnectorList: 201;D;202;D
Type - Grafika - CAT0: yes
Type - Kóty - CAT: 0; CB: 560 mm; CB1: 280 mm; CH: 504 mm; CH1: 252 mm; D: 315 mm; DY: 22 mm; E: 15 mm; F: 400 mm; G: 40 mm; H2D: 504 mm; L: 276 mm; L1: 138 mm; L2D: 276 mm; W2D: 560 mm
Type - Identifikační data - Kód sestavy: CH01; magiPartTypeId: 206; magiProductCode: CWK 315-3-2,5; magiProductFamilyId: CWK *-3-2,5; magiProductId: CWK 315-3-2,5; Název typu: CWK 315-3-2,5; Označení typu: 35; Popis: Duct cooler for duct installation, circular; Popis sestavy: Vodní; URL: www.systemair.com/global; VersionID: 2.0/2021.6.24.1/SYSTEMAIR_CWK_Q13_001; Výrobce: Systemair
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased
Classification: CH01 Uniformat (Uniformat); Group: SUP 20
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.15181 m2; NetVolume: 0.0778982 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: EQC; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 2485 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - ang2D: 0 deg; Objem: 0.0778982 m3; Plocha: 0.577161 m2; Velikost: 315-315
Identifikační data - ID systému: Potrubní chladič - externí; Kód prvku: CH01.35.0153; Označení: 0153; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13962874; Rodina: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased; Rodina a typ: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased: CWK 315-3-2,5; Typ: CWK 315-3-2,5

# IfcBuildingElementProxy: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 400-3-2,5 (2)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - QmdConnectorList: 201;D;202;D
Type - Grafika - CAT0: yes
Type - Kóty - CAT: 0; CB: 710 mm; CB1: 355 mm; CH: 529 mm; CH1: 264.5 mm; D: 400 mm; DY: 22 mm; E: 15 mm; F: 425 mm; G: 65 mm; H2D: 529 mm; L: 330 mm; L1: 165 mm; L2D: 330 mm; W2D: 710 mm
Type - Identifikační data - Kód sestavy: CH01; magiPartTypeId: 206; magiProductCode: CWK 400-3-2,5; magiProductFamilyId: CWK *-3-2,5; magiProductId: CWK 400-3-2,5; Název typu: CWK 400-3-2,5; Označení typu: 36; Popis: Duct cooler for duct installation, circular; Popis sestavy: Vodní; URL: www.systemair.com/global; VersionID: 2.0/2021.6.24.1/SYSTEMAIR_CWK_Q13_001; Výrobce: Systemair
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased
Classification: CH01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56892 m2; NetVolume: 0.123945 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 400 mm-400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 400 mm-400 mm
Text - CCI Funkční systém: J; CCI Komponenta: EQC; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Grafika - Použít měřítko poznámky: yes
Kóty - ang2D: 0 deg; Objem: 0.123945 m3; Plocha: 0.785717 m2; Velikost: 400-400
Identifikační data - ID systému: Potrubní chladič - externí; Productdata: © MagiCAD Group, all rights reserved
Jiné - Rodina: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased; Id typu: 13962872; Rodina a typ: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased: CWK 400-3-2,5; Typ: CWK 400-3-2,5
Name (Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 400-3-2,5:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13967695 | 4.NP_SO-101 | 4.NP_SO-101 | 1270.11 | CH01.36.0154 | 0154 | Jiné - Páteřní trasa: yes
14074050 | -1.PP_SO-101 | -1.PP_SO-101 | 1725.99 | CH01.36.0159 | 0159

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1000x400x1000, Tlumič hluku hranatý kulisový.LH:1000x400x1000:13917985
In: 4.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 1000 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 1000 mm; Jmenovitá velikost výstupu - výška: 400 mm; Průtočná mezera: 100 mm; Šířka: 1000 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1000x400x1000; Označení typu: 28; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 19
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.52 m2; NetVolume: 0.404725 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 1576.9 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 19; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.404725 m3; Plocha: 2.76 m2; Velikost: 1000 × 400-1000 × 400
Identifikační data - Kód prvku: TC03.28.0124; Označení: 0124
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 14060169; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1000x400x1000; Typ: 1000x400x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:300x600x1000, Tlumič hluku hranatý kulisový.LH:300x600x1000:13828374
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 300 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 300 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 300 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 300x600x1000; Označení typu: 16; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: SUP 20
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.09 m2; NetVolume: 0.182275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 300 mm × 600 mm-300 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 300 mm × 600 mm-300 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 3257.5 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 20; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.182275 m3; Plocha: 1.545 m2; Velikost: 300 × 600-300 × 600
Identifikační data - Kód prvku: TC03.16.0075; Označení: 0075
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13828253; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 300x600x1000; Typ: 300x600x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:300x600x500, Tlumič hluku hranatý kulisový.LH:300x600x500:13829412
In: 2.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 300 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 300 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 300 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 300x600x500; Označení typu: 17; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 28
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.19 m2; NetVolume: 0.092275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 300 mm × 600 mm-300 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 300 mm × 600 mm-300 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 3140 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 28; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.092275 m3; Plocha: 1.095 m2; Velikost: 300 × 600-300 × 600
Identifikační data - Kód prvku: TC03.17.0078; Označení: 0078
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13828701; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 300x600x500; Typ: 300x600x500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:315x315x1000 (3)
In: 1.NP_SO-101
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 315 mm; Průtočná mezera: 100 mm; Šířka: 315 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 315x315x1000; Označení typu: 05; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku hranatý kulisový.LH; Počet kulis: 6
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.00595 m2; NetVolume: 0.100557 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 315 mm-315 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 315 mm-315 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 3155 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.100557 m3; Plocha: 1.00297 m2; Velikost: 315 × 315-315 × 315
Jiné - Páteřní trasa: yes; Id typu: 13624978; Rodina: Tlumič hluku hranatý kulisový.LH; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 315x315x1000; Typ: 315x315x1000
Name (Tlumič hluku hranatý kulisový.LH:315x315x1000:...) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13625015 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | TC03.05.0033 | 0033
13625051 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | TC03.05.0034 | 0034
13832353 | Přívodní | Přívod vzduchu | SUP 43 | SUP | TC03.05.0089 | 0089

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:315x315x1000, Tlumič hluku hranatý kulisový.LH:315x315x1000:13832411
In: 1.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 315 mm; Průtočná mezera: 100 mm; Šířka: 315 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 315x315x1000; Označení typu: 05; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku hranatý kulisový.LH; Počet kulis: 6
Classification: TC03 Uniformat (Uniformat); Group: ETA 29
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.00595 m2; NetVolume: 0.100557 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 315 mm-315 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 315 mm-315 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.00833333 m3/s; Tlaková ztráta: 0.000339299 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 3155.01 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 29; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.100557 m3; Plocha: 1.00297 m2; Velikost: 315 × 315-315 × 315
Identifikační data - Kód prvku: TC03.05.0090; Označení: 0090
Jiné - Páteřní trasa: yes; Id typu: 13624978; Rodina: Tlumič hluku hranatý kulisový.LH; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 315x315x1000; Typ: 315x315x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:315x560x1000, Tlumič hluku hranatý kulisový.LH:315x560x1000:13759590
In: -1.PP_SO-101
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 315 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu - šířka: 315 mm; Jmenovitá velikost výstupu - výška: 560 mm; Průtočná mezera: 100 mm; Šířka: 315 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 315x560x1000; Označení typu: 11; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.0129 m2; NetVolume: 0.178627 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm × 560 mm-315 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm × 560 mm-315 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 1300 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 3; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.178627 m3; Plocha: 1.50645 m2; Velikost: 315 × 560-315 × 560
Identifikační data - Kód prvku: TC03.11.0062; Označení: 0062
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13620202; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 315x560x1000; Typ: 315x560x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:500x600x1500, Tlumič hluku hranatý kulisový.LH:500x600x1500:13844719
In: 4.NP_SO-101
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 500 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 500x600x1500; Označení typu: 22; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 14
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.354 m2; NetVolume: 0.453575 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 600 mm-500 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 600 mm-500 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 800 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 14; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.453575 m3; Plocha: 2.677 m2; Velikost: 500 × 600-500 × 600
Identifikační data - Kód prvku: TC03.22.0110; Označení: 0110
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13844638; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 500x600x1500; Typ: 500x600x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:560x400x1500, Tlumič hluku hranatý kulisový.LH:560x400x1500:13898206
In: 4.NP_SO-101
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 560 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 560 mm; Jmenovitá velikost výstupu - výška: 400 mm; Průtočná mezera: 100 mm; Šířka: 560 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 560x400x1500; Označení typu: 23; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.4472 m2; NetVolume: 0.338745 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 560 mm × 400 mm-560 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 560 mm × 400 mm-560 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: 965 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 1; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.338745 m3; Plocha: 2.2236 m2; Velikost: 560 × 400-560 × 400
Identifikační data - Kód prvku: TC03.23.0113; Označení: 0113
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13898239; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 560x400x1500; Typ: 560x400x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x300x1000, Tlumič hluku hranatý kulisový.LH:600x300x1000:13827054
In: 2.NP_SO-101
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 300 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 300 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 300 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x300x1000; Označení typu: 15; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
