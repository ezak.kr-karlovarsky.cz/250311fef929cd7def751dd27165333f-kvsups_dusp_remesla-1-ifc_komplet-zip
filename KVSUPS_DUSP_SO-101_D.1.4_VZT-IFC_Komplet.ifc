Properties of the parts of a building model (IFC4), part 10 of 21

# IfcDistributionPort (3839)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_14064724_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_12996920_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_12998163_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533642_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_12998163_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529317_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13118589_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13547847_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13540619_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13118589_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13118589_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13501771_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13118589_4 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13501795_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13452292_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13119322_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13119322_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14002817_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13119331_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14042709_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14042711_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13119331_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13123321_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14042878_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14044341_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13123321_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13321210_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13764674_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13321210_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14070746_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13528763_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13322445_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13322446_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13932505_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14048255_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13322446_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13407843_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030236_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13999627_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13407843_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13533691_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13407843_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13533715_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13407843_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13762391_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13407866_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13407866_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13762684_3 | SOURCE | DUCT | VENTILATION | ETA 4
Port_13407868_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_13762684_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_13407868_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
Port_13762558_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 4
InPort_13407868_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13841819_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13407876_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13452388_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14002739_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13407876_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13577663_2 | SINK | DUCT | VENTILATION | ETA 4
OutPort_13407883_0 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13407883_1 | SINK | DUCT | VENTILATION | ETA 4
OutPort_14042242_1 | SOURCE | DUCT | VENTILATION | ETA 4
InPort_13407931_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704891_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_14067680_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13407931_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13407931_3 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458427_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13503737_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13409872_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13409872_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13959134_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460979_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13409872_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13461007_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13409872_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13461035_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13409872_4 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14072068_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13409983_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13409983_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072121_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13409983_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13460418_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13409983_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13460442_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13409983_4 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13460472_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13410323_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14033196_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14033198_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13410323_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13829774_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13410324_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13410324_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14004616_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13410709_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13427874_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13503598_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13410709_1 | SOURCE | DUCT | VENTILATION | SUP 27
Port_13410902_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13969605_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13410902_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13503598_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_13523349_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13410902_2 | SOURCE | DUCT | VENTILATION | SUP 27
Port_13410910_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13969605_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
Port_13410910_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 27
InPort_13502405_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13410910_2 | SOURCE | DUCT | VENTILATION | SUP 27
Port_13410991_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13971498_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13410991_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13971192_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_14042709_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13411568_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13411568_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_14044507_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13840855_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13411616_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13411616_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13926968_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13505762_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13413254_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13413254_2 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13505683_0 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13413254_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13505528_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13505574_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13413254_4 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13413980_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13540954_3 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13966762_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13413980_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13413980_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13501439_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13413980_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13501541_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13415163_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13415165_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13415165_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13443579_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13417411_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13417411_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13999563_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13417411_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13512362_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13417411_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13512398_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13417765_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13835599_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13417765_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13513859_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13420243_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13841268_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000904_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13420243_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13763692_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13420243_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13421340_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908814_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13835538_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13421340_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13453982_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13421340_5 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13738863_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13421856_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13421856_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13740119_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14072222_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13421915_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13421915_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13926459_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13424462_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13738931_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14073366_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13424462_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13425859_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000906_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13923565_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13425859_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13425859_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13545139_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13632366_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13426364_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13426364_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13843705_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13427874_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13537851_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13433496_1 | SINK | DUCT | VENTILATION | SUP 43
InPort_13433502_1 | SINK | DUCT | VENTILATION | SUP 43
Port_13435227_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13960644_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13435227_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13531029_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_14049936_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13435564_0 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13435564_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_14049938_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13435587_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13480632_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13967230_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13435587_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13971343_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13438941_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438941_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000749_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438941_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523400_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438941_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523424_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438941_4 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13538087_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438941_5 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13933187_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13438968_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13538084_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13538087_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13438968_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13439466_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14072068_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523692_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13439466_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13439466_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13504010_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13439641_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13503737_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13503749_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13439641_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13439676_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13503749_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000752_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13439676_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13461088_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13439676_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13461112_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13439676_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13442660_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13439914_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13439914_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14050509_1 | SOURCE | DUCT | VENTILATION | ETA 29
Port_13442092_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442113_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442117_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442113_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442119_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442117_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932562_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442119_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442121_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442121_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13442124_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13442125_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14039447_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13442124_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442125_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13932562_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442127_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13442136_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14039449_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13442127_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442128_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14039446_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442130_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14039447_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442131_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14039448_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442132_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14039449_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13442133_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932562_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13442133_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13442136_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13452714_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13442274_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704785_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704799_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13442274_2 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13442437_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13704803_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13442569_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13442437_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704819_0 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13442569_2 | SOURCE | DUCT | VENTILATION | ETA 29
OutPort_13442659_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13442659_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13442660_0 | SOURCE | DUCT | VENTILATION | ETA 29
Port_13442767_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_14070313_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_13442767_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_13442946_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_13442946_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_13442947_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
Port_13442947_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 2
InPort_13443017_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704474_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000877_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443017_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455042_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443017_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704692_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443019_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443019_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13964726_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455218_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443019_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704524_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443023_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443023_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443027_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704634_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443025_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443025_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443030_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443027_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704628_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443030_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704686_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443207_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13961126_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13964726_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443207_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13443459_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932562_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13443459_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13452714_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14062497_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13443564_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13443564_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13443579_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13443564_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13512440_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13935481_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13443775_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13443775_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935482_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14062574_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13443820_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13443820_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14070266_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13970265_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13444619_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13444619_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970300_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13444633_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842801_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000754_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13444633_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460839_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13444633_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460871_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13444633_4 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460895_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13444633_5 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13843170_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13444719_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13444719_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13444871_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13444871_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13444861_0 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13444861_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13444861_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13502776_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13444861_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13502889_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13444861_4 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13502818_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13842730_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13445091_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13445091_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842676_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13452280_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13452292_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000908_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13452280_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13452333_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13452280_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13452388_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13452380_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13452380_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13452397_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13452397_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13452391_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13452391_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000910_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13452391_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13504128_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13452714_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533468_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13453004_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070381_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13453004_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14070572_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13453704_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455338_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13453734_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13705002_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13453768_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704988_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13907468_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13454191_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13454191_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000756_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13454191_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13461308_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13454191_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13461332_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13454246_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454224_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13454224_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539766_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13454238_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454246_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000759_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454238_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460634_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454238_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460660_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454238_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13460684_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13454238_4 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13455066_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704476_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455090_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704518_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455118_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704628_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455190_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13704686_2 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13455338_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13705000_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13455338_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508662_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455523_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908654_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13835536_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455523_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14054881_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13455602_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13455602_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14000879_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13455602_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13511769_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13455602_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13511793_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13455738_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908775_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455762_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13908775_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455923_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462444_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455946_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455923_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455938_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455946_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455955_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455938_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13532691_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455938_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13455949_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455955_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13827792_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455949_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13461543_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13455949_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13456168_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_14035123_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_14035127_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456168_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456323_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_14035127_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456352_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456323_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456346_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456352_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456573_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456346_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456355_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456573_2 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456575_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456355_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456508_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456575_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_14049938_1 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13456508_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13456603_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13456611_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000881_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13456603_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13461509_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13456603_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13456611_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13827909_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13630955_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13457493_0 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13457493_1 | SINK | DUCT | VENTILATION | ETA 29
OutPort_14000821_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13457493_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13510097_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13457565_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457582_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14000823_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457565_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508258_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457565_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508278_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457565_3 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508298_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457565_4 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13829862_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457574_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13457574_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13931301_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14072806_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457574_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13457582_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076543_0 | SOURCE | DUCT | VENTILATION | SUP 20
Port_13457647_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829902_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13457647_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509401_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13457647_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_14072544_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457656_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13999346_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13999348_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457656_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457656_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13918487_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457662_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13918316_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13834762_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457662_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_14076550_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457686_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13457686_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076542_3 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13457697_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14076550_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13918679_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457697_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508346_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13457697_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13457733_0 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13999400_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13999403_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457733_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13999346_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457910_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457910_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_14000825_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457910_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457955_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13457910_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13457981_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13458114_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13630884_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000827_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13458114_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508058_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13458114_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13704738_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458289_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704799_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458311_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704819_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458355_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13704887_2 | SINK | DUCT | VENTILATION | ETA 29
OutPort_13458391_1 | SOURCE | DUCT | VENTILATION | ETA 29
InPort_13705172_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13458937_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14054655_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13458961_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13843705_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13460539_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13460815_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842730_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13538084_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13461252_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13461634_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13827792_0 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13462036_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462341_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462036_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462621_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13462341_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13462179_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13462341_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462362_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462362_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14031643_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13462444_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462475_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462446_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462474_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13849869_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462446_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462475_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462474_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462474_3 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462661_0 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13462613_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462621_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462613_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462635_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462626_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462635_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13462626_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14030094_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13529850_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462652_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462652_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462671_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462661_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13529850_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462671_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13462665_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13462665_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13512038_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13830510_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13479598_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13479598_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509157_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13830664_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13479645_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13479645_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830347_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13479645_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13909727_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13479645_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13909793_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13479645_4 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13909850_1 | SOURCE | DUCT | VENTILATION | ETA 28
Port_13479653_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964535_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13479653_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829100_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13830347_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13479816_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13479816_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13509331_2 | SOURCE | DUCT | VENTILATION | ETA 28
Port_13480246_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
Port_13829125_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 20
InPort_14033273_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13480246_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13480246_2 | SINK | DUCT | VENTILATION | SUP 20
OutPort_14033536_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13480542_0 | SINK | DUCT | EXHAUST | ETA 30
OutPort_14049936_1 | SOURCE | DUCT | EXHAUST | ETA 30
InPort_13480632_2 | SINK | DUCT | EXHAUST | ETA 30
OutPort_13480542_1 | SOURCE | DUCT | EXHAUST | ETA 30
Port_13480777_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_14063966_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13480777_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519409_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13500070_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13614156_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_13500070_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
Port_14056037_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 1
InPort_13540429_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13501751_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13503622_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502512_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502512_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13503598_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13540312_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502512_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502525_0 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13503622_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14000761_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502525_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502595_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502525_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502619_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502525_3 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502647_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502525_4 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13502667_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13502525_5 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_14030721_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13503431_1 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13504195_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13614336_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13504195_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13531019_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13828009_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13505019_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13509157_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505209_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505277_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505209_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505209_3 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13931934_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505259_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505277_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13931301_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505259_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13964159_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505409_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505409_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505767_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505767_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505420_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505420_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505769_2 | SOURCE | DUCT | VENTILATION | SUP 20
Port_13505486_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829100_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505486_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505492_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505492_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505498_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505504_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505498_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13830789_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13505504_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13505529_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13505507_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13505507_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830789_2 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13505528_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13505526_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13505526_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13505529_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13505560_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827214_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827293_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13505560_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13505572_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13505574_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13505575_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13505572_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827202_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13505575_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13826752_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13505671_0 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13505671_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826685_2 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13505683_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13505681_0 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13505681_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826683_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13505689_0 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13826466_2 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13826467_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13505689_1 | SOURCE | DUCT | VENTILATION | ODA 11
InPort_13505760_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505762_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13505769_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13505760_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13826466_1 | SINK | DUCT | VENTILATION | ODA 11
OutPort_13506025_1 | SOURCE | DUCT | VENTILATION | ODA 11
Port_13506026_1 | SOURCEANDSINK | CABLE | CONTROL
Port_13506026_2 | SOURCEANDSINK | CABLE | ELECTROACOUSTIC
Port_13506026_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_13506285_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827747_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827762_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13506285_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827268_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13506825_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13506825_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827293_2 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13506888_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827268_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13827502_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13506888_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13506992_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13507043_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14000331_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13506992_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13507043_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13507035_0 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13507035_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13507146_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13507138_0 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13827758_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_14055089_1 | SINK | DUCT | EXHAUST | EHA 8
OutPort_13507138_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13507146_2 | SINK | DUCT | EXHAUST | EHA 8
OutPort_14055107_1 | SOURCE | DUCT | EXHAUST | EHA 8
InPort_13508106_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830582_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508126_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830582_3 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508146_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830582_4 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13508662_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508656_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508656_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508698_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508698_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13844021_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508729_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14069993_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13844043_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13508729_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14070024_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508773_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14000829_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508773_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508818_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508773_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13508842_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13508773_3 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14069853_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13508874_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13508874_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14000831_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13508874_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13508921_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13509033_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509077_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509077_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509278_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_14000833_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509077_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509119_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509077_3 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509215_0 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509276_2 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509278_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13509215_1 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509276_1 | SINK | DUCT | VENTILATION | SUP 20
OutPort_13830582_0 | SOURCE | DUCT | VENTILATION | SUP 20
InPort_13509331_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13509323_0 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13509323_1 | SINK | DUCT | VENTILATION | ETA 28
OutPort_14000835_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13509323_2 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13509966_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13509323_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13509986_1 | SOURCE | DUCT | VENTILATION | ETA 28
InPort_13509323_4 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13510049_1 | SOURCE | DUCT | VENTILATION | ETA 28
Port_13509377_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964593_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509377_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13829060_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13509377_3 | SINK | DUCT | VENTILATION | ETA 28
OutPort_13830385_0 | SOURCE | DUCT | VENTILATION | ETA 28
Port_13509393_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509401_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509393_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964632_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509592_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13509594_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13509592_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13705274_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13509594_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13844039_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13509795_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964593_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13509795_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
Port_13964608_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 28
InPort_13511606_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13835138_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13835077_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13511644_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13511644_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14000883_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13511644_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13511705_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13512014_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13528872_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13512038_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13512014_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14070096_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13512468_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13512748_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13512748_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14028670_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13512794_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13968053_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13512794_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13849551_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13939065_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13512794_2 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13513847_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14031542_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13513847_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13513859_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_14068415_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_13518474_0 | SOURCE | DUCT | VENTILATION | ODA 1
InPort_13518474_1 | SINK | DUCT | VENTILATION | ODA 1
OutPort_14057710_1 | SOURCE | DUCT | VENTILATION | ODA 1
Port_13518843_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519202_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844721_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519402_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519409_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519402_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519426_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519413_0 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13844724_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519413_1 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
Port_13519426_2 | SOURCEANDSINK | DUCT | EXHAUST | EHA 14
InPort_13520138_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14035677_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13917985_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13520138_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14028662_1 | SINK | DUCT | VENTILATION | ETA 14
OutPort_13520466_1 | SOURCE | DUCT | VENTILATION | ETA 14
InPort_13520466_2 | SINK | DUCT | VENTILATION | ETA 14
InPort_13917462_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13520551_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520551_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058113_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520640_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13917464_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520641_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13520640_2 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520640_3 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058221_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14035677_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13520641_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520641_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13936057_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14058114_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13520757_0 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13520757_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14058133_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_14055241_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523233_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523233_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13632366_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523233_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523290_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523682_0 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523692_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523682_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14000764_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523682_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523779_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13523682_3 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13523811_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13525743_1 | SINK | DUCT | VENTILATION | SUP 43
InPort_13525798_1 | SINK | DUCT | VENTILATION | SUP 43
Port_13525869_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13525893_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13527670_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527868_3 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527670_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527689_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527681_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527689_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13527681_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13764674_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_14062799_0 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13527868_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13527868_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_13528981_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13528762_1 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13528790_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13528762_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_14048273_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13528790_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13528763_1 | SOURCE | DUCT | VENTILATION | ETA 19
InPort_13528872_2 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14060592_0 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13528981_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
Port_14030096_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 19
InPort_13529262_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13935330_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13529262_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14001218_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529263_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_14001218_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529263_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529328_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529315_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529317_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529315_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13529328_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13531019_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
Port_13531029_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 30
InPort_13845211_2 | SINK | DUCT | VENTILATION | ETA 19
OutPort_13532742_1 | SOURCE | DUCT | VENTILATION | ETA 19
Port_13533453_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533468_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533453_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533650_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533470_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932663_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533470_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533652_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13961971_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13533470_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13533516_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13533515_0 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13533515_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13961971_1 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_13533567_0 | SINK | DUCT | VENTILATION | SUP 43
OutPort_14030156_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14030174_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13533567_1 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13533640_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533642_3 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533640_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13533652_1 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13533643_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13533642_2 | SOURCE | DUCT | VENTILATION | SUP 43
InPort_14030156_1 | SINK | DUCT | VENTILATION | SUP 43
OutPort_13533643_0 | SOURCE | DUCT | VENTILATION | SUP 43
Port_13533650_2 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
Port_13932664_0 | SOURCEANDSINK | DUCT | VENTILATION | SUP 43
InPort_13537849_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13829774_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13829776_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13537849_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13537851_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13829776_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13537888_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14033206_1 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14033196_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13537888_2 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_14033206_2 | SINK | DUCT | VENTILATION | ETA 30
OutPort_13537890_0 | SOURCE | DUCT | VENTILATION | ETA 30
InPort_13537890_1 | SINK | DUCT | VENTILATION | ETA 30
OutPort_14033208_2 | SOURCE | DUCT | VENTILATION | ETA 30
Port_13538762_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13626260_2 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13538762_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13626278_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13538795_0 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13626260_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
Port_13538795_1 | SOURCEANDSINK | DUCT | VENTILATION | ETA 32
InPort_13539663_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970265_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13829788_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539663_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842530_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539665_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13539665_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13829788_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13970286_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539699_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13539699_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970295_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13539766_2 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13842518_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13539786_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13970286_1 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13829792_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539786_2 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13842508_1 | SINK | DUCT | VENTILATION | SUP 27
OutPort_13539788_0 | SOURCE | DUCT | VENTILATION | SUP 27
InPort_13539788_1 | SINK | DUCT | VENTILATION | SUP 27
