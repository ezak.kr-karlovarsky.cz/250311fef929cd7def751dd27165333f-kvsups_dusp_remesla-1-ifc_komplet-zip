Properties of the parts of a building model (IFC4), part 5 of 9

# IfcSpace: Šablonárna-2 A0103-2:12813202, A0103-2
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 52.6757 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103-2; Číslo místnosti: Neobsazené; Název: Šablonárna-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M-1 A0111-1:12813102, A0111-1
In: -1.PP_SO-101
LongName: Šatna-M-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111-1; Číslo místnosti: Neobsazené; Název: Šatna-M-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-M-1 A0114.1-1:12813135, A0114.1-1
In: -1.PP_SO-101
LongName: Šatna-M-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1-1; Číslo místnosti: Neobsazené; Název: Šatna-M-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-M-1 A0115.1-1:12813136, A0115.1-1
In: -1.PP_SO-101
LongName: Šatna-M-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1-1; Číslo místnosti: Neobsazené; Název: Šatna-M-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-M-2 A0111-2:12813219, A0111-2
In: -1.PP_SO-101
LongName: Šatna-M-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111-2; Číslo místnosti: Neobsazené; Název: Šatna-M-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M-2 A0114.1-2:12813252, A0114.1-2
In: -1.PP_SO-101
LongName: Šatna-M-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1-2; Číslo místnosti: Neobsazené; Název: Šatna-M-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M-2 A0115.1-2:12813253, A0115.1-2
In: -1.PP_SO-101
LongName: Šatna-M-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1-2; Číslo místnosti: Neobsazené; Název: Šatna-M-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-Ž-1 A0108-1:12813104, A0108-1
In: -1.PP_SO-101
LongName: Šatna-Ž-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108-1; Číslo místnosti: Neobsazené; Název: Šatna-Ž-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-Ž-2 A0108-2:12813221, A0108-2
In: -1.PP_SO-101
LongName: Šatna-Ž-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108-2; Číslo místnosti: Neobsazené; Název: Šatna-Ž-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcBuildingElementProxy: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU:DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU, DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU:DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU:12797023
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU; Název typu: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU; Označení typu: 02; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU
Classification: AT01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.15 m2; NetVolume: 1.125 m3
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Bouráno ve FÁZI 2: yes; Fáze vytvoření: Fáze 1
Kóty - Objem: 1.125 m3; Plocha: 0.45 m2
Identifikační data - Kód prvku: AT01.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Id typu: 12797021; Rodina: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU; Rodina a typ: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU; Typ: DOČASNÉ PŘÍPOJNÉ MÍSTO PLYNU

# IfcBuildingElementProxy: Stávající HUP SO101:Stávající HUP SO101, Stávající HUP SO101:Stávající HUP SO101:12765919
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: VE01; Komentáře k typům: STÁVAJÍCÍ ZEMNÍ HUP; Název typu: Stávající HUP SO101; Označení typu: 01; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Stávající HUP SO101
Classification: VE01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.75232 m2; NetVolume: 0.144794 m3
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Přesunout s blízkými prvky: no
Fázování - Bouráno ve FÁZI 2: yes; Fáze vytvoření: Stávající stav
Kóty - Objem: 0.144794 m3; Plocha: 0.166777 m2
Identifikační data - Kód prvku: VE01.01.0001; Označení: 0001
Jiné - Id typu: 12765917; Rodina: Stávající HUP SO101; Rodina a typ: Stávající HUP SO101: Stávající HUP SO101; Typ: Stávající HUP SO101

# IfcDistributionPort (1119)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12766300_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800209_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12766300_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12768241_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801742_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12768241_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801774_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12768441_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800557_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12768441_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12784374_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12768451_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800551_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12768451_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800555_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769175_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804799_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769175_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801391_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769449_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801742_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769449_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800488_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769459_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800488_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12769459_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12782200_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12772258_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12774303_0 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12774398_0 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12772258_2 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12772258_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_12772304_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12772306_0 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12790459_0 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12772304_2 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12772304_3 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_12772306_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12790491_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12790491_2 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12774197_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12774197_2 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12790521_2 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774199_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788276_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774199_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12790521_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774303_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774505_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774344_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802042_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774344_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802027_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774353_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816760_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774353_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816762_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774398_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802029_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774402_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801129_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774402_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801131_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12774505_2 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12800734_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774647_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783031_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774647_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774845_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774656_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775058_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774656_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774785_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774719_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775056_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774719_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775058_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774785_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781911_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774820_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774845_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774820_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774824_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774824_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776992_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774845_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783025_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774857_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783025_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12774857_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775543_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775037_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801129_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775037_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775056_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775098_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775513_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775098_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779275_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775112_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780054_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775112_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775513_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775172_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780048_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775172_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775432_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775215_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779479_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775215_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775352_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775352_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775483_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775419_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775434_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775419_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779295_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775430_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775432_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775430_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775434_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775445_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775460_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775445_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779307_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775454_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780050_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775454_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775460_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775456_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780048_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775456_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775457_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775456_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780050_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775457_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775482_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775471_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775486_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775471_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779323_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775480_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780052_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775480_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775486_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775482_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775483_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775482_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780052_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775543_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775555_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775543_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780054_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775555_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775604_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775604_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776393_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775691_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776310_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775691_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779211_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775730_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776384_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775730_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779251_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775903_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775911_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775903_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775985_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775911_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776304_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775913_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775989_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775913_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779195_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775983_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775985_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775983_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12775989_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776005_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780056_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776005_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776066_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776015_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776319_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776015_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776378_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776015_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780056_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776019_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776070_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776019_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779235_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776064_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776066_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776064_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776070_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776295_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776314_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776295_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780060_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776304_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780058_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776308_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776310_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776308_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776314_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776318_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780058_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776318_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776319_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776318_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780060_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776369_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776388_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776369_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780062_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776378_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776392_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776382_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776384_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776382_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776388_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776392_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776393_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776392_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780062_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776465_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776499_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776465_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779159_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776467_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776513_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776467_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779171_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776469_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776471_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776469_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776477_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776471_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776495_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776473_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776479_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776473_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12778062_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776475_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776477_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776475_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776479_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776481_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780064_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776481_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776489_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776483_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776504_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776483_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776509_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776483_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780064_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776485_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776491_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776485_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779125_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776487_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776489_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776487_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776491_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776493_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776501_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776493_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780066_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776495_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779113_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776497_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776499_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776497_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776501_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776503_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779113_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776503_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776504_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776503_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780066_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776507_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776515_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776507_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780068_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776509_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776517_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776511_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776513_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776511_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776515_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776517_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776591_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776517_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780068_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776577_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776599_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776577_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779183_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776579_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780070_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776579_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776587_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776581_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776591_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776581_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776595_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776581_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780070_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776583_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776589_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776583_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779143_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776585_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776587_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776585_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776589_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776593_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776601_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776593_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780072_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776595_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776654_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776597_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776599_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776597_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776601_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776654_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776666_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776654_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780072_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776666_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776774_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776772_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776774_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776772_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779397_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776933_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780074_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776933_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776939_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776935_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776941_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776935_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779345_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776937_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776939_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776937_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776941_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776943_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776951_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776943_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779333_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776945_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780076_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776945_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776951_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776947_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780074_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776947_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776948_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776947_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780076_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776948_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776957_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776957_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776975_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776975_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776987_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776977_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776987_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776977_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776991_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776984_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779462_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776984_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776991_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776991_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783027_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12776992_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783027_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12778062_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776473_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779125_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776485_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779143_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776583_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779159_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776465_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779171_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776467_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779183_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776577_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779195_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775913_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779211_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775691_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779235_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776019_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779251_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775730_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779275_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775098_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779295_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775419_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779307_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775445_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779323_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12775471_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779333_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776943_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779345_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12776935_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779389_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779397_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779389_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779462_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779462_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779472_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779472_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779479_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779493_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781969_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779493_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780322_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779495_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780311_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779495_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779497_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779497_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781972_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779499_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783131_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779499_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780339_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779501_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780322_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779501_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780078_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779501_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783131_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779503_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780078_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779503_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779792_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779505_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779543_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779505_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779731_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779507_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779792_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779507_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779543_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779509_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780080_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779509_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779519_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779511_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780560_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779511_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779513_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779513_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779538_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779515_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779521_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779515_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779732_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779517_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779519_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779517_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779521_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779523_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779531_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779523_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779733_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779525_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780082_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779525_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779531_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779527_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780080_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779527_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779528_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779527_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780082_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779528_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779537_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779533_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779541_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779533_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779734_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779535_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780084_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779535_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779541_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
