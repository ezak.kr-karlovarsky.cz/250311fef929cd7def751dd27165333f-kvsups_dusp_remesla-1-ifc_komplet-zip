Properties of the parts of a building model (IFC4), part 8 of 9

# IfcPipeSegment: Typy trubek:Ocel_černá (215)
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
12775112 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.713 | 985.713 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 63 | ø15 | 21.3 | 16 | TR02.02.0022 | 0022 | no | GS_NTL vnitřní 3
12775172 | 2.NP_SO-101 | 1689.64 | 0.000356274 | 0.113064 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0796224 | 15 | 29 | ø15 | 21.3 | 16 | TR02.02.0023 | 0023 | no | GS_NTL vnitřní 3
12775215 | 1.NP_SO-101 | 758.725 | 0.000891835 | 0.0803275 | ø25 mm | 0.00367647 | 4479.36 | 4479.36 | 3720.64 | 1.NP_SO-101 |  | 3720.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3720.64 | 0.0595901 | 25 | 62 | ø25 | 33.7 | 27.2 | TR02.02.0024 | 0024 | no | GS_NTL vnitřní 3
12775419 | 2.NP_SO-101 | 297.712 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 29 | ø15 | 21.3 | 16 | TR02.02.0025 | 0025 | no | GS_NTL vnitřní 3
12775430 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 29 | ø15 | 21.3 | 16 | TR02.02.0026 | 0026 | no | GS_NTL vnitřní 3
12775445 | 2.NP_SO-101 | 297.712 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 30 | ø15 | 21.3 | 16 | TR02.02.0027 | 0027 | no | GS_NTL vnitřní 3
12775454 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 30 | ø15 | 21.3 | 16 | TR02.02.0028 | 0028 | no | GS_NTL vnitřní 3
12775457 | 2.NP_SO-101 | 1763.4 | 0.000891835 | 0.186694 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.138497 | 25 | 22 | ø25 | 33.7 | 27.2 | TR02.02.0029 | 0029 | no | GS_NTL vnitřní 3
12775471 | 2.NP_SO-101 | 297.712 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 32 | ø15 | 21.3 | 16 | TR02.02.0030 | 0030 | no | GS_NTL vnitřní 3
12775480 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 32 | ø15 | 21.3 | 16 | TR02.02.0031 | 0031 | no | GS_NTL vnitřní 3
12775483 | 2.NP_SO-101 | 1524.61 | 0.000891835 | 0.161413 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.119742 | 25 | 62 | ø25 | 33.7 | 27.2 | TR02.02.0032 | 0032 | no | GS_NTL vnitřní 3
12775555 | 2.NP_SO-101 | 101.696 | 0.000891835 | 0.0107667 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.00798718 | 25 | 34 | ø25 | 33.7 | 27.2 | TR02.02.0033 | 0033 | no | GS_NTL vnitřní 3
12775691 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 41 | ø15 | 21.3 | 16 | TR02.02.0034 | 0034 | no | GS_NTL vnitřní 3
12775730 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 42 | ø15 | 21.3 | 16 | TR02.02.0035 | 0035 | no | GS_NTL vnitřní 3
12775903 | 2.NP_SO-101 | 120.746 | 0.000356274 | 0.00807982 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00569002 | 15 | 38 | ø15 | 21.3 | 16 | TR02.02.0036 | 0036 | no | GS_NTL vnitřní 3
12775913 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 38 | ø15 | 21.3 | 16 | TR02.02.0037 | 0037 | no | GS_NTL vnitřní 3
12775983 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 38 | ø15 | 21.3 | 16 | TR02.02.0038 | 0038 | no | GS_NTL vnitřní 3
12776005 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 40 | ø15 | 21.3 | 16 | TR02.02.0039 | 0039 | no | GS_NTL vnitřní 3
12776019 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 40 | ø15 | 21.3 | 16 | TR02.02.0040 | 0040 | no | GS_NTL vnitřní 3
12776064 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 40 | ø15 | 21.3 | 16 | TR02.02.0041 | 0041 | no | GS_NTL vnitřní 3
12776295 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 41 | ø15 | 21.3 | 16 | TR02.02.0042 | 0042 | no | GS_NTL vnitřní 3
12776304 | 2.NP_SO-101 | 1417.93 | 0.000356274 | 0.0948822 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0668184 | 15 | 38 | ø15 | 21.3 | 16 | TR02.02.0043 | 0043 | no | GS_NTL vnitřní 3
12776308 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 41 | ø15 | 21.3 | 16 | TR02.02.0044 | 0044 | no | GS_NTL vnitřní 3
12776319 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 39 | ø25 | 33.7 | 27.2 | TR02.02.0045 | 0045 | no | GS_NTL vnitřní 3
12776369 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 42 | ø15 | 21.3 | 16 | TR02.02.0046 | 0046 | no | GS_NTL vnitřní 3
12776378 | 2.NP_SO-101 | 1442.56 | 0.000891835 | 0.152727 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.113299 | 25 | 37 | ø25 | 33.7 | 27.2 | TR02.02.0047 | 0047 | no | GS_NTL vnitřní 3
12776382 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 42 | ø15 | 21.3 | 16 | TR02.02.0048 | 0048 | no | GS_NTL vnitřní 3
12776393 | 2.NP_SO-101 | 229.537 | 0.000891835 | 0.0243015 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0180278 | 25 | 34 | ø25 | 33.7 | 27.2 | TR02.02.0049 | 0049 | no | GS_NTL vnitřní 3
12776465 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 53 | ø15 | 21.3 | 16 | TR02.02.0050 | 0050 | no | GS_NTL vnitřní 3
12776467 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 55 | ø15 | 21.3 | 16 | TR02.02.0051 | 0051 | no | GS_NTL vnitřní 3
12776469 | 2.NP_SO-101 | 120.746 | 0.000356274 | 0.00807982 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00569002 | 15 | 52 | ø15 | 21.3 | 16 | TR02.02.0052 | 0052 | no | GS_NTL vnitřní 3
12776473 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 52 | ø15 | 21.3 | 16 | TR02.02.0053 | 0053 | no | GS_NTL vnitřní 3
12776475 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 52 | ø15 | 21.3 | 16 | TR02.02.0054 | 0054 | no | GS_NTL vnitřní 3
12776481 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 54 | ø15 | 21.3 | 16 | TR02.02.0055 | 0055 | no | GS_NTL vnitřní 3
12776485 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 54 | ø15 | 21.3 | 16 | TR02.02.0056 | 0056 | no | GS_NTL vnitřní 3
12776487 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 54 | ø15 | 21.3 | 16 | TR02.02.0057 | 0057 | no | GS_NTL vnitřní 3
12776493 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 53 | ø15 | 21.3 | 16 | TR02.02.0058 | 0058 | no | GS_NTL vnitřní 3
12776495 | 2.NP_SO-101 | 1417.93 | 0.000356274 | 0.0948822 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0668184 | 15 | 52 | ø15 | 21.3 | 16 | TR02.02.0059 | 0059 | no | GS_NTL vnitřní 3
12776497 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 53 | ø15 | 21.3 | 16 | TR02.02.0060 | 0060 | no | GS_NTL vnitřní 3
12776504 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 51 | ø25 | 33.7 | 27.2 | TR02.02.0061 | 0061 | no | GS_NTL vnitřní 3
12776507 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 55 | ø15 | 21.3 | 16 | TR02.02.0062 | 0062 | no | GS_NTL vnitřní 3
12776509 | 2.NP_SO-101 | 1442.56 | 0.000891835 | 0.152727 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.113299 | 25 | 50 | ø25 | 33.7 | 27.2 | TR02.02.0063 | 0063 | no | GS_NTL vnitřní 3
12776511 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 55 | ø15 | 21.3 | 16 | TR02.02.0064 | 0064 | no | GS_NTL vnitřní 3
12776577 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 47 | ø15 | 21.3 | 16 | TR02.02.0065 | 0065 | no | GS_NTL vnitřní 3
12776579 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 46 | ø15 | 21.3 | 16 | TR02.02.0066 | 0066 | no | GS_NTL vnitřní 3
12776583 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 46 | ø15 | 21.3 | 16 | TR02.02.0067 | 0067 | no | GS_NTL vnitřní 3
12776585 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 46 | ø15 | 21.3 | 16 | TR02.02.0068 | 0068 | no | GS_NTL vnitřní 3
12776591 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 49 | ø25 | 33.7 | 27.2 | TR02.02.0069 | 0069 | no | GS_NTL vnitřní 3
12776593 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 47 | ø15 | 21.3 | 16 | TR02.02.0070 | 0070 | no | GS_NTL vnitřní 3
12776595 | 2.NP_SO-101 | 1442.56 | 0.000891835 | 0.152727 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.113299 | 25 | 45 | ø25 | 33.7 | 27.2 | TR02.02.0071 | 0071 | no | GS_NTL vnitřní 3
12776597 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 47 | ø15 | 21.3 | 16 | TR02.02.0072 | 0072 | no | GS_NTL vnitřní 3
12776666 | 2.NP_SO-101 | 54.3625 | 0.000891835 | 0.00575545 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.00426962 | 25 | 48 | ø25 | 33.7 | 27.2 | TR02.02.0073 | 0073 | no | GS_NTL vnitřní 3
12776772 | 1.NP_SO-101 | 758.725 | 0.000891835 | 0.0803275 | ø25 mm | 0.00367647 | 4479.36 | 3720.64 | 4479.36 | 1.NP_SO-101 |  | 3720.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3720.64 | 0.0595901 | 25 | 48 | ø25 | 33.7 | 27.2 | TR02.02.0074 | 0074 | no | GS_NTL vnitřní 3
12776933 | 2.NP_SO-101 | 1689.64 | 0.000356274 | 0.113064 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0796224 | 15 | 58 | ø15 | 21.3 | 16 | TR02.02.0075 | 0075 | no | GS_NTL vnitřní 3
12776935 | 2.NP_SO-101 | 297.712 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 58 | ø15 | 21.3 | 16 | TR02.02.0076 | 0076 | no | GS_NTL vnitřní 3
12776937 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 58 | ø15 | 21.3 | 16 | TR02.02.0077 | 0077 | no | GS_NTL vnitřní 3
12776943 | 2.NP_SO-101 | 297.712 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 59 | ø15 | 21.3 | 16 | TR02.02.0078 | 0078 | no | GS_NTL vnitřní 3
12776945 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 59 | ø15 | 21.3 | 16 | TR02.02.0079 | 0079 | no | GS_NTL vnitřní 3
12776948 | 2.NP_SO-101 | 1460.3 | 0.000891835 | 0.154605 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.114692 | 25 | 57 | ø25 | 33.7 | 27.2 | TR02.02.0080 | 0080 | no | GS_NTL vnitřní 3
12776975 | 1.NP_SO-101 | 758.725 | 0.000891835 | 0.0803275 | ø25 mm | 0.00367647 | 4479.36 | 3720.64 | 4479.36 | 1.NP_SO-101 |  | 3720.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3720.64 | 0.0595901 | 25 | 57 | ø25 | 33.7 | 27.2 | TR02.02.0081 | 0081 | no | GS_NTL vnitřní 3
12776977 | 1.NP_SO-101 | 1541.67 | 0.000891835 | 0.163219 | ø25 mm | 0.00367647 | 3716.85 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3683.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3686.4 | 0.121082 | 25 | 57 | ø25 | 33.7 | 27.2 | TR02.02.0082 | 0082 | no | GS_NTL vnitřní 3
12776984 | 1.NP_SO-101 | 1129.22 | 0.000891835 | 0.119553 | ø25 mm | 0.00367647 | 3716.85 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3683.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3686.4 | 0.088689 | 25 | 61 | ø25 | 33.7 | 27.2 | TR02.02.0083 | 0083 | no | GS_NTL vnitřní 3
12776992 | 1.NP_SO-101 | 3509.61 | 0.00141175 | 0.467492 | ø32 mm | 0.00278552 | 3721.2 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3678.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3682.05 | 0.352824 | 32 | 136 | ø32 | 42.4 | 35.9 | TR02.02.0084 | 0084 | no | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12779389 | 1.NP_SO-101 | 497.782 | 0.000891835 | 0.052701 | ø25 mm | 0.00367647 | 3716.85 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3683.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3686.4 | 0.0390957 | 25 | 48 | ø25 | 33.7 | 27.2 | TR02.02.0085 | 0085 | no | GS_NTL vnitřní 3
12779472 | 1.NP_SO-101 | 1541.67 | 0.000891835 | 0.163219 | ø25 mm | 0.00367647 | 3716.85 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3683.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3686.4 | 0.121082 | 25 | 62 | ø25 | 33.7 | 27.2 | TR02.02.0086 | 0086 | no | GS_NTL vnitřní 3
12779493 | 2.NP_SO-101 | 54.7023 | 0.00141175 | 0.00728654 | ø32 mm | 0.00278552 | 521.2 | 500 | 500 | 2.NP_SO-101 | 0 | 478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4482.05 | 0.00549928 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0087 | 0087 | no | GS_NTL vnitřní 3
12779495 | 1.NP_SO-101 | 1052.37 | 0.00141175 | 0.14018 | ø32 mm | 0.00278552 | 4476.19 | 4476.19 | 3423.81 | 1.NP_SO-101 |  | 3423.81 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3423.81 | 0.105796 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0088 | 0088 | no | GS_NTL vnitřní 3
12779499 | 1.NP_SO-101 | 1040.47 | 0.00141175 | 0.138594 | ø32 mm | 0.00278552 | 4464.28 | 3423.81 | 4464.28 | 1.NP_SO-101 |  | 3423.81 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3423.81 | 0.104599 | 32 | 143 | ø32 | 42.4 | 35.9 | TR02.02.0089 | 0089 | no | GS_NTL vnitřní 3
12779503 | 2.NP_SO-101 | 347.668 | 0.000356274 | 0.0232645 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0163835 | 15 | 81 | ø15 | 21.3 | 16 | TR02.02.0090 | 0090 | no | GS_NTL vnitřní 3
12779505 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 81 | ø15 | 21.3 | 16 | TR02.02.0091 | 0091 | no | GS_NTL vnitřní 3
12779507 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.713 | 985.713 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 81 | ø15 | 21.3 | 16 | TR02.02.0092 | 0092 | no | GS_NTL vnitřní 3
12779509 | 2.NP_SO-101 | 1789.64 | 0.000356274 | 0.119755 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0843348 | 15 | 108 | ø15 | 21.3 | 16 | TR02.02.0093 | 0093 | no | GS_NTL vnitřní 3
12779511 | 1.NP_SO-101 | 1058.72 | 0.000891835 | 0.112089 | ø25 mm | 0.00367647 | 4479.36 | 4479.36 | 3420.64 | 1.NP_SO-101 |  | 3420.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3420.64 | 0.0831521 | 25 | 83 | ø25 | 33.7 | 27.2 | TR02.02.0094 | 0094 | no | GS_NTL vnitřní 3
12779515 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 108 | ø15 | 21.3 | 16 | TR02.02.0095 | 0095 | no | GS_NTL vnitřní 3
12779517 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 108 | ø15 | 21.3 | 16 | TR02.02.0096 | 0096 | no | GS_NTL vnitřní 3
12779523 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 110 | ø15 | 21.3 | 16 | TR02.02.0097 | 0097 | no | GS_NTL vnitřní 3
12779525 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 110 | ø15 | 21.3 | 16 | TR02.02.0098 | 0098 | no | GS_NTL vnitřní 3
12779528 | 2.NP_SO-101 | 1883.4 | 0.000891835 | 0.199399 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.147922 | 25 | 106 | ø25 | 33.7 | 27.2 | TR02.02.0099 | 0099 | no | GS_NTL vnitřní 3
12779533 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 112 | ø15 | 21.3 | 16 | TR02.02.0100 | 0100 | no | GS_NTL vnitřní 3
12779535 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 112 | ø15 | 21.3 | 16 | TR02.02.0101 | 0101 | no | GS_NTL vnitřní 3
12779538 | 2.NP_SO-101 | 1514.61 | 0.000891835 | 0.160354 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.118957 | 25 | 83 | ø25 | 33.7 | 27.2 | TR02.02.0102 | 0102 | no | GS_NTL vnitřní 3
12779551 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 91 | ø15 | 21.3 | 16 | TR02.02.0103 | 0103 | no | GS_NTL vnitřní 3
12779553 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 95 | ø15 | 21.3 | 16 | TR02.02.0104 | 0104 | no | GS_NTL vnitřní 3
12779555 | 2.NP_SO-101 | 120.746 | 0.000356274 | 0.00807982 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00569002 | 15 | 89 | ø15 | 21.3 | 16 | TR02.02.0105 | 0105 | no | GS_NTL vnitřní 3
12779559 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 89 | ø15 | 21.3 | 16 | TR02.02.0106 | 0106 | no | GS_NTL vnitřní 3
12779561 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 89 | ø15 | 21.3 | 16 | TR02.02.0107 | 0107 | no | GS_NTL vnitřní 3
12779567 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 93 | ø15 | 21.3 | 16 | TR02.02.0108 | 0108 | no | GS_NTL vnitřní 3
12779571 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 93 | ø15 | 21.3 | 16 | TR02.02.0109 | 0109 | no | GS_NTL vnitřní 3
12779573 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 93 | ø15 | 21.3 | 16 | TR02.02.0110 | 0110 | no | GS_NTL vnitřní 3
12779579 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 91 | ø15 | 21.3 | 16 | TR02.02.0111 | 0111 | no | GS_NTL vnitřní 3
12779581 | 2.NP_SO-101 | 1487.93 | 0.000356274 | 0.0995663 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0701171 | 15 | 89 | ø15 | 21.3 | 16 | TR02.02.0112 | 0112 | no | GS_NTL vnitřní 3
12779583 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 91 | ø15 | 21.3 | 16 | TR02.02.0113 | 0113 | no | GS_NTL vnitřní 3
12779590 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 87 | ø25 | 33.7 | 27.2 | TR02.02.0114 | 0114 | no | GS_NTL vnitřní 3
12779593 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 95 | ø15 | 21.3 | 16 | TR02.02.0115 | 0115 | no | GS_NTL vnitřní 3
12779595 | 2.NP_SO-101 | 1582.56 | 0.000891835 | 0.167549 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.124294 | 25 | 86 | ø25 | 33.7 | 27.2 | TR02.02.0116 | 0116 | no | GS_NTL vnitřní 3
12779597 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 95 | ø15 | 21.3 | 16 | TR02.02.0117 | 0117 | no | GS_NTL vnitřní 3
12779607 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 122 | ø15 | 21.3 | 16 | TR02.02.0118 | 0118 | no | GS_NTL vnitřní 3
12779609 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 126 | ø15 | 21.3 | 16 | TR02.02.0119 | 0119 | no | GS_NTL vnitřní 3
12779611 | 2.NP_SO-101 | 120.746 | 0.000356274 | 0.00807982 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00569002 | 15 | 120 | ø15 | 21.3 | 16 | TR02.02.0120 | 0120 | no | GS_NTL vnitřní 3
12779615 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 120 | ø15 | 21.3 | 16 | TR02.02.0121 | 0121 | no | GS_NTL vnitřní 3
12779617 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 120 | ø15 | 21.3 | 16 | TR02.02.0122 | 0122 | no | GS_NTL vnitřní 3
12779623 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 124 | ø15 | 21.3 | 16 | TR02.02.0123 | 0123 | no | GS_NTL vnitřní 3
12779627 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 124 | ø15 | 21.3 | 16 | TR02.02.0124 | 0124 | no | GS_NTL vnitřní 3
12779629 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 124 | ø15 | 21.3 | 16 | TR02.02.0125 | 0125 | no | GS_NTL vnitřní 3
12779635 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 122 | ø15 | 21.3 | 16 | TR02.02.0126 | 0126 | no | GS_NTL vnitřní 3
12779637 | 2.NP_SO-101 | 1537.93 | 0.000356274 | 0.102912 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0724733 | 15 | 120 | ø15 | 21.3 | 16 | TR02.02.0127 | 0127 | no | GS_NTL vnitřní 3
12779639 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 122 | ø15 | 21.3 | 16 | TR02.02.0128 | 0128 | no | GS_NTL vnitřní 3
12779646 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 118 | ø25 | 33.7 | 27.2 | TR02.02.0129 | 0129 | no | GS_NTL vnitřní 3
12779649 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 126 | ø15 | 21.3 | 16 | TR02.02.0130 | 0130 | no | GS_NTL vnitřní 3
12779651 | 2.NP_SO-101 | 1502.56 | 0.000891835 | 0.159079 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.118011 | 25 | 117 | ø25 | 33.7 | 27.2 | TR02.02.0131 | 0131 | no | GS_NTL vnitřní 3
12779653 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 126 | ø15 | 21.3 | 16 | TR02.02.0132 | 0132 | no | GS_NTL vnitřní 3
12779661 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 130 | ø15 | 21.3 | 16 | TR02.02.0133 | 0133 | no | GS_NTL vnitřní 3
12779663 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 128 | ø15 | 21.3 | 16 | TR02.02.0134 | 0134 | no | GS_NTL vnitřní 3
12779667 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 128 | ø15 | 21.3 | 16 | TR02.02.0135 | 0135 | no | GS_NTL vnitřní 3
12779669 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 128 | ø15 | 21.3 | 16 | TR02.02.0136 | 0136 | no | GS_NTL vnitřní 3
12779675 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 116 | ø25 | 33.7 | 27.2 | TR02.02.0137 | 0137 | no | GS_NTL vnitřní 3
12779677 | 2.NP_SO-101 | 51.5812 | 0.000356274 | 0.00345161 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.00243071 | 15 | 130 | ø15 | 21.3 | 16 | TR02.02.0138 | 0138 | no | GS_NTL vnitřní 3
12779679 | 2.NP_SO-101 | 1472.56 | 0.000891835 | 0.155903 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.115655 | 25 | 115 | ø25 | 33.7 | 27.2 | TR02.02.0139 | 0139 | no | GS_NTL vnitřní 3
12779681 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 514.287 | 985.712 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 130 | ø15 | 21.3 | 16 | TR02.02.0140 | 0140 | no | GS_NTL vnitřní 3
12779689 | 2.NP_SO-101 | 54.3625 | 0.000891835 | 0.00575545 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.00426962 | 25 | 114 | ø25 | 33.7 | 27.2 | TR02.02.0141 | 0141 | no | GS_NTL vnitřní 3
12779691 | 1.NP_SO-101 | 1058.72 | 0.000891835 | 0.112089 | ø25 mm | 0.00367647 | 4479.36 | 3420.64 | 4479.36 | 1.NP_SO-101 |  | 3420.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3420.64 | 0.0831521 | 25 | 114 | ø25 | 33.7 | 27.2 | TR02.02.0142 | 0142 | no | GS_NTL vnitřní 3
12779872 | 2.NP_SO-101 | 100.902 | 0.000356274 | 0.00675196 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0047549 | 15 | 97 | ø15 | 21.3 | 16 | TR02.02.0143 | 0143 | no | GS_NTL vnitřní 3
12779874 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 97 | ø15 | 21.3 | 16 | TR02.02.0144 | 0144 | no | GS_NTL vnitřní 3
12779876 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 97 | ø15 | 21.3 | 16 | TR02.02.0145 | 0145 | no | GS_NTL vnitřní 3
12779903 | 2.NP_SO-101 | 1533.06 | 0.000891835 | 0.162308 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.120407 | 25 | 84 | ø25 | 33.7 | 27.2 | TR02.02.0146 | 0146 | no | GS_NTL vnitřní 3
12779911 | 2.NP_SO-101 | 272.324 | 0.000891835 | 0.0288314 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0213883 | 25 | 85 | ø25 | 33.7 | 27.2 | TR02.02.0147 | 0147 | no | GS_NTL vnitřní 3
12779972 | 2.NP_SO-101 | 1789.64 | 0.000356274 | 0.119755 | ø15 mm | 0.00625 | 510.65 | 500 | 500 | 2.NP_SO-101 | 0 | 489.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4492 | 0.0843348 | 15 | 101 | ø15 | 21.3 | 16 | TR02.02.0148 | 0148 | no | GS_NTL vnitřní 3
12779974 | 1.NP_SO-101 | 1058.72 | 0.000891835 | 0.112089 | ø25 mm | 0.00367647 | 4479.36 | 4479.36 | 3420.64 | 1.NP_SO-101 |  | 3420.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3420.64 | 0.0831521 | 25 | 98 | ø25 | 33.7 | 27.2 | TR02.02.0149 | 0149 | no | GS_NTL vnitřní 3
12779978 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 101 | ø15 | 21.3 | 16 | TR02.02.0150 | 0150 | no | GS_NTL vnitřní 3
12779980 | 2.NP_SO-101 | 471.425 | 0.000356274 | 0.0315458 | ø15 mm | 0.00625 | 985.712 | 985.712 | 514.287 | 2.NP_SO-101 |  | 514.287 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4514.29 | 0.0222154 | 15 | 101 | ø15 | 21.3 | 16 | TR02.02.0151 | 0151 | no | GS_NTL vnitřní 3
12779986 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 103 | ø15 | 21.3 | 16 | TR02.02.0152 | 0152 | no | GS_NTL vnitřní 3
12779988 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 103 | ø15 | 21.3 | 16 | TR02.02.0153 | 0153 | no | GS_NTL vnitřní 3
12779991 | 2.NP_SO-101 | 1883.4 | 0.000891835 | 0.199399 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.147922 | 25 | 99 | ø25 | 33.7 | 27.2 | TR02.02.0154 | 0154 | no | GS_NTL vnitřní 3
12779996 | 2.NP_SO-101 | 297.713 | 0.000356274 | 0.0199217 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.0140294 | 15 | 105 | ø15 | 21.3 | 16 | TR02.02.0155 | 0155 | no | GS_NTL vnitřní 3
12779998 | 2.NP_SO-101 | 451.581 | 0.000356274 | 0.030218 | ø15 mm | 0.00625 | 985.712 | 985.712 | 534.131 | 2.NP_SO-101 |  | 534.131 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4534.13 | 0.0212803 | 15 | 105 | ø15 | 21.3 | 16 | TR02.02.0156 | 0156 | no | GS_NTL vnitřní 3
12780001 | 2.NP_SO-101 | 1539.97 | 0.000891835 | 0.163039 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.120949 | 25 | 98 | ø25 | 33.7 | 27.2 | TR02.02.0157 | 0157 | no | GS_NTL vnitřní 3
12780150 | 1.NP_SO-101 | 11499.1 | 0.00141175 | 1.53172 | ø32 mm | 0.00278552 | 3421.2 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3378.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3382.05 | 1.15602 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0158 | 0158 |  | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12780211 | 2.NP_SO-101 | 2052.38 | 0.00141175 | 0.273384 | ø32 mm | 0.00278552 | 1476.19 | -576.188 | 1476.19 | 2.NP_SO-101 |  | -576.188 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3423.81 | 0.206327 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0159 | 0159 |  | GS_NTL vnitřní 3
12780248 | 1.NP_SO-101 | 2103.98 | 0.00141175 | 0.280257 | ø32 mm | 0.00278552 | 3421.2 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3378.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3382.05 | 0.211515 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0160 | 0160 | no | GS_NTL vnitřní 3
12780395 | 1.NP_SO-101 | 2047.24 | 0.000891835 | 0.216744 | ø25 mm | 0.00367647 | 3416.85 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3383.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3386.4 | 0.16079 | 25 | 84 | ø25 | 33.7 | 27.2 | TR02.02.0161 | 0161 | no | GS_NTL vnitřní 3
12780408 | 1.NP_SO-101 | 1058.72 | 0.000891835 | 0.112089 | ø25 mm | 0.00367647 | 4479.36 | 3420.64 | 4479.36 | 1.NP_SO-101 |  | 3420.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3420.64 | 0.0831521 | 25 | 84 | ø25 | 33.7 | 27.2 | TR02.02.0162 | 0162 | no | GS_NTL vnitřní 3
12780476 | 1.NP_SO-101 | 6971.39 | 0.000891835 | 0.738072 | ø25 mm | 0.00367647 | 3416.85 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3383.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3386.4 | 0.547531 | 25 | 113 | ø25 | 33.7 | 27.2 | TR02.02.0163 | 0163 | no | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12780484 | 1.NP_SO-101 | 734.293 | 0.00141175 | 0.0978104 | ø32 mm | 0.00278552 | 3421.2 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3378.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3382.05 | 0.0738192 | 32 | 143 | ø32 | 42.4 | 35.9 | TR02.02.0164 | 0164 | no | GS_NTL vnitřní 3
12780514 | 1.NP_SO-101 | 562.213 | 0.000891835 | 0.0595224 | ø25 mm | 0.00367647 | 3416.85 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3383.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3386.4 | 0.0441561 | 25 | 98 | ø25 | 33.7 | 27.2 | TR02.02.0165 | 0165 | no | GS_NTL vnitřní 3
12780544 | 1.NP_SO-101 | 562.213 | 0.000891835 | 0.0595224 | ø25 mm | 0.00367647 | 3416.85 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3383.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3386.4 | 0.0441561 | 25 | 83 | ø25 | 33.7 | 27.2 | TR02.02.0166 | 0166 | no | GS_NTL vnitřní 3
12780624 | 1.NP_SO-101 | 2047.24 | 0.000891835 | 0.216744 | ø25 mm | 0.00367647 | 3416.85 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3383.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3386.4 | 0.16079 | 25 | 114 | ø25 | 33.7 | 27.2 | TR02.02.0167 | 0167 | no | GS_NTL vnitřní 3
12781911 | 2.NP_SO-101 | 44.9796 | 0.00141175 | 0.00599144 | ø32 mm | 0.00278552 | 521.2 | 500 | 500 | 2.NP_SO-101 | 0 | 478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4482.05 | 0.00452184 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0168 | 0168 | no | GS_NTL vnitřní 3
12781972 | 2.NP_SO-101 | 65.7664 | 0.00141175 | 0.00876032 | ø32 mm | 0.00278552 | 521.2 | 500 | 500 | 2.NP_SO-101 | 0 | 478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4482.05 | 0.00661156 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0169 | 0169 | no | GS_NTL vnitřní 3
12782012 | 2.NP_SO-101 | 2096.03 | 0.00141175 | 0.279198 | ø32 mm | 0.00278552 | 1476.19 | -619.838 | 1476.19 | 2.NP_SO-101 |  | -619.838 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3380.16 | 0.210715 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0170 | 0170 | no | GS_NTL vnitřní 3
12784193 | -1.PP_SO-101 | 1164.44 | 0.000356274 | 0.0779192 | ø15 mm | 0.00625 | 2510.65 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2489.35 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | -658 | 0.0548727 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0171 | 0171 | no | GS_Odvětrání plynovodu 1 (6) (2)
12784208 | -1.PP_SO-101 | 1611.56 | 0.000356274 | 0.107839 | ø15 mm | 0.00625 | 2485.71 | 874.157 | 2485.71 | -1.PP_SO-101 |  | 874.157 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | -2275.84 | 0.0759428 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0172 | 0172 | no | GS_NTL vnitřní 3; GS_Odvětrání plynovodu 1 (6) (2)
12786245 | 3.NP_SO-101 | 1430.87 | 0.000356274 | 0.095748 | ø15 mm | 0.00625 | 1898.68 | 467.807 | 1898.68 | 3.NP_SO-101 |  | 467.807 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 8467.81 | 0.0674281 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0173 | 0173 | no | GS_Odvětrání plynovodu 1 (6) (2)
12786270 | 3.NP_SO-101 | 171.425 | 0.000356274 | 0.0114711 | ø15 mm | 0.00625 | 1898.68 | 1727.25 | 1898.68 | 3.NP_SO-101 |  | 1727.25 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 9727.25 | 0.00807821 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0174 | 0174 | no | GS_Odvětrání plynovodu 1 (6) (2)
12787030 | -1.PP_SO-101 | 5644.01 | 0.000356274 | 0.377674 | ø15 mm | 0.00625 | 2510.65 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2489.35 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | -658 | 0.265968 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0175 | 0175 | no | GS_Odvětrání plynovodu 1 (6) (2) | Identifikační data - Komentáře: ODVZUŠNĚNÍ PLYNOVODU NAD STŘECHU
12787216 | -1.PP_SO-101 | 7505.67 | 0.000356274 | 0.502249 | ø15 mm | 0.00625 | 10020 | 10020 | 2514.29 | -1.PP_SO-101 |  | 2514.29 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | -635.712 | 0.353697 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0176 | 0176 | no | GS_Odvětrání plynovodu 1 (6) (2) | Identifikační data - Komentáře: ODVZUŠNĚNÍ PLYNOVODU NAD STŘECHU
12787292 | 3.NP_SO-101 | 730.946 | 0.000356274 | 0.0489119 | ø15 mm | 0.00625 | -370.518 | -370.518 | -1101.46 | 3.NP_SO-101 |  | -1101.46 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 6898.54 | 0.034445 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0177 | 0177 | no | GS_Odvětrání plynovodu 1 (6) (2) | Identifikační data - Komentáře: ODVZUŠNĚNÍ PLYNOVODU NAD STŘECHU
12787353 | 3.NP_SO-101 | 134.278 | 0.000356274 | 0.00898536 | ø15 mm | 0.00625 | -1105.1 | -1115.75 | -1115.75 | 3.NP_SO-101 | 0 | -1126.4 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 6876.25 | 0.00632772 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0178 | 0178 | no | GS_Odvětrání plynovodu 1 (6) (2)
12787383 | 3.NP_SO-101 | 1689.52 | 0.000356274 | 0.113056 | ø15 mm | 0.00625 | -345.581 | -356.231 | -356.231 | 3.NP_SO-101 | 0 | -366.881 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7635.77 | 0.0796167 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0179 | 0179 | no | GS_Odvětrání plynovodu 1 (6) (2)
12787555 | 3.NP_SO-101 | 2350.75 | 0.000356274 | 0.157302 | ø15 mm | 0.00625 | 458.641 | -355.369 | 448.633 | 3.NP_SO-101 | 36.397 | -365.377 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7637.11 | 0.110776 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0180 | 0180 | no | GS_Odvětrání plynovodu 1 (6) (2)
12787688 | 3.NP_SO-101 | 163.882 | 0.000356274 | 0.0109663 | ø15 mm | 0.00625 | 1923.61 | 1912.96 | 1912.96 | 3.NP_SO-101 | 0 | 1902.31 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 9904.96 | 0.00772276 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0181 | 0181 | no | GS_Odvětrání plynovodu 1 (6) (2) | Identifikační data - Komentáře: ODVZUŠNĚNÍ PLYNOVODU
12787772 | -1.PP_SO-101 | 59.3088 | 0.000356274 | 0.0039687 | ø15 mm | 0.00625 | 818.157 | 818.157 | 758.848 | -1.PP_SO-101 |  | 758.848 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -2391.15 | 0.00279486 | 15 | 172 | ø15 | 21.3 | 16 | TR02.02.0182 | 0182 | no | GS_NTL vnitřní 3
12788112 | -1.PP_SO-101 | 134.962 | 0.00285535 | 0.025567 | ø50 mm | 0.00188679 | 530.15 | 500 | 500 | -1.PP_SO-101 | 0 | 469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -2676.5 | 0.0211998 | 50 | 163 | ø50 | 60.3 | 53 | TR02.02.0183 | 0183 | no | GS_NTL vnitřní 3
12788278 | -1.PP_SO-101 | 1837.59 | 0.00285535 | 0.348109 | ø50 mm | 0.00188679 | 2530.15 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -676.5 | 0.288648 | 50 | 232 | ø50 | 60.3 | 53 | TR02.02.0184 | 0184 | yes | GS_NTL vnitřní 3
12790459 | -1.PP_SO-101 | 192.728 | 0.00285535 | 0.03651 | ø50 mm | 0.00188679 | 2530.15 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -676.5 | 0.0302737 | 50 | 170 | ø50 | 60.3 | 53 | TR02.02.0185 | 0185 | yes | GS_NTL vnitřní 3
12791971 | -1.PP_SO-101 | 149.667 | 0.000356274 | 0.0100151 | ø15 mm | 0.00625 | 702.848 | 702.848 | 553.181 | -1.PP_SO-101 |  | 553.181 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -2596.82 | 0.00705288 | 15 | 172 | ø15 | 21.3 | 16 | TR02.02.0186 | 0186 | no | GS_NTL vnitřní 3
12799361 | 3.NP_SO-101 | 2373.67 | 0.000356274 | 0.158836 | ø15 mm | 0.00625 | 464.17 | 453.52 | 453.52 | 3.NP_SO-101 | 0 | 442.87 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 8445.52 | 0.111856 | 15 | 168 | ø15 | 21.3 | 16 | TR02.02.0202 | 0202 | no | GS_Odvětrání plynovodu 1 (6) (2)
12800303 | -1.PP_SO-101 | 6333.33 | 0.00285535 | 1.19977 | ø50 mm | 0.00188679 | 2530.15 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -676.5 | 0.994836 | 50 | 232 | ø50 | 60.3 | 53 | TR02.02.0207 | 0207 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12800401 | -1.PP_SO-101 | 3926.18 | 0.00285535 | 0.743768 | ø50 mm | 0.00188679 | 6459.52 | 6459.52 | 2533.34 | -1.PP_SO-101 |  | 2533.34 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -616.662 | 0.616723 | 50 | 232 | ø50 | 60.3 | 53 | TR02.02.0208 | 0208 | yes | GS_NTL vnitřní 3
12800734 | 1.NP_SO-101 | 246.15 | 0.00183197 | 0.0373505 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.0309321 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0209 | 0209 | yes | GS_NTL vnitřní 3
12800985 | 2.NP_SO-101 | 25.6855 | 0.00141175 | 0.0034214 | ø32 mm | 0.00278552 | 1521.2 | 1500 | 1500 | 2.NP_SO-101 | 0 | 1478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 5482.05 | 0.00258219 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0210 | 0210 | no | GS_NTL vnitřní 3
12801084 | 2.NP_SO-101 | 1752.37 | 0.00141175 | 0.233423 | ø32 mm | 0 | 1476.19 | -276.187 | 1476.19 | 2.NP_SO-101 |  | -276.188 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3723.81 | 0.176168 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0211 | 0211 | no | GS_NTL vnitřní 3
12801187 | 2.NP_SO-101 | 19.3648 | 0.00141175 | 0.00257947 | ø32 mm | 0.00278552 | 1521.2 | 1500 | 1500 | 2.NP_SO-101 | 0 | 1478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 5482.05 | 0.00194677 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0212 | 0212 | no | GS_NTL vnitřní 3
12801377 | 2.NP_SO-101 | 34.4015 | 0.00141175 | 0.0045824 | ø32 mm | 0.00278552 | 1521.2 | 1500 | 1500 | 2.NP_SO-101 | 0 | 1478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 5482.05 | 0.00345841 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0213 | 0213 |  | GS_NTL vnitřní 3
12801389 | 2.NP_SO-101 | 2002.38 | 0.00141175 | 0.266723 | ø32 mm | 0 | 1476.19 | 1476.19 | -526.188 | 2.NP_SO-101 |  | -526.188 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3473.81 | 0.201301 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0214 | 0214 |  | GS_NTL vnitřní 3
12801478 | 2.NP_SO-101 | 17.9735 | 0.00141175 | 0.00239414 | ø32 mm | 0.00278552 | 1521.2 | 1500 | 1500 | 2.NP_SO-101 | 0 | 1478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 5482.05 | 0.0018069 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0215 | 0215 |  | GS_NTL vnitřní 3
12801763 | 1.NP_SO-101 | 1052.34 | 0.00183197 | 0.159681 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.132241 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0216 | 0216 | yes | GS_NTL vnitřní 3
12801777 | 1.NP_SO-101 | 1761.32 | 0.00183197 | 0.267261 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.221334 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0217 | 0217 | yes | GS_NTL vnitřní 3
12802054 | 1.NP_SO-101 | 1056.19 | 0.00141175 | 0.140688 | ø32 mm | 0.00278552 | 3371.2 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3328.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3332.05 | 0.10618 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0218 | 0218 | yes | GS_NTL vnitřní 3
12802095 | 1.NP_SO-101 | 272.375 | 0.00141175 | 0.0362813 | ø32 mm | 0.00278552 | 3371.2 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3328.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3332.05 | 0.0273821 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0219 | 0219 | yes | GS_NTL vnitřní 3
12802743 | 1.NP_SO-101 | 1109.73 | 0.00141175 | 0.14782 | ø32 mm | 0.00278552 | 3371.2 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3328.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3332.05 | 0.111562 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0220 | 0220 | yes | GS_NTL vnitřní 3
12803201 | 1.NP_SO-101 | 1271.43 | 0.000356274 | 0.0850786 | ø15 mm | 0 | 4985.71 | 3714.29 | 4985.71 | 1.NP_SO-101 |  | 3714.29 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3714.29 | 0.0599145 | 15 | 224 | ø15 | 21.3 | 16 | TR02.02.0221 | 0221 | no | GS_NTL vnitřní 3
12803490 | 2.NP_SO-101 | 197.713 | 0.000356274 | 0.0132301 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00931698 | 15 | 224 | ø15 | 21.3 | 16 | TR02.02.0222 | 0222 | no | GS_NTL vnitřní 3
12804208 | 1.NP_SO-101 | 2535.57 | 0.000356274 | 0.16967 | ø15 mm | 0.00278552 | 3710.65 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3689.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3692 | 0.119486 | 15 | 225 | ø15 | 21.3 | 16 | TR02.02.0223 | 0223 | no | GS_NTL vnitřní 3
12804379 | 1.NP_SO-101 | 1271.43 | 0.000356274 | 0.0850786 | ø15 mm | 0 | 4985.71 | 3714.29 | 4985.71 | 1.NP_SO-101 |  | 3714.29 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3714.29 | 0.0599145 | 15 | 225 | ø15 | 21.3 | 16 | TR02.02.0224 | 0224 | no | GS_NTL vnitřní 3
12804381 | 2.NP_SO-101 | 197.712 | 0.000356274 | 0.0132301 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00931698 | 15 | 225 | ø15 | 21.3 | 16 | TR02.02.0225 | 0225 | no | GS_NTL vnitřní 3
12804532 | 1.NP_SO-101 | 4969.5 | 0.000356274 | 0.332539 | ø15 mm | 0.00625 | 3710.65 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3689.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3692 | 0.234182 | 15 | 224 | ø15 | 21.3 | 16 | TR02.02.0226 | 0226 | no | GS_NTL vnitřní 3
12804789 | 1.NP_SO-101 | 105.657 | 0.000356274 | 0.00707014 | ø15 mm | 0.00278552 | 3460.65 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3439.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3442 | 0.00497897 | 15 | 227 | ø15 | 21.3 | 16 | TR02.02.0227 | 0227 | no | GS_NTL vnitřní 3
12804800 | 1.NP_SO-101 | 7047.87 | 0.00141175 | 0.938801 | ø32 mm | 0.00278552 | 3471.2 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3428.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3432.05 | 0.708529 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0228 | 0228 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12804803 | 1.NP_SO-101 | 1523 | 0.000356274 | 0.101913 | ø15 mm | 0.00278552 | 3460.65 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3439.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3442 | 0.0717697 | 15 | 225 | ø15 | 21.3 | 16 | TR02.02.0229 | 0229 | no | GS_NTL vnitřní 3
12804885 | 1.NP_SO-101 | 284.2 | 0.000356274 | 0.0190175 | ø15 mm | 0.00278552 | 3460.65 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3439.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3442 | 0.0133926 | 15 | 227 | ø15 | 21.3 | 16 | TR02.02.0230 | 0230 | no | GS_NTL vnitřní 3
12804970 | 1.NP_SO-101 | 215.075 | 0.000356274 | 0.0143919 | ø15 mm | 0 | 3685.71 | 3685.71 | 3470.64 | 1.NP_SO-101 |  | 3470.64 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3470.64 | 0.0101352 | 15 | 224 | ø15 | 21.3 | 16 | TR02.02.0231 | 0231 | no | GS_NTL vnitřní 3
12804973 | 1.NP_SO-101 | 287.23 | 0.000356274 | 0.0192203 | ø15 mm | 0.00278552 | 3460.65 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3439.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3442 | 0.0135354 | 15 | 227 | ø15 | 21.3 | 16 | TR02.02.0232 | 0232 | no | GS_NTL vnitřní 3
12805005 | 1.NP_SO-101 | 221.425 | 0.000356274 | 0.0148169 | ø15 mm | 0 | 3685.71 | 3685.71 | 3464.29 | 1.NP_SO-101 |  | 3464.29 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3464.29 | 0.0104344 | 15 | 225 | ø15 | 21.3 | 16 | TR02.02.0233 | 0233 | no | GS_NTL vnitřní 3
12814931 | 1.NP_SO-101 | 326.524 | 0.00141175 | 0.0434942 | ø32 mm | 0.00278552 | 3421.2 | 3400 | 3400 | 1.NP_SO-101 | 0 | 3378.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3382.05 | 0.0328258 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0234 | 0234 |  | GS_NTL vnitřní 3
12816749 | 1.NP_SO-101 | 52.375 | 0.00141175 | 0.00697653 | ø32 mm | 0 | 3426.19 | 3426.19 | 3373.81 | 1.NP_SO-101 |  | 3373.81 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3373.81 | 0.00526531 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0235 | 0235 | yes | GS_NTL vnitřní 3

# IfcValve: Bezpečnostní uzávěr BAP:DN32, Bezpečnostní uzávěr BAP:DN32:12772258
In: 1.NP_SO-101
Type - Material: Color RGB 045-045-045, Color RGB 140-140-140, Color RGB 168-128-048
Type - Elektroinstalace – zatížení - Voltage: 230 V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Pressure Stage: 0 mm
Type - Materiály a povrchové úpravy - Black: Color RGB 045-045-045; Grey: Color RGB 140-140-140; Yellow: Color RGB 168-128-048
Type - Kóty - Jmenovitá velikost vstupu: 32 mm; Jmenovitá velikost výstupu: 32 mm; Use Nominal Diameter: yes
Type - Identifikační data - Article Description: Generic valve; Article Type: Generic Valve; Číslo OmniClass: 23.65.55.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; EMCS Version: 3.0; ETIM Article Class: EC010120; Family Version: 11.14; ID kategorie: BAP G1 1/4"; Kód sestavy: VE25; Komentáře k typům: DN40; MEPcontent Class: VALVE; Model: Generic Valve; Nadpis OmniClass: Valves for Liquid Services; Název typu: DN32; Označení typu: 01; Popis: Generic valve; Popis sestavy: Automatický bezpečnostní uzávěr; Revit Version: 2018; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Bezpečnostní uzávěr BAP
Classification: VE25 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Elektroinstalace – zatížení - Power: 0 W
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Actual Offset: 10 mm; Negative Offset: 10 mm; Podlaží: 1.NP_SO-101; Výška od podlaží: 3350 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Flow 1: 0 m3/s; Flow 2: 0 m3/s; Klasifikace systému: Ostatní,Napájení; Název systému: GS_NTL vnitřní 3
Elektrotechnika - Phase: 1
Grafika - Annotation Offset: 0 mm; Použít měřítko poznámky: no
Kóty - Depth: 77 mm; Diameter: 40 mm; Height: 192 mm; Length: 156 mm; Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.0017913 m3; Velikost: ø40-ø40
Identifikační data - Kód prvku: VE25.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Control Depth: 69 mm; Control Radius: 34.5 mm; Flange Length: 98 mm; Id typu: 12782947; M: 131 mm; Outer Diameter: 60.3 mm; Outer Radius: 30.15 mm; Radius: 46 mm; Rodina: Bezpečnostní uzávěr BAP; Rodina a typ: Bezpečnostní uzávěr BAP: DN32; Typ: DN32

# IfcValve: Bezpečnostní uzávěr BAP:DN40, Bezpečnostní uzávěr BAP:DN40:12772304
In: -1.PP_SO-101
Type - Material: Color RGB 045-045-045, Color RGB 140-140-140, Color RGB 168-128-048
Type - Elektroinstalace – zatížení - Voltage: 230 V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Pressure Stage: 0 mm
Type - Materiály a povrchové úpravy - Black: Color RGB 045-045-045; Grey: Color RGB 140-140-140; Yellow: Color RGB 168-128-048
Type - Kóty - Use Nominal Diameter: yes; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm
Type - Identifikační data - Custom: no; Article Description: Generic valve; Article Type: Generic Valve; Číslo OmniClass: 23.65.55.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; EMCS Version: 3.0; ETIM Article Class: EC010120; Family Version: 11.14; ID kategorie: BAP G1 1/2"; Kód sestavy: VE25; Komentáře k typům: DN40; MEPcontent Class: VALVE; Model: Generic Valve; Nadpis OmniClass: Valves for Liquid Services; Název typu: DN40; Označení typu: 02; Popis: Generic valve; Popis sestavy: Automatický bezpečnostní uzávěr; Revit Version: 2018; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Bezpečnostní uzávěr BAP
Classification: VE25 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Elektroinstalace – zatížení - Power: 0 W
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Actual Offset: 10 mm; Negative Offset: 10 mm; Podlaží: -1.PP_SO-101; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Flow 1: 0 m3/s; Flow 2: 0 m3/s; Klasifikace systému: Ostatní,Napájení; Název systému: GS_NTL vnitřní 3
Elektrotechnika - Phase: 1
Grafika - Annotation Offset: 0 mm; Použít měřítko poznámky: no
Kóty - Depth: 77 mm; Diameter: 50 mm; Height: 192 mm; Length: 156 mm; Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.0017913 m3; Velikost: ø50-ø50
Identifikační data - Kód prvku: VE25.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Rodina: Bezpečnostní uzávěr BAP; Control Depth: 69 mm; Control Radius: 34.5 mm; Flange Length: 98 mm; Id typu: 12772219; M: 131 mm; Outer Diameter: 60.3 mm; Outer Radius: 30.15 mm; Radius: 46 mm; Rodina a typ: Bezpečnostní uzávěr BAP: DN40; Typ: DN40

# IfcValve: Stabilizační regulátor:DN 32, Stabilizační regulátor:DN 32:12774505
In: 1.NP_SO-101
Type - Material: Metal - Caleffi - Alluminium
Type - Mechanické – zatížení - Maximum Inlet Pressure: 50000 Pa
Type - Vazby - Výchozí výška: 0 mm; Body Radius: 45.5 mm; Connection Lenght: 290 mm; Connection Radius: 37.5 mm; Flange Radius: 92.5 mm; Flange Thickness: 22 mm
