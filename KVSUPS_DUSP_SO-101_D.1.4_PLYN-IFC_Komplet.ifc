Properties of the parts of a building model (IFC4), part 9 of 9

# IfcValve: Stabilizační regulátor:DN 32, Stabilizační regulátor:DN 32:12774505
Type - Mechanické - Maximum Working Temperature: 60 C; Minimum Working Temperature: -15 C
Type - Konstrukce - Mass: 13.6 kg
Type - Domovní instalace - Application Fluids: Gas; Connection Size: DN 32; Connection Type: Flanged; Nominal Diameter: 40 mm; Nominal Radius: 20 mm
Type - Materiály a povrchové úpravy - Grey: Metal - Caleffi - Alluminium
Type - Kóty - Jmenovitá velikost vstupu: 32 mm; Jmenovitá velikost výstupu: 32 mm; Overall Height: 471 mm; Overall Lenght: 290 mm; Overall Width: 330 mm
Type - Identifikační data - Custom: no; Article Description: Gas pressure closing filter regulator, double diaphragm. Flanged connection; Certification: CE; Číslo OmniClass: 23.27.57.00; Copyright: ©Caleffi Italy; Family Version: 01.00; GLN: 8016615000009; GTIN: 8016615041811; ID kategorie: SR G1 1/4"; Kód sestavy: VE06; Manufacturer Art. No.: 850060; Manufacturer URL: http://www.caleffi.com/international/en-int; Model: DN 65; Název typu: DN 32; Označení typu: 04; Popis: Gas pressure closing filter regulator, double diaphragm. Flanged connection; Popis sestavy: Regulační; Product Page URL: https://www.caleffi.com/international/en-int/catalogue/gas-pressure-closing-filter-regulator-double-diaphragm-flanged-connection-850060; Revit Version: 2015; Series: 850; Výrobce: Caleffi Italy
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Stabilizační regulátor
Classification: VE06 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Mechanické – tok - Flow: 0 m3/s; Tlaková ztráta: 0 Pa
Mechanické – zatížení - Pressure Drop: 0 Pa
Text - CCI Funkční systém: E; CCI Komponenta: KHA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101; Actual Offset: 10 mm; Negative Offset: 10 mm; Výška od podlaží: 3350 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no; Annotation Offset RL: 0 mm
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.0148267 m3; Velikost: ø40-ø40
Identifikační data - Kód prvku: VE06.04.0004; Označení: 0004
Jiné - Páteřní trasa: yes; Rodina: Stabilizační regulátor; Id typu: 12782901; Rodina a typ: Stabilizační regulátor: DN 32; Typ: DN 32

# IfcValve: Stabilizační regulátor:DN 40, Stabilizační regulátor:DN 40:12774197
In: -1.PP_SO-101
Type - Material: Metal - Caleffi - Alluminium
Type - Mechanické – zatížení - Maximum Inlet Pressure: 50000 Pa
Type - Vazby - Výchozí výška: 0 mm; Body Radius: 45.5 mm; Connection Lenght: 290 mm; Connection Radius: 37.5 mm; Flange Radius: 92.5 mm; Flange Thickness: 22 mm
Type - Mechanické - Maximum Working Temperature: 60 C; Minimum Working Temperature: -15 C
Type - Konstrukce - Mass: 13.6 kg
Type - Domovní instalace - Application Fluids: Gas; Connection Size: DN 40; Connection Type: Flanged; Nominal Diameter: 40 mm; Nominal Radius: 20 mm
Type - Materiály a povrchové úpravy - Grey: Metal - Caleffi - Alluminium
Type - Kóty - Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; Overall Height: 471 mm; Overall Lenght: 290 mm; Overall Width: 330 mm
Type - Identifikační data - Custom: no; Article Description: Gas pressure closing filter regulator, double diaphragm. Flanged connection; Certification: CE; Číslo OmniClass: 23.27.57.00; Copyright: ©Caleffi Italy; Family Version: 01.00; GLN: 8016615000009; GTIN: 8016615041811; ID kategorie: SR G 1 1/2"; Kód sestavy: VE06; Manufacturer Art. No.: 850060; Manufacturer URL: http://www.caleffi.com/international/en-int; Model: DN 65; Název typu: DN 40; Označení typu: 03; Popis: Gas pressure closing filter regulator, double diaphragm. Flanged connection; Popis sestavy: Regulační; Product Page URL: https://www.caleffi.com/international/en-int/catalogue/gas-pressure-closing-filter-regulator-double-diaphragm-flanged-connection-850060; Revit Version: 2015; Series: 850; Výrobce: Caleffi Italy
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Stabilizační regulátor
Classification: VE06 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Mechanické – tok - Flow: 0 m3/s; Tlaková ztráta: 0 Pa
Mechanické – zatížení - Pressure Drop: 0 Pa
Text - CCI Funkční systém: E; CCI Komponenta: KHA; CCI Technický systém: HA
Vazby - Podlaží: -1.PP_SO-101; Actual Offset: 10 mm; Negative Offset: 10 mm; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no; Annotation Offset RL: 0 mm
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.0148267 m3; Velikost: ø40-ø40
Identifikační data - Kód prvku: VE06.03.0003; Označení: 0003
Jiné - Páteřní trasa: yes; Id typu: 12774174; Rodina: Stabilizační regulátor; Rodina a typ: Stabilizační regulátor: DN 40; Typ: DN 40

# IfcValve: Závitový_G_Ventil kulový.CC:DN 15 (3)
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 56 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G 1/2"; Kód sestavy: VE01; Komentáře k typům: kulový; Model: DN 15; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 15; Označení typu: 08; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 28 mm; DD: 56 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000739804 m3; Průměr připojení: 15 mm; Velikost: ø15-ø15
Identifikační data - Popis: G_Ventil
Jiné - Angle3: 30 deg; Rodina: Závitový_G_Ventil kulový.CC; A: 15 mm; Angle1: 20 deg; Angle2: 22.5 deg; B: 17 mm; B2: 28.494 mm; Ch: 25 mm; CW: 27 mm; D: 43 mm; D1: 32.4246 mm; D2: 13.6 mm; D3: 18.6 mm; D4: 26.325 mm; E: 86 mm; Id typu: 12781877; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 15; Typ: DN 15
Name (Závitový_G_Ventil kulový.CC:DN 15:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení | Páteřní trasa | Group
12787753 | -1.PP_SO-101 | -1.PP_SO-101 | 758.848 | VE01.08.0042 | 0042 | no | GS_NTL vnitřní 3
12787770 | -1.PP_SO-101 | -1.PP_SO-101 | 874.157 | VE01.08.0043 | 0043 | no | GS_NTL vnitřní 3; GS_Odvětrání plynovodu 1 (6) (2) | Mechanické – tok - Tlaková ztráta: 0 Pa
12804883 | 1.NP_SO-101 | 1.NP_SO-101 | 3450 | VE01.08.0053 | 0053 |  | GS_NTL vnitřní 3

# IfcValve: Závitový_G_Ventil kulový.CC:DN 25 (4)
In: 2.NP_SO-101
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 80 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G1"; Kód sestavy: VE01; Komentáře k typům: kulový; Model: DN 25; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 25; Označení typu: 06; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 40 mm; DD: 80 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 2.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Objem: 0.000144309 m3
Identifikační data - Popis: G_Ventil
Jiné - A: 25 mm; Angle1: 20 deg; Angle2: 22.5 deg; Angle3: 30 deg; B: 22 mm; B2: 33.7706 mm; Ch: 38 mm; CW: 32 mm; D: 58 mm; D1: 37.8366 mm; D2: 16.6 mm; D3: 21.6 mm; D4: 31.2 mm; E: 112 mm; Id typu: 12781873; Rodina: Závitový_G_Ventil kulový.CC; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 25; Typ: DN 25
Name (Závitový_G_Ventil kulový.CC:DN 25:...) | Celková velikost | Výška od podlaží (mm) | Maximální velikost (mm) = Minimální velikost (mm) = Průměr připojení (mm) | Velikost | Kód prvku | Komentáře | Označení
12781908 | ø25 mm-ø25 mm | 500 | 25 | ø25-ø25 | VE01.06.0039 | PODRUŽNÉ UZAVŘENÍ Z UČITELSKÉHO PRACOVIŠTĚ | 0039
12781969 | ø32 mm-ø32 mm | 500 | 32 | ø32-ø32 | VE01.06.0040 | PODRUŽNÉ UZAVŘENÍ Z UČITELSKÉHO PRACOVIŠTĚ | 0040
12801185 | ø32 mm-ø32 mm | 1500 | 32 | ø32-ø32 | VE01.06.0049 | HLAVNÍ UZÁVĚR UČEBNY - OPATŘEN SKŘÍŇKOU S POPISEM | 0049
12801476 | ø32 mm-ø32 mm | 1500 | 32 | ø32-ø32 | VE01.06.0050 | HLAVNÍ UZÁVĚR UČEBNY - OPATŘEN SKŘÍŇKOU S POPISEM | 0050

# IfcValve: Závitový_G_Ventil kulový.CC:DN 32, Závitový_G_Ventil kulový.CC:DN 32:12782200
In: 1.NP_SO-101
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 94 mm; Jmenovitá velikost vstupu: 32 mm; Jmenovitá velikost výstupu: 32 mm; JMENOVITÝ PRŮMĚR: 32 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G1 1/4"; Kód sestavy: VE01; Komentáře k typům: kulový; Model: DN 32; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 32; Označení typu: 07; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 47 mm; DD: 94 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 3350 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.000176716 m3; Průměr připojení: 40 mm; Velikost: ø40-ø40
Identifikační data - Kód prvku: VE01.07.0041; Označení: 0041; Popis: G_Ventil
Jiné - Páteřní trasa: yes; Typ: DN 32; Angle3: 30 deg; Rodina: Závitový_G_Ventil kulový.CC; A: 32 mm; Angle1: 20 deg; Angle2: 22.5 deg; B: 24 mm; B2: 35.8813 mm; Ch: 47 mm; CW: 34 mm; D: 63 mm; D1: 40.0013 mm; D2: 17.6 mm; D3: 22.6 mm; D4: 33.15 mm; E: 112 mm; Id typu: 12781871; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 32

# IfcValve: Závitový_G_Ventil kulový.CC:DN 40 (2)
In: -1.PP_SO-101
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 103 mm; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G1 1/2"; Kód sestavy: VE01; Komentáře k typům: kulový; Model: DN 40; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 40; Označení typu: 09; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 51.5 mm; DD: 103 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.00023269 m3; Průměr připojení: 50 mm; Velikost: ø50-ø50
Identifikační data - Popis: G_Ventil
Jiné - Typ: DN 40; Angle3: 30 deg; Rodina: Závitový_G_Ventil kulový.CC; A: 40 mm; Angle1: 20 deg; Angle2: 22.5 deg; B: 24 mm; B2: 35.8813 mm; Ch: 53 mm; CW: 34 mm; D: 73 mm; D1: 40.0013 mm; D2: 19.6 mm; D3: 24.6 mm; D4: 33.15 mm; E: 143 mm; Id typu: 12781869; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 40
Name (Závitový_G_Ventil kulový.CC:DN 40:...) | Výška od podlaží (mm) | Kód prvku | Označení | Páteřní trasa
12788109 | 500 | VE01.09.0044 | 0044 | no | Mechanické – tok - Tlaková ztráta: 0 Pa
12788276 | 2500 | VE01.09.0045 | 0045 | yes

# IfcValve: Závitový_G_Ventil kulový.CC:DN 50 (3)
In: -1.PP_SO-101
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 126 mm; Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G2"; Kód sestavy: VE01; Komentáře k typům: kulový; Model: DN 50; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 50; Označení typu: 10; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 63 mm; DD: 126 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat); Group: GS_NTL vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø65 mm-ø65 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: -1.PP_SO-101
Fázování - Bouráno ve FÁZI 2: yes; Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 1
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 65 mm; Minimální velikost: 65 mm; Objem: 0.000312359 m3; Průměr připojení: 65 mm; Velikost: ø65-ø65
Identifikační data - Popis: G_Ventil
Jiné - Páteřní trasa: yes; Angle3: 30 deg; Rodina: Závitový_G_Ventil kulový.CC; A: 50 mm; Angle1: 20 deg; Angle2: 22.5 deg; B: 28.5 mm; B2: 40.6303 mm; Ch: 66 mm; CW: 38.5 mm; D: 81 mm; D1: 44.8721 mm; D2: 21.2 mm; D3: 26.2 mm; D4: 37.5375 mm; E: 143 mm; Id typu: 12781867; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 50; Typ: DN 50
Name (Závitový_G_Ventil kulový.CC:DN 50:...) | Tlaková ztráta (Pa) | Výška od podlaží (mm) | Kód prvku | Označení
12797284 | 0 | 3100 | VE01.10.0046 | 0046
12797285 |  | 2850 | VE01.10.0047 | 0047
12797286 | 0 | 2600 | VE01.10.0048 | 0048

# IfcValve: Závitový_Kulový kohout s motýlkem a hadičníkem:DN10 (36)
In: 2.NP_SO-101
Type - Material: MANIPULAČNÍ PROSTOR, 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Kóty - DÉLKA: 63 mm; Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: KK G3/8"; Kód sestavy: VE01; Komentáře k typům: Přímý vypouštěcí kulový kohout s páčkou s vnitřním závitem DN 15; Model: DN 15 vnitřní závit; Název typu: DN10; Označení typu: 05; Popis: Kulový kohout; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; A: -12 mm; B: 19 mm; C: 16 mm; D: 44 mm; E: -12 mm; H: 37.6 mm; H1: 24.6 mm; H2: 13 mm; KL: no; L1: 28 mm; L2: 63 mm; Lookup Table Name: Vypoštěcí kulový kohout s páčkou.CC; M: 48 mm; M1: 20 mm; Název rodiny: Závitový_Kulový kohout s motýlkem a hadičníkem; P: 25 mm; P1: 30 mm; P2: 14 mm; PR: yes; Typ: 1 mm; U: 0 deg; UP: 30 deg
Classification: VE01 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000642485 m3; Velikost: ø15
Jiné - Id typu: 12783221; Rodina: Závitový_Kulový kohout s motýlkem a hadičníkem; Rodina a typ: Závitový_Kulový kohout s motýlkem a hadičníkem: DN10; Typ: DN10
Name (Závitový_Kulový kohout s motýlkem a hadičníkem:DN10:...) | Kód prvku | Označení
12778062 | VE01.05.0005 | 0005
12779125 | VE01.05.0006 | 0006
12779143 | VE01.05.0007 | 0007
12779159 | VE01.05.0008 | 0008
12779171 | VE01.05.0009 | 0009
12779183 | VE01.05.0010 | 0010
12779195 | VE01.05.0011 | 0011
12779211 | VE01.05.0012 | 0012
12779235 | VE01.05.0013 | 0013
12779251 | VE01.05.0014 | 0014
12779275 | VE01.05.0015 | 0015
12779295 | VE01.05.0016 | 0016
12779307 | VE01.05.0017 | 0017
12779323 | VE01.05.0018 | 0018
12779333 | VE01.05.0019 | 0019
12779345 | VE01.05.0020 | 0020
12779719 | VE01.05.0021 | 0021
12779722 | VE01.05.0022 | 0022
12779723 | VE01.05.0023 | 0023
12779724 | VE01.05.0024 | 0024
12779725 | VE01.05.0025 | 0025
12779726 | VE01.05.0026 | 0026
12779727 | VE01.05.0027 | 0027
12779728 | VE01.05.0028 | 0028
12779729 | VE01.05.0029 | 0029
12779730 | VE01.05.0030 | 0030
12779731 | VE01.05.0031 | 0031
12779732 | VE01.05.0032 | 0032
12779733 | VE01.05.0033 | 0033
12779734 | VE01.05.0034 | 0034
12779882 | VE01.05.0035 | 0035
12780006 | VE01.05.0036 | 0036
12780007 | VE01.05.0037 | 0037
12780008 | VE01.05.0038 | 0038
12803624 | VE01.05.0051 | 0051
12804383 | VE01.05.0052 | 0052

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 1235.47 m2; Hrubý objem: 2857.7 m3; Obsazená plocha: 1235.47 m2; Obsazený objem: 2857.7 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
