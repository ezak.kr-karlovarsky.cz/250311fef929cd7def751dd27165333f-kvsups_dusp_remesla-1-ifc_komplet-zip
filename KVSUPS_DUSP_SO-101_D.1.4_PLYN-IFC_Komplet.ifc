Properties of the parts of a building model (IFC4), part 6 of 9

# IfcDistributionPort (1119)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12779537_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779538_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779537_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780084_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779551_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779585_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779551_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779728_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779553_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779599_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779553_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779730_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779555_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779557_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779555_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779563_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779557_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779581_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779559_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779565_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779559_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779727_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779561_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779563_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779561_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779565_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779567_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780086_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779567_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779575_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779569_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779590_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779569_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779595_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779569_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780086_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779571_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779577_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779571_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779729_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779573_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779575_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779573_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779577_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779579_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779587_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779579_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780090_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779581_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780088_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779583_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779585_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779583_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779587_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779589_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780088_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779589_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779590_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779589_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780090_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779593_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779601_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779593_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780092_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779595_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779603_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779597_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779599_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779597_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779601_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779603_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779911_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779603_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780092_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779607_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779641_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779607_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779724_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779609_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779655_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779609_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779725_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779611_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779613_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779611_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779619_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779613_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779637_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779615_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779621_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779615_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779719_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779617_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779619_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779617_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779621_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779623_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780094_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779623_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779631_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779625_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779646_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779625_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779651_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779625_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780094_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779627_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779633_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779627_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779722_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779629_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779631_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779629_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779633_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779635_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779643_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779635_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780096_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779637_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779720_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779639_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779641_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779639_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779643_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779645_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779720_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779645_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779646_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779645_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780096_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779649_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779657_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779649_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780098_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779651_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779659_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779653_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779655_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779653_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779657_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779659_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779675_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779659_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780098_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779661_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779683_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779661_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779726_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779663_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780100_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779663_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779671_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779665_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779675_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779665_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779679_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779665_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780100_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779667_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779673_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779667_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779723_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779669_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779671_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779669_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779673_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779677_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779685_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779677_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780102_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779679_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779687_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779681_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779683_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779681_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779685_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779687_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779689_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779687_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780102_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779689_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779693_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779691_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779693_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779691_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780631_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779719_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779615_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779722_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779627_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779723_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779667_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779724_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779607_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779725_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779609_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779726_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779661_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779727_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779559_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779728_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779551_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779729_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779571_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779730_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779553_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779731_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779505_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779732_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779515_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779733_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779523_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779734_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779533_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779872_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779906_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779872_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780104_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779874_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779880_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779874_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779882_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779876_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779906_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779876_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779880_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12779882_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779874_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779903_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779910_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779903_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780410_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779910_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779911_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779910_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780104_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779972_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780106_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779972_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779982_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779974_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780532_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779974_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779976_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779976_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780001_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779978_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779984_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779978_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780006_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779980_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779982_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779980_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779984_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779986_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779994_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779986_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780007_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779988_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780108_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779988_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779994_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779990_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780106_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779990_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779991_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779990_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780108_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779991_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780000_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779996_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780004_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779996_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780008_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779998_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780110_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12779998_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780004_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780000_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780001_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780000_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780110_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12780006_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779978_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12780007_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779986_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12780008_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12779996_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780150_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814969_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780150_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780316_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780211_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801433_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780211_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814971_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780248_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780311_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780248_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780316_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780339_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780484_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780395_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780479_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780395_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780499_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780408_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780410_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780408_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780479_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780476_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780499_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780476_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780572_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780484_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783133_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780499_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783133_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780499_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780514_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780514_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780532_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780544_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780560_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780544_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780572_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780572_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780624_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780624_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12780631_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781908_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783029_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781908_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783031_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781911_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12783029_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781969_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12781972_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12782012_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801215_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12782012_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802042_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12782200_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800734_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12784193_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12800592_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12784193_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787074_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
InPort_12800592_2 | SINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
OutPort_12784208_0 | SOURCE | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
InPort_12784208_1 | SINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
OutPort_12787770_4 | SOURCE | PIPE | USERDEFINED | GS_Odvětrání plynovodu 1 (6) (2)
Port_12784366_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12784374_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12784366_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788112_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12784366_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12791987_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12786245_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787709_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12786245_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799396_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12786270_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787713_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12786270_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12801865_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787030_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787074_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787030_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787076_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787076_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787216_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787216_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787413_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787292_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787409_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787292_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787405_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787353_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787409_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787353_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787413_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787383_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787640_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787383_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787405_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787555_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799392_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787555_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787640_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787688_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787709_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787688_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787713_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12787753_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12791971_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12787753_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12787772_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12787770_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12787772_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12787770_4 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12784208_1 | SOURCE | PIPE | VENT | GS_NTL vnitřní 3
Port_12788109_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788112_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12788109_4 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788276_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788278_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12788278_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12815710_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12790459_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800551_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12791971_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12791987_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12794034_1 | SOURCEANDSINK | PIPE
Port_12794034_2 | SOURCEANDSINK | PIPE
Port_12794425_1 | SOURCEANDSINK | PIPE
Port_12794425_2 | SOURCEANDSINK | PIPE
Port_12795990_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800185_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12795990_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800189_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12795992_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800189_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12795992_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800183_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12795998_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800185_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12795998_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800197_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12797264_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799991_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797264_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797286_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797266_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799920_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797266_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797285_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797268_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799842_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797268_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797284_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797279_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799920_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797279_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799842_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
OutPort_12797284_3 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797285_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797871_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
OutPort_12797286_3 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797356_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800053_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797356_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800041_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797556_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799741_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12797556_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799763_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12797562_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799699_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12797562_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799710_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12797783_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800209_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797783_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800213_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797795_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800213_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797795_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800053_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12797871_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12798434_1 | SOURCEANDSINK | PIPE
Port_12798434_2 | SOURCEANDSINK | PIPE
Port_12798659_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799763_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12798659_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799767_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12798691_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799767_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12798691_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799361_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799392_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799361_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799396_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1 (6) (2)
Port_12799683_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799699_2 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799683_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799741_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 1
Port_12799920_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799921_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799921_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799991_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799991_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799992_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12799992_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800041_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 1
Port_12800130_0 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800183_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800130_1 | SOURCEANDSINK | PIPE | VENT | GS_Odvětrání plynovodu 2
Port_12800303_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12815710_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800303_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12815712_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800401_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12815712_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800401_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801836_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800555_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800557_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800985_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801185_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12800985_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801086_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801084_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801086_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801084_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801131_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801185_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801187_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801187_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801215_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801377_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801476_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801377_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801437_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801389_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801391_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801389_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801437_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801433_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801478_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801476_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801478_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801763_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801774_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801763_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801838_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801777_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801834_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801777_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801838_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801834_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12801836_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802027_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802029_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802042_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802054_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802054_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802103_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802095_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802103_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802095_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802123_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802123_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802743_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12802743_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816751_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12803201_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804332_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12803201_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804337_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12803490_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804332_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12803490_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12803624_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12803624_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12803490_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804208_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805011_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804208_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805015_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804337_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804532_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804379_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804384_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804379_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805015_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804381_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804384_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804381_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804383_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
InPort_12804383_1 | SINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
OutPort_12804381_1 | SOURCE | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804532_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804990_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804789_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805076_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804789_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804811_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804799_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804800_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804799_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805076_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804800_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816760_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804803_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804972_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804803_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805007_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804811_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804885_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804883_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804885_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804883_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804973_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804970_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804972_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804970_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804990_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804972_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12804973_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805005_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805007_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805005_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12805011_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814931_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814969_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814931_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12814971_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816749_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816751_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816749_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3
Port_12816762_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL vnitřní 3

# IfcDistributionSystem: GS_NTL vnitřní (2)
PredefinedType: USERDEFINED
Name
GS_NTL vnitřní 1
GS_NTL vnitřní 3

# IfcDistributionSystem: GS_Odvětrání plynovodu (3)
PredefinedType: VENT
Name
GS_Odvětrání plynovodu 1 (6) (2)
GS_Odvětrání plynovodu 2
GS_Odvětrání plynovodu 1

# IfcPipeFitting: Chránička potrubí:Ocel (3)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TR00; Nadpis OmniClass: Pipework Fittings; Název typu: Ocel; Označení typu: 05; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: Chránička potrubí; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TR00 Uniformat (Uniformat)
Qto_PipeFittingBaseQuantities - GrossCrossSectionArea: 0.0190069 m2; NetCrossSectionArea: 0.0190069 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø100 mm-ø100 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: -1000 mm
Fázování - Bouráno ve FÁZI 2: yes; Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 50 mm; Jmenovitý průměr: 100 mm; Maximální velikost: 100 mm; Minimální velikost: 100 mm; Velikost: ø100-ø100; Velikost značky: 62.23 mm; Vnější průměr tvarovky: 155.575 mm
Jiné - Páteřní trasa: yes; Id typu: 12767156; Rodina: Chránička potrubí; Rodina a typ: Chránička potrubí: Ocel; Typ: Ocel; Vnější poloměr tvarovky: 77.7875 mm
Name (Chránička potrubí:Ocel:...) | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) | Objem (m3) | Kód prvku | Označení
12794034 | 29732.9 | 14.5321 | 0.565179 | TR00.05.0173 | 0173
12794425 | 4600 | 2.24827 | 0.0874393 | TR00.05.0174 | 0174
12798434 | 2450 | 1.19745 | 0.0465709 | TR00.05.0175 | 0175

# IfcPipeFitting: M_Koleno, obecné:Standardní (142)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní; Typ: Standardní
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12774785 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0001 | 0001 | no | 23.8125 | 17.4625
12774824 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0002 | 0002 | no | 23.8125 | 17.4625
12775056 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0004 | 0004 | no | 23.8125 | 17.4625
12775058 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0005 | 0005 | no | 23.8125 | 17.4625
12775352 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0006 | 0006 | no | 20.6375 | 14.2875
12775432 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0007 | 0007 | no | 14.2875 | 7.9375
12775434 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0008 | 0008 | no | 14.2875 | 7.9375
12775460 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0010 | 0010 | no | 14.2875 | 7.9375
12775486 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0012 | 0012 | no | 14.2875 | 7.9375
12775513 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0013 | 0013 | no | 14.2875 | 7.9375
12775604 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0015 | 0015 | no | 20.6375 | 14.2875
12775911 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0016 | 0016 | no | 14.2875 | 7.9375
12775985 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0017 | 0017 | no | 14.2875 | 7.9375
12775989 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0018 | 0018 | no | 14.2875 | 7.9375
12776066 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0020 | 0020 | no | 14.2875 | 7.9375
12776070 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0021 | 0021 | no | 14.2875 | 7.9375
12776310 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0022 | 0022 | no | 14.2875 | 7.9375
12776314 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0023 | 0023 | no | 14.2875 | 7.9375
12776384 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0025 | 0025 | no | 14.2875 | 7.9375
12776388 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0026 | 0026 | no | 14.2875 | 7.9375
12776471 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0028 | 0028 | no | 14.2875 | 7.9375
12776477 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0029 | 0029 | no | 14.2875 | 7.9375
12776479 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0030 | 0030 | no | 14.2875 | 7.9375
12776489 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0032 | 0032 | no | 14.2875 | 7.9375
12776491 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0033 | 0033 | no | 14.2875 | 7.9375
12776499 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0034 | 0034 | no | 14.2875 | 7.9375
12776501 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0035 | 0035 | no | 14.2875 | 7.9375
12776513 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0037 | 0037 | no | 14.2875 | 7.9375
12776515 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0038 | 0038 | no | 14.2875 | 7.9375
12776587 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0041 | 0041 | no | 14.2875 | 7.9375
12776589 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0042 | 0042 | no | 14.2875 | 7.9375
12776599 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0043 | 0043 | no | 14.2875 | 7.9375
12776601 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0044 | 0044 | no | 14.2875 | 7.9375
12776774 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0046 | 0046 | no | 20.6375 | 14.2875
12776939 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0047 | 0047 | no | 14.2875 | 7.9375
12776941 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0048 | 0048 | no | 14.2875 | 7.9375
12776951 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0050 | 0050 | no | 14.2875 | 7.9375
12776957 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0051 | 0051 | no | 20.6375 | 14.2875
12776987 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0052 | 0052 | no | 20.6375 | 14.2875
12779397 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0055 | 0055 | no | 20.6375 | 14.2875
12779479 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0057 | 0057 | no | 20.6375 | 14.2875
12779497 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0058 | 0058 | no | 23.8125 | 17.4625
12779513 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0060 | 0060 | no | 20.6375 | 14.2875
12779519 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0061 | 0061 | no | 14.2875 | 7.9375
12779521 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0062 | 0062 | no | 14.2875 | 7.9375
12779531 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0064 | 0064 | no | 14.2875 | 7.9375
12779541 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0066 | 0066 | no | 14.2875 | 7.9375
12779543 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0067 | 0067 | no | 14.2875 | 7.9375
12779557 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0068 | 0068 | no | 14.2875 | 7.9375
12779563 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0069 | 0069 | no | 14.2875 | 7.9375
12779565 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0070 | 0070 | no | 14.2875 | 7.9375
12779575 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0072 | 0072 | no | 14.2875 | 7.9375
12779577 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0073 | 0073 | no | 14.2875 | 7.9375
12779585 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0074 | 0074 | no | 14.2875 | 7.9375
