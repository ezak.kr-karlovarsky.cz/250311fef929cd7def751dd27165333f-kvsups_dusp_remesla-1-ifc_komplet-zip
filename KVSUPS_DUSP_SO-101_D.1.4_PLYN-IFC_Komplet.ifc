Properties of the parts of a building model (IFC4), part 7 of 9

# IfcPipeFitting: M_Koleno, obecné:Standardní (142)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12779587 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0075 | 0075 | no | 14.2875 | 7.9375
12779599 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0077 | 0077 | no | 14.2875 | 7.9375
12779601 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0078 | 0078 | no | 14.2875 | 7.9375
12779613 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0080 | 0080 | no | 14.2875 | 7.9375
12779619 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0081 | 0081 | no | 14.2875 | 7.9375
12779621 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0082 | 0082 | no | 14.2875 | 7.9375
12779631 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0084 | 0084 | no | 14.2875 | 7.9375
12779633 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0085 | 0085 | no | 14.2875 | 7.9375
12779641 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0086 | 0086 | no | 14.2875 | 7.9375
12779643 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0087 | 0087 | no | 14.2875 | 7.9375
12779655 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0089 | 0089 | no | 14.2875 | 7.9375
12779657 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0090 | 0090 | no | 14.2875 | 7.9375
12779671 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0093 | 0093 | no | 14.2875 | 7.9375
12779673 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0094 | 0094 | no | 14.2875 | 7.9375
12779683 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0095 | 0095 | no | 14.2875 | 7.9375
12779685 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0096 | 0096 | no | 14.2875 | 7.9375
12779693 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0098 | 0098 | no | 20.6375 | 14.2875
12779792 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0100 | 0100 | no | 14.2875 | 7.9375
12779880 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0101 | 0101 | no | 14.2875 | 7.9375
12779906 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0102 | 0102 | no | 14.2875 | 7.9375
12779976 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0104 | 0104 | no | 20.6375 | 14.2875
12779982 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0105 | 0105 | no | 14.2875 | 7.9375
12779984 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0106 | 0106 | no | 14.2875 | 7.9375
12779994 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0108 | 0108 | no | 14.2875 | 7.9375
12780004 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0110 | 0110 | no | 14.2875 | 7.9375
12780311 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0143 | 0143 | no | 23.8125 | 17.4625
12780316 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0144 | 0144 |  | 23.8125 | 17.4625
12780339 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0146 | 0146 | no | 23.8125 | 17.4625
12780410 | 2.NP_SO-101 | ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0147 | 0147 | no | 20.6375 | 14.2875
12780479 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0148 | 0148 | no | 20.6375 | 14.2875
12780532 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0150 | 0150 | no | 20.6375 | 14.2875
12780560 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0151 | 0151 | no | 20.6375 | 14.2875
12780631 | 1.NP_SO-101 | ø25 mm-ø25 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0153 | 0153 | no | 20.6375 | 14.2875
12787074 | -1.PP_SO-101 | ø15 mm-ø15 mm | -1.PP_SO-101 | 2500 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0162 | 0162 | no | 14.2875 | 7.9375
12787076 | -1.PP_SO-101 | ø15 mm-ø15 mm | -1.PP_SO-101 | 2500 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0163 | 0163 | no | 14.2875 | 7.9375
12787405 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | -356.231 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0164 | 0164 | no | 14.2875 | 7.9375
12787409 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | -1115.75 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0165 | 0165 | no | 14.2875 | 7.9375
12787413 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | -1115.75 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0166 | 0166 | no | 14.2875 | 7.9375
12787640 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | -356.231 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 9.87099e-07 | 2.51927 | 20 | ø15-ø15 | 1.11968 | 15.875 | TT01.01.0167 | 0167 | no | 14.2875 | 7.9375
12787709 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | 1912.96 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0168 | 0168 | no | 14.2875 | 7.9375
12787713 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | 1912.96 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0169 | 0169 | no | 14.2875 | 7.9375
12799392 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | 453.52 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0176 | 0176 | no | 14.2875 | 7.9375
12799396 | 3.NP_SO-101 | ø15 mm-ø15 mm | 3.NP_SO-101 | 453.52 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0177 | 0177 | no | 14.2875 | 7.9375
12799699 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 3600 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0178 | 0178 |  | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12799741 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 3600 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0180 | 0180 |  | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12799763 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | -1000 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0181 | 0181 |  | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12799767 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | -1000 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0182 | 0182 |  | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12799842 | -1.PP_SO-101 | ø65 mm-ø65 mm | -1.PP_SO-101 | 3100 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0183 | 0183 | yes | 39.6875 | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12800041 | -1.PP_SO-101 | ø65 mm-ø65 mm | -1.PP_SO-101 | -1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0186 | 0186 | yes | 39.6875 | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12800053 | -1.PP_SO-101 | ø65 mm-ø65 mm | -1.PP_SO-101 | -1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0187 | 0187 | yes | 39.6875 | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12800183 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | -1000 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0188 | 0188 | yes | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12800185 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 1000 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0189 | 0189 | yes | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12800189 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 1000 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0190 | 0190 | yes | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12800209 | -1.PP_SO-101 | ø65 mm-ø65 mm | -1.PP_SO-101 | -1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0192 | 0192 | yes | 39.6875 | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12800213 | -1.PP_SO-101 | ø65 mm-ø65 mm | -1.PP_SO-101 | -1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0193 | 0193 | yes | 39.6875 | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12800488 | 1.NP_SO-101 | ø40 mm-ø40 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0194 | 0194 | yes | 26.9875 | 20.6375
12800551 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 2500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0195 | 0195 | yes | 33.3375 | 26.9875
12800555 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0196 | 0196 | yes | 33.3375 | 26.9875
12800592 | -1.PP_SO-101 | ø15 mm-ø15 mm | -1.PP_SO-101 | 2500 | GS_Odvětrání plynovodu | Průduch | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0198 | 0198 | no | 14.2875 | 7.9375
12801086 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 1500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0199 | 0199 | no | 23.8125 | 17.4625
12801129 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0200 | 0200 | no | 23.8125 | 17.4625
12801131 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0201 | 0201 | no | 23.8125 | 17.4625
12801215 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 1500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0202 | 0202 | no | 23.8125 | 17.4625
12801391 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0203 | 0203 |  | 23.8125 | 17.4625
12801433 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 1500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0204 | 0204 |  | 23.8125 | 17.4625
12801437 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | 1500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0205 | 0205 |  | 23.8125 | 17.4625
12801742 | 1.NP_SO-101 | ø40 mm-ø40 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0206 | 0206 | yes | 26.9875 | 20.6375
12801774 | 1.NP_SO-101 | ø40 mm-ø40 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0207 | 0207 | yes | 26.9875 | 20.6375
12801834 | -1.PP_SO-101 | ø40 mm-ø40 mm | -1.PP_SO-101 | 6500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0208 | 0208 | yes | 26.9875 | 20.6375
12801838 | 1.NP_SO-101 | ø40 mm-ø40 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0210 | 0210 | yes | 26.9875 | 20.6375
12802027 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0212 | 0212 | yes | 23.8125 | 17.4625
12802103 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0215 | 0215 | yes | 23.8125 | 17.4625
12802123 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0216 | 0216 | yes | 23.8125 | 17.4625
12804332 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0217 | 0217 | no | 14.2875 | 7.9375
12804337 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0218 | 0218 | no | 14.2875 | 7.9375
12804384 | 2.NP_SO-101 | ø15 mm-ø15 mm | 2.NP_SO-101 | 1000 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0219 | 0219 | no | 14.2875 | 7.9375
12804811 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0221 | 0221 | no | 14.2875 | 7.9375
12804990 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0223 | 0223 | no | 14.2875 | 7.9375
12805007 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0224 | 0224 | no | 14.2875 | 7.9375
12805011 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0225 | 0225 | no | 14.2875 | 7.9375
12805015 | 1.NP_SO-101 | ø15 mm-ø15 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0226 | 0226 | no | 14.2875 | 7.9375
12814969 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0228 | 0228 |  | 23.8125 | 17.4625
12814971 | 2.NP_SO-101 | ø32 mm-ø32 mm | 2.NP_SO-101 | -600 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0229 | 0229 |  | 23.8125 | 17.4625
12815710 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 2500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0230 | 0230 |  | 33.3375 | 26.9875
12815712 | -1.PP_SO-101 | ø50 mm-ø50 mm | -1.PP_SO-101 | 2500 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0231 | 0231 | yes | 33.3375 | 26.9875
12816751 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0232 | 0232 | yes | 23.8125 | 17.4625
12816760 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000357152 | 23.6905 | 89.7058 | ø32-ø32 | 13.8985 | 34.925 | TT01.01.0233 | 0233 | yes | 23.8125 | 17.4625
12816762 | 1.NP_SO-101 | ø32 mm-ø32 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0234 | 0234 | yes | 23.8125 | 17.4625

# IfcPipeFitting: M_Křížení, obecné:Standardní, M_Křížení, obecné:Standardní:12780499
In: 1.NP_SO-101
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm-ø25 mm-ø25 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 3400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Jmenovitý poloměr: 12.5 mm; Jmenovitý průměr: 25 mm; Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000536717 m3; Od středu ke konci: 26.9875 mm; Úhel 2: 90 deg; Velikost: ø25-ø25-ø25-ø25; Velikost značky: 11.43 mm; Vnější průměr tvarovky: 28.575 mm
Identifikační data - Kód prvku: TT06.04.0149; Označení: 0149
Jiné - Páteřní trasa: no; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Štítek, od středu ke konci: 26.9875 mm; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Vnější poloměr tvarovky: 14.2875 mm

# IfcPipeFitting: M_Přechod, obecný:Standardní (49)
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat); Group: GS_NTL vnitřní 3
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 3
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
12779113 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0054 | 0054 | no | 28.575 | yes | no | 7.9375 | 14.2875
12779720 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0099 | 0099 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780048 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0111 | 0111 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780050 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0112 | 0112 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780052 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0113 | 0113 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780054 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.987 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0114 | 0114 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780056 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0115 | 0115 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780058 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0116 | 0116 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780060 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0117 | 0117 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780062 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0118 | 0118 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780064 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0119 | 0119 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780066 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0120 | 0120 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780068 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0121 | 0121 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780070 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0122 | 0122 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780072 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0123 | 0123 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780074 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0124 | 0124 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780076 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0125 | 0125 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780078 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0126 | 0126 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780080 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0127 | 0127 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780082 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0128 | 0128 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780084 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0129 | 0129 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780086 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0130 | 0130 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780088 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0131 | 0131 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780090 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0132 | 0132 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780092 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0133 | 0133 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780094 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0134 | 0134 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780096 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0135 | 0135 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780098 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0136 | 0136 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780100 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0137 | 0137 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780102 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0138 | 0138 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780104 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0139 | 0139 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780106 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 500 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0140 | 0140 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780108 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0141 | 0141 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780110 | 2.NP_SO-101 | ø25 mm-ø15 mm | 2.NP_SO-101 | 526.988 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0142 | 0142 | no | 28.575 | yes | no | 7.9375 | 14.2875
12780322 | 2.NP_SO-101 | ø32 mm-ø25 mm | 2.NP_SO-101 | 500 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0145 | 0145 | no | 34.925 | no | yes | 17.4625 | 14.2875
12783025 | 2.NP_SO-101 | ø32 mm-ø25 mm | 2.NP_SO-101 | 500 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT03.03.0154 | 0154 | no | 34.925 | yes | no | 14.2875 | 17.4625
12783027 | 1.NP_SO-101 | ø32 mm-ø25 mm | 1.NP_SO-101 | 3700 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0155 | 0155 | no | 34.925 | no | yes | 17.4625 | 14.2875
12783029 | 2.NP_SO-101 | ø32 mm-ø25 mm | 2.NP_SO-101 | 500 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0156 | 0156 | no | 34.925 | no | yes | 17.4625 | 14.2875
12783031 | 2.NP_SO-101 | ø32 mm-ø25 mm | 2.NP_SO-101 | 500 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0157 | 0157 | no | 34.925 | no | yes | 17.4625 | 14.2875
12783131 | 2.NP_SO-101 | ø32 mm-ø25 mm | 2.NP_SO-101 | 473.012 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0158 | 0158 | no | 34.925 | no | yes | 17.4625 | 14.2875
12783133 | 1.NP_SO-101 | ø32 mm-ø25 mm | 1.NP_SO-101 | 3400 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT03.03.0159 | 0159 | no | 34.925 | no | yes | 17.4625 | 14.2875
12784374 | -1.PP_SO-101 | ø150 mm-ø50 mm | -1.PP_SO-101 | 500 | 38.8938 | 25 | 75 | 50 | 150 | 150 | 50 | 0.00036149 | 0.0225099 | ø150-ø50 | 21.59 | 62.23 | 53.975 | 155.575 | TT03.03.0161 | 0161 | yes | 155.575 | no | yes | 77.7875 | 26.9875
12790491 | -1.PP_SO-101 | ø50 mm-ø40 mm | -1.PP_SO-101 | 2500 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0170 | 0170 | yes | 53.975 | yes | no | 20.6375 | 26.9875
12790521 | -1.PP_SO-101 | ø50 mm-ø40 mm | -1.PP_SO-101 | 2500 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0171 | 0171 | yes | 53.975 | yes | no | 20.6375 | 26.9875
12791987 | -1.PP_SO-101 | ø50 mm-ø15 mm | -1.PP_SO-101 | 539.687 | 13.4938 | 25 | 7.5 | 50 | 15 | 50 | 15 | 0.000014165 | 0.00255798 | ø50-ø15 | 21.59 | 6.35 | 53.975 | 15.875 | TT03.03.0172 | 0172 | no | 53.975 | yes | no | 7.9375 | 26.9875
12800557 | -1.PP_SO-101 | ø150 mm-ø50 mm | -1.PP_SO-101 | 500 | 38.8938 | 75 | 25 | 150 | 50 | 150 | 50 | 0.00036146 | 0.0225099 | ø150-ø50 | 62.23 | 21.59 | 155.575 | 53.975 | TT03.03.0197 | 0197 | yes | 155.575 | yes | no | 26.9875 | 77.7875
12801836 | -1.PP_SO-101 | ø50 mm-ø40 mm | -1.PP_SO-101 | 6459.52 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0209 | 0209 | yes | 53.975 | yes | no | 20.6375 | 26.9875
12802029 | 1.NP_SO-101 | ø40 mm-ø32 mm | 1.NP_SO-101 | 3350 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.0213 | 0213 | yes | 41.275 | yes | no | 17.4625 | 20.6375
12805076 | 1.NP_SO-101 | ø32 mm-ø15 mm | 1.NP_SO-101 | 3450 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.0227 | 0227 | yes | 34.925 | yes | no | 7.9375 | 17.4625

# IfcPipeFitting: M_Spoj T, obecný:Standardní (36)
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT04; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT04 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
12774845 | 2.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT04.02.0003 | 0003 | no | 17.4625
12775456 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0009 | 0009 | no | 14.2875
12775482 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0011 | 0011 | no | 14.2875
12775543 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0014 | 0014 | no | 14.2875
12776015 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0019 | 0019 | no | 14.2875
12776318 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0024 | 0024 | no | 14.2875
12776392 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0027 | 0027 | no | 14.2875
12776483 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0031 | 0031 | no | 14.2875
12776503 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0036 | 0036 | no | 14.2875
12776517 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0039 | 0039 | no | 14.2875
12776581 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0040 | 0040 | no | 14.2875
12776654 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0045 | 0045 | no | 14.2875
12776947 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0049 | 0049 | no | 14.2875
12776991 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0053 | 0053 | no | 14.2875
12779462 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-101 | 3700 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0056 | 0056 | no | 14.2875
12779501 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0059 | 0059 | no | 14.2875
12779527 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0063 | 0063 | no | 14.2875
12779537 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0065 | 0065 | no | 14.2875
12779569 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0071 | 0071 | no | 14.2875
12779589 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0076 | 0076 | no | 14.2875
12779603 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0079 | 0079 | no | 14.2875
12779625 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0083 | 0083 | no | 14.2875
12779645 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0088 | 0088 | no | 14.2875
12779659 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0091 | 0091 | no | 14.2875
12779665 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0092 | 0092 | no | 14.2875
12779687 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0097 | 0097 | no | 14.2875
12779910 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0103 | 0103 | no | 14.2875
12779990 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0107 | 0107 | no | 14.2875
12780000 | 2.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-101 | 500 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0109 | 0109 | no | 14.2875
12780572 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-101 | 3400 | GS_NTL vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT04.02.0152 | 0152 | no | 14.2875
12784366 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 500 | GS_NTL vnitřní 3 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT04.02.0160 | 0160 | yes | 26.9875
12799920 | -1.PP_SO-101 | ø65 mm-ø65 mm-ø65 mm | -1.PP_SO-101 | 2850 | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT04.02.0184 | 0184 | yes | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12799991 | -1.PP_SO-101 | ø65 mm-ø65 mm-ø65 mm | -1.PP_SO-101 | 2600 | GS_NTL vnitřní 1 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT04.02.0185 | 0185 | yes | 33.3375 | Fázování - Bouráno ve FÁZI 2: yes
12802042 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-101 | 3350 | GS_NTL vnitřní 3 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT04.02.0214 | 0214 | yes | 17.4625
12804799 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní 3 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT04.02.0220 | 0220 | yes | 17.4625
12804972 | 1.NP_SO-101 | ø15 mm-ø15 mm-ø15 mm | 1.NP_SO-101 | 3450 | GS_NTL vnitřní 3 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT04.02.0222 | 0222 | no | 7.9375

# IfcPipeFitting: M_Uzavření, obecné:Standardní (3)
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT05; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 06; Popis sestavy: Záslepka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT05 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_Odvětrání plynovodu; Klasifikace systému: Průduch
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní
Name (M_Uzavření, obecné:Standardní:...) | In | Length (mm) = Výš. (mm) = Vnější poloměr tvarovky (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Podlaží | Výška od podlaží (mm) | Bouráno ve FÁZI 2 | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa
12799710 | -1.PP_SO-101 | 26.9875 | 0.0022878 | 0.0045762 | ø50 mm | -1.PP_SO-101 | 3433.34 | yes | GS_Odvětrání plynovodu 1 | 25 | 50 | 0.0000617472 | ø50 | 53.975 | TT05.06.0179 | 0179
12800197 | -1.PP_SO-101 | 26.9875 | 0.0022878 | 0.0045762 | ø50 mm | -1.PP_SO-101 | 833.337 | yes | GS_Odvětrání plynovodu 2 | 25 | 50 | 0.0000617472 | ø50 | 53.975 | TT05.06.0191 | 0191 | yes
12801865 | 3.NP_SO-101 | 7.9375 | 0.000197906 | 0.000395865 | ø15 mm | 3.NP_SO-101 | 1727.25 |  | GS_Odvětrání plynovodu 1 (6) (2) | 7.5 | 15 | 0.00000157102 | ø15 | 15.875 | TT05.06.0211 | 0211 | no

# IfcPipeSegment: Typy trubek:Ocel_bralen (20)
In: -1.PP_SO-101
Type - Material: 255-192- 0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Komentáře k typům: ČICHAČKA; Název typu: Ocel_bralen; Označení typu: 01; Popis: OC Bralen; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: -1.PP_SO-101; Vertikální zarovnání: Střed
Fázování - Bouráno ve FÁZI 2: yes; Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.1 mm; Materiál: Kov, ocel; Popis úseku: BRALEN; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - Bralen; Výkaz/typ: Bralen
Jiné - Id typu: 12487575; Rodina: Typy trubek; Rodina a typ: Typy trubek: Ocel_bralen; Typ: Ocel_bralen
Name (Typy trubek:Ocel_bralen:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
12766300 | 1926.98 | 0.00454772 | 0.460692 | ø65 mm | 0 | 966.663 | 966.663 | -960.313 | -960.313 | Ostatní | GS_NTL vnitřní 1 | -4110.31 | 0.393495 | 65 | 152 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0001 | 0001 | yes
12795990 | 384.567 | 0.00285535 | 0.0728516 | ø50 mm | 0.00188679 | 1030.15 | 1000 | 1000 | 969.85 | Průduch | GS_Odvětrání plynovodu 2 | -2176.5 | 0.0604076 | 50 | 5 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0187 | 0187 | yes | 0
12795992 | 1933.33 | 0.00285535 | 0.366245 | ø50 mm | 0 | 966.663 | -966.662 | 966.663 | -966.662 | Průduch | GS_Odvětrání plynovodu 2 | -4116.66 | 0.303686 | 50 | 5 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0188 | 0188 | yes
12795998 | 133.325 | 0.00285535 | 0.0252568 | ø50 mm | 0 | 966.663 | 833.337 | 966.663 | 833.337 | Průduch | GS_Odvětrání plynovodu 2 | -2316.66 | 0.0209426 | 50 | 5 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0189 | 0189 | yes
12797264 | 405.806 | 0.00454772 | 0.0970181 | ø65 mm | 0.00188679 | 2638.05 | 2600 | 2600 | 2561.95 | Ostatní | GS_NTL vnitřní 1 | -584.45 | 0.0828669 | 65 | 141 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0190 | 0190 | yes | 0
12797266 | 405.806 | 0.00454772 | 0.0970181 | ø65 mm | 0.00188679 | 2888.05 | 2850 | 2850 | 2811.95 | Ostatní | GS_NTL vnitřní 1 | -334.45 | 0.0828669 | 65 | 7 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0191 | 0191 | yes | 0
12797268 | 412.156 | 0.00454772 | 0.0985362 | ø65 mm | 0.00188679 | 3138.05 | 3100 | 3100 | 3061.95 | Ostatní | GS_NTL vnitřní 1 | -84.45 | 0.0841636 | 65 | 150 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0192 | 0192 | yes | 0
12797279 | 164.275 | 0.00454772 | 0.0392741 | ø65 mm | 0.00188679 | 3060.31 | 3060.31 | 2896.04 | 2896.04 | Ostatní | GS_NTL vnitřní 1 | -253.962 | 0.0335455 | 65 | 150 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0193 | 0193 | yes
12797356 | 2523.09 | 0.00454772 | 0.603209 | ø65 mm | 0.00145138 | -961.95 | -1000 | -1000 | -1038.05 | Ostatní | GS_NTL vnitřní 1 | -4184.45 | 0.515224 | 65 | 152 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0194 | 0194 |  | 0
12797556 | 4533.33 | 0.00285535 | 0.858784 | ø50 mm | 0.00188679 | 3566.66 | -966.663 | 3566.66 | -966.663 | Průduch | GS_Odvětrání plynovodu 1 | -4116.66 | 0.712093 | 50 | 6 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0195 | 0195
12797562 | 133.325 | 0.00285535 | 0.0252568 | ø50 mm | 0.00188679 | 3566.66 | 3433.34 | 3566.66 | 3433.34 | Průduch | GS_Odvětrání plynovodu 1 | 283.337 | 0.0209426 | 50 | 6 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0196 | 0196
12797783 | 4716.35 | 0.00454772 | 1.12756 | ø65 mm | 0.00145138 | -961.95 | -1000 | -1000 | -1038.05 | Ostatní | GS_NTL vnitřní 1 | -4184.45 | 0.963095 | 65 | 152 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0197 | 0197 | yes | 0
12797795 | 29803.5 | 0.00454772 | 7.12528 | ø65 mm | 0.00145138 | -961.95 | -1000 | -1000 | -1038.05 | Ostatní | GS_NTL vnitřní 1 | -4184.45 | 6.08599 | 65 | 152 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0198 | 0198 | yes | 0 | Identifikační data - Komentáře: VEDENO POD PODLAHOU, OPATŘENO HDPE CHRÁNIČKOU - OBA KONCE OPATŘENY ČICHAČKOU, NA ZAČÁTKU ETAPY 2 ZŮSTANE BEZ VYUŽITÍ - POTRUBÍ I CHRÁNIČKA BUDE ZAFOUKÁNO POPÍLKOBETONEM A OBA KONCE ZASLEPENY
12797871 | 750.864 | 0.00454772 | 0.179513 | ø65 mm | 0.00145138 | 2888.05 | 2850 | 2850 | 2811.95 | Ostatní | GS_NTL vnitřní 1 | -334.45 | 0.153329 | 65 | 7 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0199 | 0199 | yes | 0
12798659 | 113.325 | 0.00285535 | 0.0214681 | ø50 mm | 0.00188679 | -969.85 | -1000 | -1000 | -1030.15 | Průduch | GS_Odvětrání plynovodu 1 | -4176.5 | 0.017801 | 50 | 6 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0200 | 0200 |  | 0
12798691 | 126.663 | 0.00285535 | 0.0239947 | ø50 mm | 0.00188679 | -969.85 | -1000 | -1000 | -1030.15 | Průduch | GS_Odvětrání plynovodu 1 | -4176.5 | 0.0198961 | 50 | 6 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0201 | 0201 |  | 0
12799683 | 84.3936 | 0.00285535 | 0.0159874 | ø50 mm | 0.00188679 | 3630.15 | 3600 | 3600 | 3569.85 | Průduch | GS_Odvětrání plynovodu 1 | 423.5 | 0.0132565 | 50 | 6 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0203 | 0203 |  | 0
12799921 | 157.925 | 0.00454772 | 0.037756 | ø65 mm | 0.00145138 | 2803.96 | 2803.96 | 2646.04 | 2646.04 | Ostatní | GS_NTL vnitřní 1 | -503.962 | 0.0322488 | 65 | 151 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0204 | 0204 | yes
12799992 | 3514.28 | 0.00454772 | 0.840176 | ø65 mm | 0.00145138 | 2553.96 | 2553.96 | -960.313 | -960.313 | Ostatní | GS_NTL vnitřní 1 | -4110.31 | 0.717627 | 65 | 152 | GS_NTL vnitřní | ø65 | 76.1 | 68.9 | TR02.01.0205 | 0205 | yes
12800130 | 380 | 0.00285535 | 0.0719865 | ø50 mm | 0.00188679 | -969.85 | -1000 | -1000 | -1030.15 | Průduch | GS_Odvětrání plynovodu 2 | -4176.5 | 0.0596903 | 50 | 5 | GS_Odvětrání plynovodu | ø50 | 60.3 | 53 | TR02.01.0206 | 0206 | yes | 0

# IfcPipeSegment: Typy trubek:Ocel_černá (215)
Type - Material: 255-192- 0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_černá; Označení typu: 02; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Materiál: Kov, ocel; Drsnost: 0.1 mm; Popis úseku: FE; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ
Jiné - Rodina: Typy trubek; Id typu: 12487561; Rodina a typ: Typy trubek: Ocel_černá; Typ: Ocel_černá
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
12768241 | 1.NP_SO-101 | 1861.83 | 0.00183197 | 0.282513 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.233965 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0002 | 0002 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12768441 | -1.PP_SO-101 | 2519.14 | 0.0198527 | 1.25834 | ø150 mm | 0.000662252 | 579.5 | 500 | 500 | -1.PP_SO-101 | 0 | 420.5 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -2725.5 | 1.18711 | 150 | 169 | ø150 | 159 | 151 | TR02.02.0003 | 0003 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: AKUMULACE PLYNU
12768451 | -1.PP_SO-101 | 1933.32 | 0.00285535 | 0.366245 | ø50 mm | 0.00188679 | 2466.66 | 533.337 | 2466.66 | -1.PP_SO-101 |  | 533.337 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -2616.66 | 0.303686 | 50 | 170 | ø50 | 60.3 | 53 | TR02.02.0004 | 0004 | yes | GS_NTL vnitřní 3
12769175 | 1.NP_SO-101 | 2978.82 | 0.00141175 | 0.396789 | ø32 mm | 0.00278552 | 3471.2 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3428.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3432.05 | 0.299464 | 32 | 220 | ø32 | 42.4 | 35.9 | TR02.02.0005 | 0005 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12769449 | 1.NP_SO-101 | 5878.71 | 0.00183197 | 0.892029 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.73874 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0006 | 0006 | yes | GS_NTL vnitřní 3
12769459 | 1.NP_SO-101 | 19551.2 | 0.00183197 | 2.96668 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 2.45688 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0007 | 0007 | yes | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12772306 | -1.PP_SO-101 | 283.447 | 0.00285535 | 0.0536957 | ø50 mm | 0.00188679 | 2530.15 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -676.5 | 0.0445238 | 50 | 170 | ø50 | 60.3 | 53 | TR02.02.0008 | 0008 | yes | GS_NTL vnitřní 3
12774199 | -1.PP_SO-101 | 284.163 | 0.00285535 | 0.0538313 | ø50 mm | 0.00188679 | 2530.15 | 2500 | 2500 | -1.PP_SO-101 | 0 | 2469.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | -676.5 | 0.0446362 | 50 | 232 | ø50 | 60.3 | 53 | TR02.02.0009 | 0009 | yes | GS_NTL vnitřní 3
12774303 | 1.NP_SO-101 | 308.768 | 0.00183197 | 0.0468521 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.0388009 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0010 | 0010 | yes | GS_NTL vnitřní 3
12774344 | 1.NP_SO-101 | 850.2 | 0.00141175 | 0.11325 | ø32 mm | 0.00278552 | 3371.2 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3328.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3332.05 | 0.0854714 | 32 | 176 | ø32 | 42.4 | 35.9 | TR02.02.0011 | 0011 | yes | GS_NTL vnitřní 3
12774353 | 1.NP_SO-101 | 4590.29 | 0.00141175 | 0.611443 | ø32 mm | 0.00278552 | 3471.2 | 3450 | 3450 | 1.NP_SO-101 | 0 | 3428.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3432.05 | 0.461466 | 32 | 233 | ø32 | 42.4 | 35.9 | TR02.02.0012 | 0012 | yes | GS_NTL vnitřní 3
12774398 | 1.NP_SO-101 | 1735.34 | 0.00183197 | 0.263318 | ø40 mm | 0.00239234 | 3374.15 | 3350 | 3350 | 1.NP_SO-101 | 0 | 3325.85 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3329.1 | 0.218069 | 40 | 174 | ø40 | 48.3 | 41.8 | TR02.02.0013 | 0013 | yes | GS_NTL vnitřní 3
12774402 | 1.NP_SO-101 | 3279.7 | 0.00141175 | 0.436868 | ø32 mm | 0.00278552 | 3721.2 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3678.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3682.05 | 0.329711 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0014 | 0014 | no | GS_NTL vnitřní 3 | Identifikační data - Komentáře: VEDENO POD STROPEM
12774647 | 2.NP_SO-101 | 63.5829 | 0.00141175 | 0.00846947 | ø32 mm | 0.00278552 | 521.2 | 500 | 500 | 2.NP_SO-101 | 0 | 478.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4482.05 | 0.00639205 | 32 | 25 | ø32 | 42.4 | 35.9 | TR02.02.0015 | 0015 | no | GS_NTL vnitřní 3
12774656 | 1.NP_SO-101 | 752.375 | 0.00141175 | 0.100219 | ø32 mm | 0.00278552 | 4476.19 | 4476.19 | 3723.81 | 1.NP_SO-101 |  | 3723.81 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3723.81 | 0.075637 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0016 | 0016 | no | GS_NTL vnitřní 3
12774719 | 1.NP_SO-101 | 881.621 | 0.00141175 | 0.117435 | ø32 mm | 0.00278552 | 3721.2 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3678.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3682.05 | 0.0886302 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0017 | 0017 | no | GS_NTL vnitřní 3
12774820 | 1.NP_SO-101 | 746.025 | 0.00141175 | 0.0993732 | ø32 mm | 0.00278552 | 4469.84 | 3723.81 | 4469.84 | 1.NP_SO-101 |  | 3723.81 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3723.81 | 0.0749986 | 32 | 136 | ø32 | 42.4 | 35.9 | TR02.02.0018 | 0018 | no | GS_NTL vnitřní 3
12774857 | 2.NP_SO-101 | 330.205 | 0.000891835 | 0.0349594 | ø25 mm | 0.00367647 | 516.85 | 500 | 500 | 2.NP_SO-101 | 0 | 483.15 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4486.4 | 0.0259342 | 25 | 33 | ø25 | 33.7 | 27.2 | TR02.02.0019 | 0019 | no | GS_NTL vnitřní 3
12775037 | 1.NP_SO-101 | 3807.35 | 0.00141175 | 0.507152 | ø32 mm | 0.00278552 | 3721.2 | 3700 | 3700 | 1.NP_SO-101 | 0 | 3678.8 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 3682.05 | 0.382757 | 32 | 151 | ø32 | 42.4 | 35.9 | TR02.02.0020 | 0020 | no | GS_NTL vnitřní 3
12775098 | 2.NP_SO-101 | 178.35 | 0.000356274 | 0.0119345 | ø15 mm | 0.00625 | 1010.65 | 1000 | 1000 | 2.NP_SO-101 | 0 | 989.35 | GS_NTL vnitřní | Ostatní | GS_NTL vnitřní 3 | 4992 | 0.00840455 | 15 | 63 | ø15 | 21.3 | 16 | TR02.02.0021 | 0021 | no | GS_NTL vnitřní 3
