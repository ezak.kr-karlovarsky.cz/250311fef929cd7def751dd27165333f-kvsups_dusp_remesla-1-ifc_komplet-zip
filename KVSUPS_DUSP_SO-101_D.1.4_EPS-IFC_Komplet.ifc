Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 3097ffd8-9c5e-4fbf-bc4a-f377b06a2983, NumberOfSaves: 103], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-13T16:51:57
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject
Phase: SpD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.12 02:30

# IfcBuilding, Budova E
LongName: Budova E
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.12 02:30

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-101
In: Budova E
LongName: 2.NP_SO-101; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-101
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:32
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (4)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:31
1.NP_SO-101 | 1.NP_SO-101 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:32
3.NP_SO-101 | 3.NP_SO-101 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:32
4.NP_SO-101 | 4.NP_SO-101 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:32

# IfcAlarm: Automatický požární hlásič.CC:APH (165)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 2300 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Automatický požární hlásič.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP04; Komentáře k typům: automatický; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH; Označení typu: 01; Popis: Požární hlásič; Popis sestavy: Optický/tepelný multikriteriální hlásič; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Automatický požární hlásič.CC
Classification: EP04 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: BBB; CCI Technický systém: LB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000471217 m3
Jiné - Id typu: 275002; Rodina: Automatický požární hlásič.CC; Rodina a typ: Automatický požární hlásič.CC: APH; Typ: APH
Name (Automatický požární hlásič.CC:APH:...) | In | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Kód prvku | Označení | UPRAVIL
659151 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0001 | 0001 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659201 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0002 | 0002 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659733 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0003 | 0003 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659737 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0004 | 0004 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659741 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659745 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0006 | 0006 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659749 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0007 | 0007 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659765 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0008 | 0008 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659769 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0009 | 0009 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659773 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0010 | 0010 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659777 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0011 | 0011 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659785 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0012 | 0012 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659789 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0013 | 0013 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659825 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0014 | 0014 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659833 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0015 | 0015 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659841 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0016 | 0016 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
659852 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0017 | 0017 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
661225 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0018 | 0018 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
661229 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | -1.PP_SO-101 | EP04.01.0019 | 0019 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662569 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0021 | 0021 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662809 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0022 | 0022 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662824 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0023 | 0023 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662828 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662832 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0025 | 0025 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662840 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662844 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0027 | 0027 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662848 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662852 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0029 | 0029 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662856 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0030 | 0030 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662868 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0031 | 0031 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662900 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662904 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662908 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0034 | 0034 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662912 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0035 | 0035 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662974 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662986 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662990 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3740 | 2.NP_SO-101 | EP04.01.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662994 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3740 | 2.NP_SO-101 | EP04.01.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
662998 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663002 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663006 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663010 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663014 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663018 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663022 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663038 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663042 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663046 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663058 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663062 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663066 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663074 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663438 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0067 | 0067 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663442 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0068 | 0068 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663446 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0069 | 0069 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663450 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0070 | 0070 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663454 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0071 | 0071 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663458 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | EP04.01.0072 | 0072 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663462 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0073 | 0073 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663466 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | EP04.01.0074 | 0074 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663470 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0075 | 0075 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663474 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0076 | 0076 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663478 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663482 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0078 | 0078 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663486 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0079 | 0079 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663490 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0080 | 0080 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663494 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0081 | 0081 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663498 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0082 | 0082 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663502 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0083 | 0083 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663506 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0084 | 0084 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663510 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0085 | 0085 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663514 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0086 | 0086 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663560 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0087 | 0087 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663564 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0088 | 0088 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663568 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0089 | 0089 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663603 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0090 | 0090 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663607 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0091 | 0091 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663611 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0092 | 0092 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663615 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3575 | 2.NP_SO-101 | EP04.01.0093 | 0093 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663619 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3740 | 2.NP_SO-101 | EP04.01.0094 | 0094 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663623 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3740 | 2.NP_SO-101 | EP04.01.0095 | 0095 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663653 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3575 | 1.NP_SO-101 | EP04.01.0098 | 0098 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663657 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3575 | 1.NP_SO-101 | EP04.01.0099 | 0099 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663816 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0100 | 0100 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663856 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0101 | 0101 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663860 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0102 | 0102 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663864 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0103 | 0103 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663868 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0104 | 0104 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663872 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0105 | 0105 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663876 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0106 | 0106 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663880 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2865 | 4.NP_SO-101 | EP04.01.0107 | 0107 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663884 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0108 | 0108 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663888 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0109 | 0109 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663892 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0110 | 0110 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663896 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0111 | 0111 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663900 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0112 | 0112 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663904 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0113 | 0113 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663908 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0114 | 0114 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663912 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0115 | 0115 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663975 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0116 | 0116 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663979 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0117 | 0117 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663983 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0118 | 0118 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663987 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0119 | 0119 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663991 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0120 | 0120 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
663995 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0121 | 0121 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664003 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3790 | 3.NP_SO-101 | EP04.01.0122 | 0122 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664079 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0127 | 0127 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664083 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0128 | 0128 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664087 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664091 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0130 | 0130 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664095 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
664099 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | 4.NP_SO-101 | EP04.01.0132 | 0132 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665477 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 5688.17 | 4.NP_SO-101 | EP04.01.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665485 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 5250 | 4.NP_SO-101 | EP04.01.0134 | 0134 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665505 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 5250 | 4.NP_SO-101 | EP04.01.0135 | 0135 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665513 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 6539.82 | 4.NP_SO-101 | EP04.01.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665954 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2810 | 4.NP_SO-101 | EP04.01.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665958 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2810 | 4.NP_SO-101 | EP04.01.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665962 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3200 | 4.NP_SO-101 | EP04.01.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665966 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2810 | 4.NP_SO-101 | EP04.01.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
665995 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2810 | 4.NP_SO-101 | EP04.01.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
666172 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3195 | 4.NP_SO-101 | EP04.01.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
666751 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3195 | 4.NP_SO-101 | EP04.01.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
666755 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3195 | 4.NP_SO-101 | EP04.01.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
666874 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 5250 | 4.NP_SO-101 | EP04.01.0145 | 0145 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667352 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3195 | -1.PP_SO-101 | EP04.01.0150 | 0150 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667375 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667379 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667383 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0153 | 0153 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667387 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2890 | -1.PP_SO-101 | EP04.01.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667539 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0156 | 0156 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667543 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0157 | 0157 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667547 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3565 | 1.NP_SO-101 | EP04.01.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667605 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3565 | 2.NP_SO-101 | EP04.01.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667629 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3565 | 2.NP_SO-101 | EP04.01.0160 | 0160 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667633 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3565 | 2.NP_SO-101 | EP04.01.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667637 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3565 | 2.NP_SO-101 | EP04.01.0162 | 0162 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667675 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2820 | 4.NP_SO-101 | EP04.01.0163 | 0163 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667683 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 4320 | 3.NP_SO-101 | EP04.01.0164 | 0164 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667776 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2300 | 4.NP_SO-101 | EP04.01.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667780 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2300 | 4.NP_SO-101 | EP04.01.0166 | 0166 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
667784 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2300 | 4.NP_SO-101 | EP04.01.0167 | 0167 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:56
727478 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0211 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:20
727495 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0212 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727503 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0213 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727513 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0214 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727521 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0215 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727529 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0216 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727537 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0217 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727547 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0218 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727559 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0219 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727567 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0220 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727575 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0221 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727583 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0222 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727591 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0223 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727601 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0224 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727611 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0225 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:21
727623 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0226 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727633 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0227 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727643 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0228 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727653 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0229 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727661 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0230 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727673 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0231 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727681 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0232 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22
727689 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3575 | 3.NP_SO-101 | EP04.01.0043 | 0233 | Fruhauf.vinarice@seznam.cz 2023.08.10 07:22

# IfcAlarm: Lineární optický hlásič.CC:Lineární optický hlásič.CC, Lineární optický hlásič.CC:Lineární optický hlásič.CC:716764
In: 4.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 5600 mm
Type - Grafika - Přijímač a vysílač: no
Type - Kóty - HLOUBKA: 120 mm; ŠÍŘKA: 120 mm; VÝŠKA: 210 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP08; Název typu: Lineární optický hlásič.CC; Označení typu: 08; Popis sestavy: Lineární hlásič; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Lineární optický hlásič.CC; Q: 140 mm; T: 10 mm; V: 120 mm
Classification: EP08 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BRA; CCI Technický systém: LB
Vazby - Délka: 19000 mm; Odsazení od hostitele: -190.919 mm; Pracovní rovina: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.003168 m3; Plocha: 0.0816 m2
Identifikační data - Kód prvku: EP08.08.0194; Označení: 0194
Jiné - H: 120 mm; Id typu: 716498; Rodina: Lineární optický hlásič.CC; Rodina a typ: Lineární optický hlásič.CC: Lineární optický hlásič.CC; Typ: Lineární optický hlásič.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 07:13; X: no

# IfcAlarm: Lineární teplotní hlásič - vyhodnocovací jednotka.CC:1 Vstup, Lineární teplotní hlásič - vyhodnocovací jednotka.CC:1 Vstup:662492
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.21.11.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP08; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Temperature Monitors; Název typu: 1 Vstup; Označení typu: 02; Popis: Popis; Popis sestavy: Lineární hlásič; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Lineární teplotní hlásič - vyhodnocovací jednotka.CC
Classification: EP08 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BTB; CCI Technický systém: LB
Vazby - Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 3350 mm; Podlaží: 1.NP_SO-101; Výška od podlaží: 3350 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000139343 m3
Identifikační data - Kód prvku: EP08.02.0020; Označení: 0020
Jiné - Id typu: 662470; Rodina: Lineární teplotní hlásič - vyhodnocovací jednotka.CC; Rodina a typ: Lineární teplotní hlásič - vyhodnocovací jednotka.CC: 1 Vstup; Typ: 1 Vstup; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:54

# IfcAlarm: Ovládané a pomocné zařízení EP.CC:APH (3)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Ovládané a pomocné zařízení EPS.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP16; Komentáře k typům: Ovládané a pomocné zařízení EPS; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH; Označení typu: 04; Popis: Zařízení EPS; Popis sestavy: Vstupně/výstupní prvek (koppler); URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Ovládané a pomocné zařízení EP.CC
Classification: EP16 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000384 m3
Jiné - Typ: APH; Id typu: 668985; Rodina: Ovládané a pomocné zařízení EP.CC; Rodina a typ: Ovládané a pomocné zařízení EP.CC: APH; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:54
Name (Ovládané a pomocné zařízení EP.CC:APH:...) | In | Podlaží | Hostitel | Kód prvku | Označení
669009 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | EP16.04.0168 | 0168
692231 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | EP16.04.0188 | 0188
692240 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | EP16.04.0190 | 0190

# IfcAlarm: Ovládané a pomocné zařízení EP.CC:PK (12)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Ovládané a pomocné zařízení EPS.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PK00; Komentáře k typům: Ovládané a pomocné zařízení EPS; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: PK; Označení typu: 09; Popis: Zařízení EPS; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Ovládané a pomocné zařízení EP.CC
Classification: PK00 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000384 m3
Jiné - Rodina: Ovládané a pomocné zařízení EP.CC; Id typu: 721093; Rodina a typ: Ovládané a pomocné zařízení EP.CC: PK; Typ: PK; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:55
Name (Ovládané a pomocné zařízení EP.CC:PK:...) | In | Podlaží | Hostitel | Kód prvku | Označení
721131 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0199 | 0199
721135 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0200 | 0200
721139 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0201 | 0201
721143 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0202 | 0202
721147 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0203 | 0203
721151 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PK00.09.0204 | 0204
721179 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PK00.09.0205 | 0205
721183 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PK00.09.0206 | 0206
721187 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PK00.09.0207 | 0207
721191 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PK00.09.0208 | 0208
722328 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PK00.09.0209 | 0209
722332 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PK00.09.0210 | 0210

# IfcAlarm: Přídržný magnet.CC:Přídržný magnet.CC (9)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 5 mm; ŠÍŘKA: 50 mm; VÝŠKA: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP00; Komentáře k typům: Přídržný magnet; Model: Model; Název typu: Přídržný magnet.CC; Označení typu: 05; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; d: -5 mm; l2: -17.5 mm; -l2: 17.5 mm; Název rodiny: Přídržný magnet.CC; R: 5 mm
Classification: EP00 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: MBB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000061212 m3
Jiné - Id typu: 670220; Rodina: Přídržný magnet.CC; Rodina a typ: Přídržný magnet.CC: Přídržný magnet.CC; Typ: Přídržný magnet.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:54
Name (Přídržný magnet.CC:Přídržný magnet.CC:...) | In | Podlaží | Hostitel | Kód prvku | Označení
670236 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | EP00.05.0169 | 0169
670240 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | EP00.05.0170 | 0170
671407 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | EP00.05.0171 | 0171
671408 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | EP00.05.0172 | 0172
671417 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP00.05.0173 | 0173
671418 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP00.05.0174 | 0174
671441 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP00.05.0175 | 0175
671445 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP00.05.0176 | 0176
719631 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP00.05.0197 | 0197

# IfcAlarm: Tlačítkový požární hlásič.CC:Tlačítkový požární hlásič.CC (26)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1500 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 20 mm; ŠÍŘKA: 88 mm; VÝŠKA: 88 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP10; Komentáře k typům: tlačítkový; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tlačítkový požární hlásič.CC; Označení typu: 03; Popis: Požární hlásič; Popis sestavy: Tlačítkový hlásič; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Tlačítkový požární hlásič.CC
Classification: EP10 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0000865641 m3
Jiné - Id typu: 661190; Rodina: Tlačítkový požární hlásič.CC; Rodina a typ: Tlačítkový požární hlásič.CC: Tlačítkový požární hlásič.CC; Typ: Tlačítkový požární hlásič.CC
Name (Tlačítkový požární hlásič.CC:Tlačítkový požární hlásič.CC:...) | In | Podlaží | Hostitel | Posun vertikální | Posun horizontální | Kód prvku | Označení | UPRAVIL
662923 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | 2 | EP10.03.0036 | 0036 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
662927 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | 0 | EP10.03.0037 | 0037 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
662935 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2 | 0 | EP10.03.0038 | 0038 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
662939 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | -2 | 0 | EP10.03.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
662955 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | 2 | EP10.03.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
662963 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2 | 0 | EP10.03.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
662967 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | 0 | EP10.03.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
663404 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | 2 | EP10.03.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663408 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2 | 0 | EP10.03.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663412 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2 | 0 | EP10.03.0063 | 0063 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663416 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | 0 | EP10.03.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
663427 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | -2 | 0 | EP10.03.0065 | 0065 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663431 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | -2 | 0 | EP10.03.0066 | 0066 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663631 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | -2 | 0 | EP10.03.0096 | 0096 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
663640 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | -2 | 0 | EP10.03.0097 | 0097 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
664010 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | -2 | 0 | EP10.03.0123 | 0123 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
664014 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2 | 0 | EP10.03.0124 | 0124 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
664018 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | 2 | EP10.03.0125 | 0125 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
664022 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | -2 | EP10.03.0126 | 0126 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
666936 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -2 | 0 | EP10.03.0146 | 0146 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
666940 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -2 | 0 | EP10.03.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
667053 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -2 | 0 | EP10.03.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
667066 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | -2 | 0 | EP10.03.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
667421 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | 0 | EP10.03.0155 | 0155 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
719491 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | -2 | EP10.03.0195 | 0195 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52
719550 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | -2 | 0 | EP10.03.0196 | 0196 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:52

# IfcAlarm: Vstupně - výstupní modul.CC:Vstupně - výstupní modul Horizontální (10)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Svislé umístění: no; Vodorovné umístění: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP16; Komentáře k typům: Vstupně - výstupní modul; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Vstupně - výstupní modul Horizontální; Označení typu: 06; Popis: Popis; Popis sestavy: Vstupně/výstupní prvek (koppler); URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vstupně - výstupní modul.CC
Classification: EP16 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/3-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 200 mm; HLOUBKA: 50 mm; Objem: 0.001509 m3; ŠÍŘKA: 150 mm
Jiné - a: 80 mm; b: 45 mm; Id typu: 672589; Rodina: Vstupně - výstupní modul.CC; Rodina a typ: Vstupně - výstupní modul.CC: Vstupně - výstupní modul Horizontální; Typ: Vstupně - výstupní modul Horizontální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
Name (Vstupně - výstupní modul.CC:Vstupně - výstupní modul Horizontální:...) | In | Podlaží | Hostitel | Kód prvku | Označení
672607 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | EP16.06.0177 | 0177
672612 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | EP16.06.0178 | 0178
672620 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | EP16.06.0179 | 0179
672625 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | EP16.06.0180 | 0180
672633 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP16.06.0181 | 0181
672638 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP16.06.0182 | 0182
672646 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | EP16.06.0183 | 0183
692233 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | EP16.06.0189 | 0189
692242 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | EP16.06.0191 | 0191
719633 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | EP16.06.0198 | 0198

# IfcAlarm: Zenerova bariera_požární poplachová zařízení.CC:Konektor obecný (6)
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1050 mm
Type - Identifikační data - Číslo OmniClass: 23.85.30.21.14.99; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP00; Komentáře k typům: Konektor obecný; Model: Model; Nadpis OmniClass: Other Concentration Detection Components; Název typu: Konektor obecný; Označení typu: 07; Popis: Konektor; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Zenerova bariera_požární poplachová zařízení.CC
Classification: EP00 Uniformat (Uniformat)
Elektroinstalace - POČET FÁZÍ: 1; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: FAC; CCI Technický systém: LB
Vazby - Podlaží: 2.NP_SO-101; Hostitel: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt; Výška od podlaží: 1050 mm; Vztažné podlaží: 2.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V
Grafika - Geometrie: yes
Kóty - Objem: 0.00175 m3; Plocha: 0.045 m2
Jiné - FAKTOR ÚČINNOSTI: 0; Id typu: 673583; Rodina: Zenerova bariera_požární poplachová zařízení.CC; Rodina a typ: Zenerova bariera_požární poplachová zařízení.CC: Konektor obecný; Typ: Konektor obecný; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 07:13
Name (Zenerova bariera_požární poplachová zařízení.CC:Konektor obecný:...) | Kód prvku | Označení
673656 | EP00.07.0184 | 0184
673675 | EP00.07.0185 | 0185
673825 | EP00.07.0186 | 0186
673990 | EP00.07.0187 | 0187
714577 | EP00.07.0192 | 0192
714579 | EP00.07.0193 | 0193

# IfcBuildingElementProxy: Tlačítko odchodové.CC:Tlačítko odchodové.CC (7)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SI09; Komentáře k typům: odchodové; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Tlačítko odchodové.CC; Označení typu: 01; Popis: Tlačítko; Popis sestavy: Tlačítko 1/10; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Tlačítko odchodové.CC
Classification: SI09 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0601622 m2; NetVolume: 0.000757411 m3
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000757411 m3
Jiné - Id typu: 671375; Rodina: Tlačítko odchodové.CC; Rodina a typ: Tlačítko odchodové.CC: Tlačítko odchodové.CC; Typ: Tlačítko odchodové.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:53
Name (Tlačítko odchodové.CC:Tlačítko odchodové.CC:...) | In | Podlaží | Hostitel | Kód prvku | Označení
671391 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | SI09.01.0001 | 0001
671395 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | SI09.01.0002 | 0002
671409 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | SI09.01.0003 | 0003
671410 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | SI09.01.0004 | 0004
671419 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | SI09.01.0005 | 0005
671420 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | SI09.01.0006 | 0006
719632 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | SI09.01.0007 | 0007

# IfcBuildingElementProxy: Ústředna_Požární.CC:Tablo obsluhy_Požární_4.CC, Ústředna_Požární.CC:Tablo obsluhy_Požární_4.CC:722652
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tablo obsluhy_Požární_4.CC; Označení typu: 01; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 3.NP_SO-101; Hostitel: Podlaží : 3.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.01.0001; Označení: 0001
Jiné - Id typu: 722649; Páteřní trasa: yes; Rodina: Ústředna_Požární.CC; Rodina a typ: Ústředna_Požární.CC: Tablo obsluhy_Požární_4.CC; Typ: Tablo obsluhy_Požární_4.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:53

# IfcDistributionPort (613)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE
Name | SystemType
Port_659151_1 | ELECTROACOUSTIC
Port_659151_2 | SECURITY
Port_659151_3 | ELECTRICAL
Port_659201_1 | ELECTROACOUSTIC
Port_659201_2 | SECURITY
Port_659201_3 | ELECTRICAL
Port_659733_1 | ELECTROACOUSTIC
Port_659733_2 | SECURITY
Port_659733_3 | ELECTRICAL
Port_659737_1 | ELECTROACOUSTIC
Port_659737_2 | SECURITY
Port_659737_3 | ELECTRICAL
Port_659741_1 | ELECTROACOUSTIC
Port_659741_2 | SECURITY
Port_659741_3 | ELECTRICAL
Port_659745_1 | ELECTROACOUSTIC
Port_659745_2 | SECURITY
Port_659745_3 | ELECTRICAL
Port_659749_1 | ELECTROACOUSTIC
Port_659749_2 | SECURITY
Port_659749_3 | ELECTRICAL
Port_659765_1 | ELECTROACOUSTIC
Port_659765_2 | SECURITY
Port_659765_3 | ELECTRICAL
Port_659769_1 | ELECTROACOUSTIC
Port_659769_2 | SECURITY
Port_659769_3 | ELECTRICAL
Port_659773_1 | ELECTROACOUSTIC
Port_659773_2 | SECURITY
Port_659773_3 | ELECTRICAL
Port_659777_1 | ELECTROACOUSTIC
Port_659777_2 | SECURITY
Port_659777_3 | ELECTRICAL
Port_659785_1 | ELECTROACOUSTIC
Port_659785_2 | SECURITY
Port_659785_3 | ELECTRICAL
Port_659789_1 | ELECTROACOUSTIC
Port_659789_2 | SECURITY
Port_659789_3 | ELECTRICAL
Port_659825_1 | ELECTROACOUSTIC
Port_659825_2 | SECURITY
Port_659825_3 | ELECTRICAL
Port_659833_1 | ELECTROACOUSTIC
Port_659833_2 | SECURITY
Port_659833_3 | ELECTRICAL
Port_659841_1 | ELECTROACOUSTIC
Port_659841_2 | SECURITY
Port_659841_3 | ELECTRICAL
Port_659852_1 | ELECTROACOUSTIC
Port_659852_2 | SECURITY
Port_659852_3 | ELECTRICAL
Port_661225_1 | ELECTROACOUSTIC
Port_661225_2 | SECURITY
Port_661225_3 | ELECTRICAL
Port_661229_1 | ELECTROACOUSTIC
Port_661229_2 | SECURITY
Port_661229_3 | ELECTRICAL
Port_662492_1 | ELECTROACOUSTIC
Port_662569_1 | ELECTROACOUSTIC
Port_662569_2 | SECURITY
Port_662569_3 | ELECTRICAL
Port_662809_1 | ELECTROACOUSTIC
Port_662809_2 | SECURITY
Port_662809_3 | ELECTRICAL
Port_662824_1 | ELECTROACOUSTIC
Port_662824_2 | SECURITY
Port_662824_3 | ELECTRICAL
Port_662828_1 | ELECTROACOUSTIC
Port_662828_2 | SECURITY
Port_662828_3 | ELECTRICAL
Port_662832_1 | ELECTROACOUSTIC
Port_662832_2 | SECURITY
Port_662832_3 | ELECTRICAL
Port_662840_1 | ELECTROACOUSTIC
Port_662840_2 | SECURITY
Port_662840_3 | ELECTRICAL
Port_662844_1 | ELECTROACOUSTIC
Port_662844_2 | SECURITY
Port_662844_3 | ELECTRICAL
Port_662848_1 | ELECTROACOUSTIC
Port_662848_2 | SECURITY
Port_662848_3 | ELECTRICAL
Port_662852_1 | ELECTROACOUSTIC
Port_662852_2 | SECURITY
Port_662852_3 | ELECTRICAL
Port_662856_1 | ELECTROACOUSTIC
Port_662856_2 | SECURITY
Port_662856_3 | ELECTRICAL
Port_662868_1 | ELECTROACOUSTIC
Port_662868_2 | SECURITY
Port_662868_3 | ELECTRICAL
Port_662900_1 | ELECTROACOUSTIC
Port_662900_2 | SECURITY
Port_662900_3 | ELECTRICAL
Port_662904_1 | ELECTROACOUSTIC
Port_662904_2 | SECURITY
Port_662904_3 | ELECTRICAL
Port_662908_1 | ELECTROACOUSTIC
Port_662908_2 | SECURITY
Port_662908_3 | ELECTRICAL
Port_662912_1 | ELECTROACOUSTIC
Port_662912_2 | SECURITY
Port_662912_3 | ELECTRICAL
Port_662923_1 | ELECTROACOUSTIC
Port_662927_1 | ELECTROACOUSTIC
Port_662935_1 | ELECTROACOUSTIC
Port_662939_1 | ELECTROACOUSTIC
Port_662955_1 | ELECTROACOUSTIC
Port_662963_1 | ELECTROACOUSTIC
Port_662967_1 | ELECTROACOUSTIC
Port_662974_1 | ELECTROACOUSTIC
Port_662974_2 | SECURITY
Port_662974_3 | ELECTRICAL
Port_662986_1 | ELECTROACOUSTIC
Port_662986_2 | SECURITY
Port_662986_3 | ELECTRICAL
Port_662990_1 | ELECTROACOUSTIC
Port_662990_2 | SECURITY
Port_662990_3 | ELECTRICAL
Port_662994_1 | ELECTROACOUSTIC
Port_662994_2 | SECURITY
Port_662994_3 | ELECTRICAL
Port_662998_1 | ELECTROACOUSTIC
Port_662998_2 | SECURITY
Port_662998_3 | ELECTRICAL
Port_663002_1 | ELECTROACOUSTIC
Port_663002_2 | SECURITY
Port_663002_3 | ELECTRICAL
Port_663006_1 | ELECTROACOUSTIC
Port_663006_2 | SECURITY
Port_663006_3 | ELECTRICAL
Port_663010_1 | ELECTROACOUSTIC
Port_663010_2 | SECURITY
Port_663010_3 | ELECTRICAL
Port_663014_1 | ELECTROACOUSTIC
Port_663014_2 | SECURITY
Port_663014_3 | ELECTRICAL
Port_663018_1 | ELECTROACOUSTIC
Port_663018_2 | SECURITY
Port_663018_3 | ELECTRICAL
Port_663022_1 | ELECTROACOUSTIC
Port_663022_2 | SECURITY
Port_663022_3 | ELECTRICAL
Port_663038_1 | ELECTROACOUSTIC
Port_663038_2 | SECURITY
Port_663038_3 | ELECTRICAL
Port_663042_1 | ELECTROACOUSTIC
Port_663042_2 | SECURITY
Port_663042_3 | ELECTRICAL
Port_663046_1 | ELECTROACOUSTIC
Port_663046_2 | SECURITY
Port_663046_3 | ELECTRICAL
Port_663058_1 | ELECTROACOUSTIC
Port_663058_2 | SECURITY
Port_663058_3 | ELECTRICAL
Port_663062_1 | ELECTROACOUSTIC
Port_663062_2 | SECURITY
Port_663062_3 | ELECTRICAL
Port_663066_1 | ELECTROACOUSTIC
Port_663066_2 | SECURITY
Port_663066_3 | ELECTRICAL
Port_663074_1 | ELECTROACOUSTIC
Port_663074_2 | SECURITY
Port_663074_3 | ELECTRICAL
Port_663404_1 | ELECTROACOUSTIC
Port_663408_1 | ELECTROACOUSTIC
Port_663412_1 | ELECTROACOUSTIC
Port_663416_1 | ELECTROACOUSTIC
Port_663427_1 | ELECTROACOUSTIC
Port_663431_1 | ELECTROACOUSTIC
Port_663438_1 | ELECTROACOUSTIC
Port_663438_2 | SECURITY
Port_663438_3 | ELECTRICAL
Port_663442_1 | ELECTROACOUSTIC
Port_663442_2 | SECURITY
Port_663442_3 | ELECTRICAL
Port_663446_1 | ELECTROACOUSTIC
Port_663446_2 | SECURITY
Port_663446_3 | ELECTRICAL
Port_663450_1 | ELECTROACOUSTIC
Port_663450_2 | SECURITY
Port_663450_3 | ELECTRICAL
Port_663454_1 | ELECTROACOUSTIC
Port_663454_2 | SECURITY
Port_663454_3 | ELECTRICAL
Port_663458_1 | ELECTROACOUSTIC
Port_663458_2 | SECURITY
Port_663458_3 | ELECTRICAL
Port_663462_1 | ELECTROACOUSTIC
Port_663462_2 | SECURITY
Port_663462_3 | ELECTRICAL
Port_663466_1 | ELECTROACOUSTIC
Port_663466_2 | SECURITY
Port_663466_3 | ELECTRICAL
Port_663470_1 | ELECTROACOUSTIC
Port_663470_2 | SECURITY
Port_663470_3 | ELECTRICAL
Port_663474_1 | ELECTROACOUSTIC
Port_663474_2 | SECURITY
Port_663474_3 | ELECTRICAL
Port_663478_1 | ELECTROACOUSTIC
Port_663478_2 | SECURITY
Port_663478_3 | ELECTRICAL
Port_663482_1 | ELECTROACOUSTIC
Port_663482_2 | SECURITY
Port_663482_3 | ELECTRICAL
Port_663486_1 | ELECTROACOUSTIC
Port_663486_2 | SECURITY
Port_663486_3 | ELECTRICAL
Port_663490_1 | ELECTROACOUSTIC
Port_663490_2 | SECURITY
Port_663490_3 | ELECTRICAL
Port_663494_1 | ELECTROACOUSTIC
Port_663494_2 | SECURITY
Port_663494_3 | ELECTRICAL
Port_663498_1 | ELECTROACOUSTIC
Port_663498_2 | SECURITY
Port_663498_3 | ELECTRICAL
Port_663502_1 | ELECTROACOUSTIC
Port_663502_2 | SECURITY
Port_663502_3 | ELECTRICAL
Port_663506_1 | ELECTROACOUSTIC
Port_663506_2 | SECURITY
Port_663506_3 | ELECTRICAL
Port_663510_1 | ELECTROACOUSTIC
Port_663510_2 | SECURITY
Port_663510_3 | ELECTRICAL
Port_663514_1 | ELECTROACOUSTIC
Port_663514_2 | SECURITY
Port_663514_3 | ELECTRICAL
Port_663560_1 | ELECTROACOUSTIC
Port_663560_2 | SECURITY
Port_663560_3 | ELECTRICAL
Port_663564_1 | ELECTROACOUSTIC
Port_663564_2 | SECURITY
Port_663564_3 | ELECTRICAL
Port_663568_1 | ELECTROACOUSTIC
Port_663568_2 | SECURITY
Port_663568_3 | ELECTRICAL
Port_663603_1 | ELECTROACOUSTIC
Port_663603_2 | SECURITY
Port_663603_3 | ELECTRICAL
Port_663607_1 | ELECTROACOUSTIC
Port_663607_2 | SECURITY
Port_663607_3 | ELECTRICAL
Port_663611_1 | ELECTROACOUSTIC
Port_663611_2 | SECURITY
Port_663611_3 | ELECTRICAL
Port_663615_1 | ELECTROACOUSTIC
Port_663615_2 | SECURITY
Port_663615_3 | ELECTRICAL
Port_663619_1 | ELECTROACOUSTIC
Port_663619_2 | SECURITY
Port_663619_3 | ELECTRICAL
Port_663623_1 | ELECTROACOUSTIC
Port_663623_2 | SECURITY
Port_663623_3 | ELECTRICAL
Port_663631_1 | ELECTROACOUSTIC
Port_663640_1 | ELECTROACOUSTIC
Port_663653_1 | ELECTROACOUSTIC
Port_663653_2 | SECURITY
Port_663653_3 | ELECTRICAL
Port_663657_1 | ELECTROACOUSTIC
Port_663657_2 | SECURITY
Port_663657_3 | ELECTRICAL
Port_663816_1 | ELECTROACOUSTIC
Port_663816_2 | SECURITY
Port_663816_3 | ELECTRICAL
Port_663856_1 | ELECTROACOUSTIC
Port_663856_2 | SECURITY
Port_663856_3 | ELECTRICAL
Port_663860_1 | ELECTROACOUSTIC
Port_663860_2 | SECURITY
Port_663860_3 | ELECTRICAL
Port_663864_1 | ELECTROACOUSTIC
Port_663864_2 | SECURITY
Port_663864_3 | ELECTRICAL
Port_663868_1 | ELECTROACOUSTIC
Port_663868_2 | SECURITY
Port_663868_3 | ELECTRICAL
Port_663872_1 | ELECTROACOUSTIC
Port_663872_2 | SECURITY
Port_663872_3 | ELECTRICAL
Port_663876_1 | ELECTROACOUSTIC
Port_663876_2 | SECURITY
Port_663876_3 | ELECTRICAL
Port_663880_1 | ELECTROACOUSTIC
Port_663880_2 | SECURITY
Port_663880_3 | ELECTRICAL
Port_663884_1 | ELECTROACOUSTIC
Port_663884_2 | SECURITY
Port_663884_3 | ELECTRICAL
Port_663888_1 | ELECTROACOUSTIC
Port_663888_2 | SECURITY
Port_663888_3 | ELECTRICAL
Port_663892_1 | ELECTROACOUSTIC
Port_663892_2 | SECURITY
Port_663892_3 | ELECTRICAL
Port_663896_1 | ELECTROACOUSTIC
Port_663896_2 | SECURITY
Port_663896_3 | ELECTRICAL
Port_663900_1 | ELECTROACOUSTIC
Port_663900_2 | SECURITY
Port_663900_3 | ELECTRICAL
Port_663904_1 | ELECTROACOUSTIC
Port_663904_2 | SECURITY
Port_663904_3 | ELECTRICAL
Port_663908_1 | ELECTROACOUSTIC
Port_663908_2 | SECURITY
Port_663908_3 | ELECTRICAL
Port_663912_1 | ELECTROACOUSTIC
Port_663912_2 | SECURITY
Port_663912_3 | ELECTRICAL
Port_663975_1 | ELECTROACOUSTIC
Port_663975_2 | SECURITY
Port_663975_3 | ELECTRICAL
Port_663979_1 | ELECTROACOUSTIC
Port_663979_2 | SECURITY
Port_663979_3 | ELECTRICAL
Port_663983_1 | ELECTROACOUSTIC
Port_663983_2 | SECURITY
Port_663983_3 | ELECTRICAL
Port_663987_1 | ELECTROACOUSTIC
Port_663987_2 | SECURITY
Port_663987_3 | ELECTRICAL
Port_663991_1 | ELECTROACOUSTIC
Port_663991_2 | SECURITY
Port_663991_3 | ELECTRICAL
Port_663995_1 | ELECTROACOUSTIC
Port_663995_2 | SECURITY
Port_663995_3 | ELECTRICAL
Port_664003_1 | ELECTROACOUSTIC
Port_664003_2 | SECURITY
Port_664003_3 | ELECTRICAL
Port_664010_1 | ELECTROACOUSTIC
Port_664014_1 | ELECTROACOUSTIC
Port_664018_1 | ELECTROACOUSTIC
Port_664022_1 | ELECTROACOUSTIC
Port_664079_1 | ELECTROACOUSTIC
Port_664079_2 | SECURITY
Port_664079_3 | ELECTRICAL
Port_664083_1 | ELECTROACOUSTIC
Port_664083_2 | SECURITY
Port_664083_3 | ELECTRICAL
Port_664087_1 | ELECTROACOUSTIC
Port_664087_2 | SECURITY
Port_664087_3 | ELECTRICAL
Port_664091_1 | ELECTROACOUSTIC
Port_664091_2 | SECURITY
Port_664091_3 | ELECTRICAL
Port_664095_1 | ELECTROACOUSTIC
Port_664095_2 | SECURITY
Port_664095_3 | ELECTRICAL
Port_664099_1 | ELECTROACOUSTIC
Port_664099_2 | SECURITY
Port_664099_3 | ELECTRICAL
Port_665477_1 | ELECTROACOUSTIC
Port_665477_2 | SECURITY
Port_665477_3 | ELECTRICAL
Port_665485_1 | ELECTROACOUSTIC
Port_665485_2 | SECURITY
Port_665485_3 | ELECTRICAL
Port_665505_1 | ELECTROACOUSTIC
Port_665505_2 | SECURITY
Port_665505_3 | ELECTRICAL
Port_665513_1 | ELECTROACOUSTIC
Port_665513_2 | SECURITY
Port_665513_3 | ELECTRICAL
Port_665954_1 | ELECTROACOUSTIC
Port_665954_2 | SECURITY
Port_665954_3 | ELECTRICAL
Port_665958_1 | ELECTROACOUSTIC
Port_665958_2 | SECURITY
Port_665958_3 | ELECTRICAL
Port_665962_1 | ELECTROACOUSTIC
Port_665962_2 | SECURITY
Port_665962_3 | ELECTRICAL
Port_665966_1 | ELECTROACOUSTIC
Port_665966_2 | SECURITY
Port_665966_3 | ELECTRICAL
Port_665995_1 | ELECTROACOUSTIC
Port_665995_2 | SECURITY
Port_665995_3 | ELECTRICAL
Port_666172_1 | ELECTROACOUSTIC
Port_666172_2 | SECURITY
Port_666172_3 | ELECTRICAL
Port_666751_1 | ELECTROACOUSTIC
Port_666751_2 | SECURITY
Port_666751_3 | ELECTRICAL
Port_666755_1 | ELECTROACOUSTIC
Port_666755_2 | SECURITY
Port_666755_3 | ELECTRICAL
Port_666874_1 | ELECTROACOUSTIC
Port_666874_2 | SECURITY
Port_666874_3 | ELECTRICAL
Port_666936_1 | ELECTROACOUSTIC
Port_666940_1 | ELECTROACOUSTIC
Port_667053_1 | ELECTROACOUSTIC
Port_667066_1 | ELECTROACOUSTIC
Port_667352_1 | ELECTROACOUSTIC
Port_667352_2 | SECURITY
Port_667352_3 | ELECTRICAL
Port_667375_1 | ELECTROACOUSTIC
Port_667375_2 | SECURITY
Port_667375_3 | ELECTRICAL
Port_667379_1 | ELECTROACOUSTIC
Port_667379_2 | SECURITY
Port_667379_3 | ELECTRICAL
Port_667383_1 | ELECTROACOUSTIC
Port_667383_2 | SECURITY
Port_667383_3 | ELECTRICAL
Port_667387_1 | ELECTROACOUSTIC
Port_667387_2 | SECURITY
Port_667387_3 | ELECTRICAL
Port_667421_1 | ELECTROACOUSTIC
Port_667539_1 | ELECTROACOUSTIC
Port_667539_2 | SECURITY
Port_667539_3 | ELECTRICAL
Port_667543_1 | ELECTROACOUSTIC
Port_667543_2 | SECURITY
Port_667543_3 | ELECTRICAL
Port_667547_1 | ELECTROACOUSTIC
Port_667547_2 | SECURITY
Port_667547_3 | ELECTRICAL
Port_667605_1 | ELECTROACOUSTIC
