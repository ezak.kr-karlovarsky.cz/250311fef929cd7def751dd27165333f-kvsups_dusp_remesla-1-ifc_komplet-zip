Properties of the parts of a building model (IFC4), part 2 of 2

# IfcDistributionPort (613)
Name | SystemType
Port_667605_2 | SECURITY
Port_667605_3 | ELECTRICAL
Port_667629_1 | ELECTROACOUSTIC
Port_667629_2 | SECURITY
Port_667629_3 | ELECTRICAL
Port_667633_1 | ELECTROACOUSTIC
Port_667633_2 | SECURITY
Port_667633_3 | ELECTRICAL
Port_667637_1 | ELECTROACOUSTIC
Port_667637_2 | SECURITY
Port_667637_3 | ELECTRICAL
Port_667675_1 | ELECTROACOUSTIC
Port_667675_2 | SECURITY
Port_667675_3 | ELECTRICAL
Port_667683_1 | ELECTROACOUSTIC
Port_667683_2 | SECURITY
Port_667683_3 | ELECTRICAL
Port_667776_1 | ELECTROACOUSTIC
Port_667776_2 | SECURITY
Port_667776_3 | ELECTRICAL
Port_667780_1 | ELECTROACOUSTIC
Port_667780_2 | SECURITY
Port_667780_3 | ELECTRICAL
Port_667784_1 | ELECTROACOUSTIC
Port_667784_2 | SECURITY
Port_667784_3 | ELECTRICAL
Port_669009_1 | ELECTROACOUSTIC
Port_669009_2 | SECURITY
Port_669009_3 | ELECTRICAL
Port_670236_1 | ELECTROACOUSTIC
Port_670240_1 | ELECTROACOUSTIC
Port_671391_1 | SECURITY
Port_671395_1 | SECURITY
Port_671407_1 | ELECTROACOUSTIC
Port_671408_1 | ELECTROACOUSTIC
Port_671409_1 | SECURITY
Port_671410_1 | SECURITY
Port_671417_1 | ELECTROACOUSTIC
Port_671418_1 | ELECTROACOUSTIC
Port_671419_1 | SECURITY
Port_671420_1 | SECURITY
Port_671441_1 | ELECTROACOUSTIC
Port_671445_1 | ELECTROACOUSTIC
Port_672607_1 | ELECTRICAL
Port_672607_2 | ELECTROACOUSTIC
Port_672612_1 | ELECTRICAL
Port_672612_2 | ELECTROACOUSTIC
Port_672620_1 | ELECTRICAL
Port_672620_2 | ELECTROACOUSTIC
Port_672625_1 | ELECTRICAL
Port_672625_2 | ELECTROACOUSTIC
Port_672633_1 | ELECTRICAL
Port_672633_2 | ELECTROACOUSTIC
Port_672638_1 | ELECTRICAL
Port_672638_2 | ELECTROACOUSTIC
Port_672646_1 | ELECTRICAL
Port_672646_2 | ELECTROACOUSTIC
Port_673656_1 | ELECTROACOUSTIC
Port_673675_1 | ELECTROACOUSTIC
Port_673825_1 | ELECTROACOUSTIC
Port_673990_1 | ELECTROACOUSTIC
Port_692231_1 | ELECTROACOUSTIC
Port_692231_2 | SECURITY
Port_692231_3 | ELECTRICAL
Port_692233_1 | ELECTRICAL
Port_692233_2 | ELECTROACOUSTIC
Port_692240_1 | ELECTROACOUSTIC
Port_692240_2 | SECURITY
Port_692240_3 | ELECTRICAL
Port_692242_1 | ELECTRICAL
Port_692242_2 | ELECTROACOUSTIC
Port_714577_1 | ELECTROACOUSTIC
Port_714579_1 | ELECTROACOUSTIC
Port_716764_1 | ELECTROACOUSTIC
Port_716764_2 | DATA
Port_719491_1 | ELECTROACOUSTIC
Port_719550_1 | ELECTROACOUSTIC
Port_719631_1 | ELECTROACOUSTIC
Port_719632_1 | SECURITY
Port_719633_1 | ELECTRICAL
Port_719633_2 | ELECTROACOUSTIC
Port_721131_1 | ELECTROACOUSTIC
Port_721131_2 | SECURITY
Port_721131_3 | ELECTRICAL
Port_721135_1 | ELECTROACOUSTIC
Port_721135_2 | SECURITY
Port_721135_3 | ELECTRICAL
Port_721139_1 | ELECTROACOUSTIC
Port_721139_2 | SECURITY
Port_721139_3 | ELECTRICAL
Port_721143_1 | ELECTROACOUSTIC
Port_721143_2 | SECURITY
Port_721143_3 | ELECTRICAL
Port_721147_1 | ELECTROACOUSTIC
Port_721147_2 | SECURITY
Port_721147_3 | ELECTRICAL
Port_721151_1 | ELECTROACOUSTIC
Port_721151_2 | SECURITY
Port_721151_3 | ELECTRICAL
Port_721179_1 | ELECTROACOUSTIC
Port_721179_2 | SECURITY
Port_721179_3 | ELECTRICAL
Port_721183_1 | ELECTROACOUSTIC
Port_721183_2 | SECURITY
Port_721183_3 | ELECTRICAL
Port_721187_1 | ELECTROACOUSTIC
Port_721187_2 | SECURITY
Port_721187_3 | ELECTRICAL
Port_721191_1 | ELECTROACOUSTIC
Port_721191_2 | SECURITY
Port_721191_3 | ELECTRICAL
Port_722328_1 | ELECTROACOUSTIC
Port_722328_2 | SECURITY
Port_722328_3 | ELECTRICAL
Port_722332_1 | ELECTROACOUSTIC
Port_722332_2 | SECURITY
Port_722332_3 | ELECTRICAL
Port_722652_1 | ELECTROACOUSTIC
Port_722652_2 | ELECTRICAL
Port_727478_1 | ELECTROACOUSTIC
Port_727478_2 | SECURITY
Port_727478_3 | ELECTRICAL
Port_727495_1 | ELECTROACOUSTIC
Port_727495_2 | SECURITY
Port_727495_3 | ELECTRICAL
Port_727503_1 | ELECTROACOUSTIC
Port_727503_2 | SECURITY
Port_727503_3 | ELECTRICAL
Port_727513_1 | ELECTROACOUSTIC
Port_727513_2 | SECURITY
Port_727513_3 | ELECTRICAL
Port_727521_1 | ELECTROACOUSTIC
Port_727521_2 | SECURITY
Port_727521_3 | ELECTRICAL
Port_727529_1 | ELECTROACOUSTIC
Port_727529_2 | SECURITY
Port_727529_3 | ELECTRICAL
Port_727537_1 | ELECTROACOUSTIC
Port_727537_2 | SECURITY
Port_727537_3 | ELECTRICAL
Port_727547_1 | ELECTROACOUSTIC
Port_727547_2 | SECURITY
Port_727547_3 | ELECTRICAL
Port_727559_1 | ELECTROACOUSTIC
Port_727559_2 | SECURITY
Port_727559_3 | ELECTRICAL
Port_727567_1 | ELECTROACOUSTIC
Port_727567_2 | SECURITY
Port_727567_3 | ELECTRICAL
Port_727575_1 | ELECTROACOUSTIC
Port_727575_2 | SECURITY
Port_727575_3 | ELECTRICAL
Port_727583_1 | ELECTROACOUSTIC
Port_727583_2 | SECURITY
Port_727583_3 | ELECTRICAL
Port_727591_1 | ELECTROACOUSTIC
Port_727591_2 | SECURITY
Port_727591_3 | ELECTRICAL
Port_727601_1 | ELECTROACOUSTIC
Port_727601_2 | SECURITY
Port_727601_3 | ELECTRICAL
Port_727611_1 | ELECTROACOUSTIC
Port_727611_2 | SECURITY
Port_727611_3 | ELECTRICAL
Port_727623_1 | ELECTROACOUSTIC
Port_727623_2 | SECURITY
Port_727623_3 | ELECTRICAL
Port_727633_1 | ELECTROACOUSTIC
Port_727633_2 | SECURITY
Port_727633_3 | ELECTRICAL
Port_727643_1 | ELECTROACOUSTIC
Port_727643_2 | SECURITY
Port_727643_3 | ELECTRICAL
Port_727653_1 | ELECTROACOUSTIC
Port_727653_2 | SECURITY
Port_727653_3 | ELECTRICAL
Port_727661_1 | ELECTROACOUSTIC
Port_727661_2 | SECURITY
Port_727661_3 | ELECTRICAL
Port_727673_1 | ELECTROACOUSTIC
Port_727673_2 | SECURITY
Port_727673_3 | ELECTRICAL
Port_727681_1 | ELECTROACOUSTIC
Port_727681_2 | SECURITY
Port_727681_3 | ELECTRICAL
Port_727689_1 | ELECTROACOUSTIC
Port_727689_2 | SECURITY
Port_727689_3 | ELECTRICAL
