Properties of the parts of a building model (IFC4), part 3 of 3

# IfcLightFixture: PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu) (225)
Name (PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu):...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | Material
1023530 | 4.NP_SO-102 | 1018792 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0425 | 0425 | Výchozí zdroj světla, <Unnamed>
1023533 | 4.NP_SO-102 | 1018795 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0426 | 0426 | Výchozí zdroj světla, <Unnamed>
1023536 | 4.NP_SO-102 | 1018798 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0427 | 0427 | Výchozí zdroj světla, <Unnamed>
1023539 | 4.NP_SO-102 | 1018801 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0428 | 0428 | Výchozí zdroj světla, <Unnamed>
1023542 | 4.NP_SO-102 | 1018804 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0429 | 0429 | Výchozí zdroj světla, <Unnamed>
1023545 | 4.NP_SO-102 | 1018816 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0430 | 0430 | Výchozí zdroj světla, <Unnamed>
1023548 | 4.NP_SO-102 | 1018819 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0431 | 0431 | Výchozí zdroj světla, <Unnamed>
1023551 | 4.NP_SO-102 | 1023530 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0432 | 0432 | Výchozí zdroj světla, <Unnamed>
1023554 | 4.NP_SO-102 | 1023533 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0433 | 0433 | Výchozí zdroj světla, <Unnamed>
1023557 | 4.NP_SO-102 | 1023536 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0434 | 0434 | Výchozí zdroj světla, <Unnamed>
1023644 | 4.NP_SO-102 | 1023539 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0436 | 0436 | Výchozí zdroj světla, <Unnamed>
1023647 | 4.NP_SO-102 | 1023542 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0437 | 0437 | Výchozí zdroj světla, <Unnamed>
1023650 | 4.NP_SO-102 | 1023545 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0438 | 0438 | Výchozí zdroj světla, <Unnamed>
1023653 | 4.NP_SO-102 | 1023548 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0439 | 0439 | Výchozí zdroj světla, <Unnamed>
1023656 | 4.NP_SO-102 | 1023551 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0440 | 0440 | Výchozí zdroj světla, <Unnamed>
1023659 | 4.NP_SO-102 | 1023554 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0441 | 0441 | Výchozí zdroj světla, <Unnamed>
1024247 | 1.NP_SO-102 | 996492 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0448 | 0448 | Výchozí zdroj světla, <Unnamed>
1024250 | 1.NP_SO-102 | 996495 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0449 | 0449 | Výchozí zdroj světla, <Unnamed>
1024253 | 1.NP_SO-102 | 996498 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0450 | 0450 | Výchozí zdroj světla, <Unnamed>
1024256 | 1.NP_SO-102 | 996501 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0451 | 0451 | Výchozí zdroj světla, <Unnamed>
1024259 | 1.NP_SO-102 | 996507 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0452 | 0452 | Výchozí zdroj světla, <Unnamed>
1024268 | 1.NP_SO-102 | 996510 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0454 | 0454 | Výchozí zdroj světla, <Unnamed>
1026249 | 4.NP_SO-102 | 1072184 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0478 | 0478 | Výchozí zdroj světla, <Unnamed>
1026252 | 4.NP_SO-102 | 1072192 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0479 | 0479 | Výchozí zdroj světla, <Unnamed>
1026255 | 4.NP_SO-102 | 1072200 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0480 | 0480 | Výchozí zdroj světla, <Unnamed>
1026258 | 4.NP_SO-102 | 1072248 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0481 | 0481 | Výchozí zdroj světla, <Unnamed>
1026261 | 4.NP_SO-102 | 1072256 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0482 | 0482 | Výchozí zdroj světla, <Unnamed>
1026264 | 4.NP_SO-102 | 1072328 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0483 | 0483 | Výchozí zdroj světla, <Unnamed>
1026267 | 4.NP_SO-102 | 1072336 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0484 | 0484 | Výchozí zdroj světla, <Unnamed>
1026270 | 4.NP_SO-102 | 1026249 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0485 | 0485 | Výchozí zdroj světla, <Unnamed>
1026273 | 4.NP_SO-102 | 1026252 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0486 | 0486 | Výchozí zdroj světla, <Unnamed>
1026321 | 4.NP_SO-102 | 1026255 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0488 | 0488 | Výchozí zdroj světla, <Unnamed>
1067887 | 3.NP_SO-102 | 1026258 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0492 | 0492 | Výchozí zdroj světla, <Unnamed>
1068836 | 3.NP_SO-102 | 1015426 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0495 | 0495 | Výchozí zdroj světla, <Unnamed>
1068850 | 3.NP_SO-102 | 1015423 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0496 | 0496 | Výchozí zdroj světla, <Unnamed>
1069223 | 2.NP_SO-102 | 1023557 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0499 | 0499 | Výchozí zdroj světla, <Unnamed>
1069245 | 2.NP_SO-102 | 1023644 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0500 | 0500 | Výchozí zdroj světla, <Unnamed>
1069255 | 2.NP_SO-102 | 1023647 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0501 | 0501 | Výchozí zdroj světla, <Unnamed>
1069265 | 2.NP_SO-102 | 1023650 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0502 | 0502 | Výchozí zdroj světla, <Unnamed>
1069273 | 2.NP_SO-102 | 1023653 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0503 | 0503 | Výchozí zdroj světla, <Unnamed>
1069285 | 2.NP_SO-102 | 1023656 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0504 | 0504 | Výchozí zdroj světla, <Unnamed>
1069621 | 2.NP_SO-102 | 1023659 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0513 | 0513 | Výchozí zdroj světla, <Unnamed>
1069622 | 2.NP_SO-102 | 1069223 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0514 | 0514 | Výchozí zdroj světla, <Unnamed>
1069633 | 1.NP_SO-102 | 1069245 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0515 | 0515 | Výchozí zdroj světla, <Unnamed>
1069826 | -1.PP_SO-102 | 1069255 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0520 | 0520 | Výchozí zdroj světla, <Unnamed>
1069900 | -1.PP_SO-102 | 1069265 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0522 | 0522 | Výchozí zdroj světla, <Unnamed>
1069908 | -1.PP_SO-102 | 1069273 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0523 | 0523 | Výchozí zdroj světla, <Unnamed>
1070094 | -1.PP_SO-102 | 1069285 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0534 | 0534 | Výchozí zdroj světla, <Unnamed>
1070112 | 1.NP_SO-102 | 1069621 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0535 | 0535 | Výchozí zdroj světla, <Unnamed>
1070152 | 1.NP_SO-102 | 1069622 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0536 | 0536 | Výchozí zdroj světla, <Unnamed>
1070160 | 1.NP_SO-102 | 1069633 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0537 | 0537 | Výchozí zdroj světla, <Unnamed>
1070168 | 1.NP_SO-102 | 1069826 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0538 | 0538 | Výchozí zdroj světla, <Unnamed>
1070186 | 1.NP_SO-102 | 1069900 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0539 | 0539 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1070243 | 1.NP_SO-102 | 1069908 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0542 | 0542 | Výchozí zdroj světla, <Unnamed>
1070262 | 1.NP_SO-102 | 1070094 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0543 | 0543 | Výchozí zdroj světla, <Unnamed>
1070263 | 1.NP_SO-102 | 1070112 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0544 | 0544 | Výchozí zdroj světla, <Unnamed>
1070289 | 1.NP_SO-102 | 1070152 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0545 | 0545 | Výchozí zdroj světla, <Unnamed>
1070303 | 1.NP_SO-102 | 1070160 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0546 | 0546 | Výchozí zdroj světla, <Unnamed>
1070399 | 1.NP_SO-102 | 1070168 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0548 | 0548 | Výchozí zdroj světla, <Unnamed>
1070407 | 1.NP_SO-102 | 1070186 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0549 | 0549 | Výchozí zdroj světla, <Unnamed>
1070441 | 1.NP_SO-102 | 1070243 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0550 | 0550 | Výchozí zdroj světla, <Unnamed>
1070481 | 1.NP_SO-102 | 1070262 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0551 | 0551 | Výchozí zdroj světla, <Unnamed>
1070493 | 1.NP_SO-102 | 1070263 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0552 | 0552 | Výchozí zdroj světla, <Unnamed>
1070516 | 1.NP_SO-102 | 1070289 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0553 | 0553 | Výchozí zdroj světla, <Unnamed>
1070545 | 1.NP_SO-102 | 1070303 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0554 | 0554 | Výchozí zdroj světla, <Unnamed>
1070553 | 1.NP_SO-102 | 1070399 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0555 | 0555 | Výchozí zdroj světla, <Unnamed>
1070565 | 1.NP_SO-102 | 1070407 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0556 | 0556 | Výchozí zdroj světla, <Unnamed>
1070577 | 1.NP_SO-102 | 1070441 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0557 | 0557 | Výchozí zdroj světla, <Unnamed>
1070607 | 1.NP_SO-102 | 1070481 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0558 | 0558 | Výchozí zdroj světla, <Unnamed>
1070635 | 1.NP_SO-102 | 1070493 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0559 | 0559 | Výchozí zdroj světla, <Unnamed>
1070645 | 1.NP_SO-102 | 1070516 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0560 | 0560 | Výchozí zdroj světla, <Unnamed>
1070653 | 1.NP_SO-102 | 1070545 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0561 | 0561 | Výchozí zdroj světla, <Unnamed>
1070661 | 1.NP_SO-102 | 1070553 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0562 | 0562 | Výchozí zdroj světla, <Unnamed>
1070669 | 1.NP_SO-102 | 1070565 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0563 | 0563 | Výchozí zdroj světla, <Unnamed>
1070753 | 2.NP_SO-102 | 1070577 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0566 | 0566 | Výchozí zdroj světla, <Unnamed>
1070763 | 2.NP_SO-102 | 1070607 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0567 | 0567 | Výchozí zdroj světla, <Unnamed>
1070769 | 2.NP_SO-102 | 1070635 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0568 | 0568 | Výchozí zdroj světla, <Unnamed>
1070779 | 2.NP_SO-102 | 1070645 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0569 | 0569 | Výchozí zdroj světla, <Unnamed>
1070787 | 2.NP_SO-102 | 1070653 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0570 | 0570 | Výchozí zdroj světla, <Unnamed>
1070795 | 2.NP_SO-102 | 1070661 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0571 | 0571 | Výchozí zdroj světla, <Unnamed>
1070815 | 2.NP_SO-102 | 1070669 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0572 | 0572 | Výchozí zdroj světla, <Unnamed>
1070832 | 2.NP_SO-102 | 1070753 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0573 | 0573 | Výchozí zdroj světla, <Unnamed>
1070861 | 2.NP_SO-102 | 1070763 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0574 | 0574 | Výchozí zdroj světla, <Unnamed>
1070869 | 2.NP_SO-102 | 1070769 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0575 | 0575 | Výchozí zdroj světla, <Unnamed>
1070887 | 2.NP_SO-102 | 1070779 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0576 | 0576 | Výchozí zdroj světla, <Unnamed>
1070930 | 2.NP_SO-102 | 1070787 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0577 | 0577 | Výchozí zdroj světla, <Unnamed>
1070938 | 2.NP_SO-102 | 1070795 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0578 | 0578 | Výchozí zdroj světla, <Unnamed>
1070961 | 2.NP_SO-102 | 1070815 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0579 | 0579 | Výchozí zdroj světla, <Unnamed>
1070969 | 2.NP_SO-102 | 1070832 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0580 | 0580 | Výchozí zdroj světla, <Unnamed>
1070979 | 2.NP_SO-102 | 1070861 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0581 | 0581 | Výchozí zdroj světla, <Unnamed>
1070989 | 2.NP_SO-102 | 1070869 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0582 | 0582 | Výchozí zdroj světla, <Unnamed>
1070997 | 2.NP_SO-102 | 1070887 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0583 | 0583 | Výchozí zdroj světla, <Unnamed>
1071005 | 2.NP_SO-102 | 1070930 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0584 | 0584 | Výchozí zdroj světla, <Unnamed>
1071013 | 2.NP_SO-102 | 1070938 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0585 | 0585 | Výchozí zdroj světla, <Unnamed>
1071025 | 2.NP_SO-102 | 1070961 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0586 | 0586 | Výchozí zdroj světla, <Unnamed>
1071033 | 2.NP_SO-102 | 1070969 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0587 | 0587 | Výchozí zdroj světla, <Unnamed>
1071041 | 2.NP_SO-102 | 1070979 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0588 | 0588 | Výchozí zdroj světla, <Unnamed>
1071049 | 2.NP_SO-102 | 1070989 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0589 | 0589 | Výchozí zdroj světla, <Unnamed>
1071057 | 2.NP_SO-102 | 1070997 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0590 | 0590 | Výchozí zdroj světla, <Unnamed>
1071065 | 2.NP_SO-102 | 1071005 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0591 | 0591 | Výchozí zdroj světla, <Unnamed>
1071075 | 2.NP_SO-102 | 1071013 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0592 | 0592 | Výchozí zdroj světla, <Unnamed>
1071235 | 2.NP_SO-102 | 1071025 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0595 | 0595 | Výchozí zdroj světla, <Unnamed>
1071275 | 2.NP_SO-102 | 1071033 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0596 | 0596 | Výchozí zdroj světla, <Unnamed>
1071303 | 2.NP_SO-102 | 1071041 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0597 | 0597 | Výchozí zdroj světla, <Unnamed>
1071328 | 2.NP_SO-102 | 1071049 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0598 | 0598 | Výchozí zdroj světla, <Unnamed>
1071336 | 2.NP_SO-102 | 1071057 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0599 | 0599 | Výchozí zdroj světla, <Unnamed>
1071344 | 2.NP_SO-102 | 1071065 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0600 | 0600 | Výchozí zdroj světla, <Unnamed>
1071361 | 2.NP_SO-102 | 1071075 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0601 | 0601 | Výchozí zdroj světla, <Unnamed>
1071491 | 2.NP_SO-102 | 1071235 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0605 | 0605 | Výchozí zdroj světla, <Unnamed>
1071499 | 2.NP_SO-102 | 1071275 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0606 | 0606 | Výchozí zdroj světla, <Unnamed>
1071505 | 2.NP_SO-102 | 1071303 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0607 | 0607 | Výchozí zdroj světla, <Unnamed>
1071513 | 2.NP_SO-102 | 1071328 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0608 | 0608 | Výchozí zdroj světla, <Unnamed>
1071521 | 2.NP_SO-102 | 1071336 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0609 | 0609 | Výchozí zdroj světla, <Unnamed>
1071533 | 2.NP_SO-102 | 1071344 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0610 | 0610 | Výchozí zdroj světla, <Unnamed>
1071541 | 2.NP_SO-102 | 1071361 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0611 | 0611 | Výchozí zdroj světla, <Unnamed>
1071549 | 2.NP_SO-102 | 1071491 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0612 | 0612 | Výchozí zdroj světla, <Unnamed>
1071557 | 2.NP_SO-102 | 1071499 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0613 | 0613 | Výchozí zdroj světla, <Unnamed>
1071565 | 2.NP_SO-102 | 1071505 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0614 | 0614 | Výchozí zdroj světla, <Unnamed>
1071573 | 2.NP_SO-102 | 1071513 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0615 | 0615 | Výchozí zdroj světla, <Unnamed>
1071579 | 2.NP_SO-102 | 1071521 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0616 | 0616 | Výchozí zdroj světla, <Unnamed>
1071770 | 2.NP_SO-102 | 1071533 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0622 | 0622 | Výchozí zdroj světla, <Unnamed>
1071836 | 2.NP_SO-102 | 1071541 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0625 | 0625 | Výchozí zdroj světla, <Unnamed>
1071844 | 2.NP_SO-102 | 1071549 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0626 | 0626 | Výchozí zdroj světla, <Unnamed>
1071852 | 2.NP_SO-102 | 1071557 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0627 | 0627 | Výchozí zdroj světla, <Unnamed>
1071862 | 2.NP_SO-102 | 1071565 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0628 | 0628 | Výchozí zdroj světla, <Unnamed>
1071870 | 2.NP_SO-102 | 1071573 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0629 | 0629 | Výchozí zdroj světla, <Unnamed>
1071878 | 2.NP_SO-102 | 1071579 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0630 | 0630 | Výchozí zdroj světla, <Unnamed>
1071886 | 2.NP_SO-102 | 1071770 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0631 | 0631 | Výchozí zdroj světla, <Unnamed>
1071931 | 3.NP_SO-102 | 1071836 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0632 | 0632 | Výchozí zdroj světla, <Unnamed>
1071939 | 3.NP_SO-102 | 1071844 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0633 | 0633 | Výchozí zdroj světla, <Unnamed>
1071949 | 3.NP_SO-102 | 1071852 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0634 | 0634 | Výchozí zdroj světla, <Unnamed>
1071957 | 3.NP_SO-102 | 1071862 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0635 | 0635 | Výchozí zdroj světla, <Unnamed>
1071965 | 3.NP_SO-102 | 1071870 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0636 | 0636 | Výchozí zdroj světla, <Unnamed>
1072159 | 3.NP_SO-102 | 1071878 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0638 | 0638 | Výchozí zdroj světla, <Unnamed>
1072184 | 3.NP_SO-102 | 1071886 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0639 | 0639 | Výchozí zdroj světla, <Unnamed>
1072192 | 3.NP_SO-102 | 1071931 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0640 | 0640 | Výchozí zdroj světla, <Unnamed>
1072200 | 3.NP_SO-102 | 1071939 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0641 | 0641 | Výchozí zdroj světla, <Unnamed>
1072248 | 4.NP_SO-102 | 1071949 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0643 | 0643 | Výchozí zdroj světla, <Unnamed>
1072256 | 4.NP_SO-102 | 1071957 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0644 | 0644 | Výchozí zdroj světla, <Unnamed>
1072328 | 4.NP_SO-102 | 1071965 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0648 | 0648 | Výchozí zdroj světla, <Unnamed>
1072336 | 4.NP_SO-102 | 1072159 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0649 | 0649 | Výchozí zdroj světla, <Unnamed>

# IfcLightFixture: PF_úniková tabulka (dveře doprava):PF_úniková tabulka (dveře doprava) (18)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře doprava); Označení typu: 04; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře doprava)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: Q; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Přesunout s blízkými prvky: no
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 972080; Rodina: PF_úniková tabulka (dveře doprava); Rodina a typ: PF_úniková tabulka (dveře doprava): PF_úniková tabulka (dveře doprava); Typ: PF_úniková tabulka (dveře doprava); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:03
Name (PF_úniková tabulka (dveře doprava):PF_úniková tabulka (dveře doprava):...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení | Material
986993 | -1.PP_SO-102 | 1026261 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0072 | 0072
986999 | -1.PP_SO-102 | 1026264 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0073 | 0073 | Výchozí zdroj světla, <Unnamed>
987023 | -1.PP_SO-102 | 1026267 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0074 | 0074 | Výchozí zdroj světla, <Unnamed>
987024 | -1.PP_SO-102 | 1026270 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0075 | 0075 | Výchozí zdroj světla, <Unnamed>
987036 | -1.PP_SO-102 | 1026273 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0076 | 0076 | Výchozí zdroj světla, <Unnamed>
987987 | -1.PP_SO-102 | 1026321 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0124 | 0124 | Výchozí zdroj světla, <Unnamed>
987993 | -1.PP_SO-102 | 1067887 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.04.0125 | 0125 | Výchozí zdroj světla, <Unnamed>
987996 | -1.PP_SO-102 | PF_úniková tabulka (dveře doprava) | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.04.0126 | 0126 | Výchozí zdroj světla, <Unnamed>
987999 | -1.PP_SO-102 | 986993 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.04.0127 | 0127 | Výchozí zdroj světla, <Unnamed>
988002 | -1.PP_SO-102 | 986999 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.04.0128 | 0128 | Výchozí zdroj světla, <Unnamed>
996513 | 1.NP_SO-102 | 987023 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.04.0197 | 0197 | Výchozí zdroj světla, <Unnamed>
996516 | 1.NP_SO-102 | 987024 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.04.0198 | 0198 | Výchozí zdroj světla, <Unnamed>
1018810 | 3.NP_SO-102 | 987036 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | OS03.04.0389 | 0389 | Výchozí zdroj světla, <Unnamed>
1070076 | -1.PP_SO-102 | 987987 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.04.0533 | 0533 | Výchozí zdroj světla, <Unnamed>
1071780 | 2.NP_SO-102 | 987993 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.04.0623 | 0623 | Výchozí zdroj světla, <Unnamed>
1071800 | 2.NP_SO-102 | 987996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.04.0624 | 0624 | Výchozí zdroj světla, <Unnamed>
1072312 | 4.NP_SO-102 | 987999 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.04.0647 | 0647 | Výchozí zdroj světla, <Unnamed>
1108155 | 1.NP_SO-102 | 987024 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.04.0658 | 0658 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1

# IfcLightFixture: PF_úniková tabulka (schody):PF_úniková tabulka (schody) (35)
Type - Material: <Unnamed>
Type - Fotometrika - Barevný filtr: 16777215; Celkový faktor světelné ztráty: 1; Definice zdroje světla (rodina): Bod+Kulová; Faktor světelné ztráty: 0; Osvětlení: 11.8206 lx; Počáteční barva: 0; Počáteční intenzita: 0; Počáteční teplota barvy: 3000 K; Posunu barevné teploty při stmívání lampy: <Žádné>; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Velikost symbolu zdroje světla: 609.6 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (schody); Označení typu: 02; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (schody)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - CCI Funkční systém: Q; CCI Komponenta: EAA; CCI Technický systém: ME; Označení pořadí svítidla: 1; Označení typu (A-Z): NZ
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Přesunout s blízkými prvky: no
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 968954; Rodina: PF_úniková tabulka (schody); Rodina a typ: PF_úniková tabulka (schody): PF_úniková tabulka (schody); Typ: PF_úniková tabulka (schody); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:04
Name (PF_úniková tabulka (schody):PF_úniková tabulka (schody):...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení | Material
975285 | -2.PP_SO-102 | 988002 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | OS03.02.0007 | 0007
988048 | -1.PP_SO-102 | 996513 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.02.0132 | 0132 | Výchozí zdroj světla, <Unnamed>
988051 | -1.PP_SO-102 | 996516 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.02.0133 | 0133 | Výchozí zdroj světla, <Unnamed>
988054 | -1.PP_SO-102 | 1018810 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.02.0134 | 0134 | Výchozí zdroj světla, <Unnamed>
988060 | -1.PP_SO-102 | 1070076 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.02.0135 | 0135 | Výchozí zdroj světla, <Unnamed>
988063 | -1.PP_SO-102 | 1071780 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.02.0136 | 0136 | Výchozí zdroj světla, <Unnamed>
988066 | -1.PP_SO-102 | 1071800 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.02.0137 | 0137 | Výchozí zdroj světla, <Unnamed>
988069 | -1.PP_SO-102 | 1072312 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.02.0138 | 0138 | Výchozí zdroj světla, <Unnamed>
1009545 | 2.NP_SO-102 | 975285 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.02.0280 | 0280 | Výchozí zdroj světla, <Unnamed>
1009548 | 2.NP_SO-102 | 988048 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.02.0281 | 0281 | Výchozí zdroj světla, <Unnamed>
1009551 | 2.NP_SO-102 | 988051 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.02.0282 | 0282 | Výchozí zdroj světla, <Unnamed>
1009554 | 2.NP_SO-102 | 988054 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.02.0283 | 0283 | Výchozí zdroj světla, <Unnamed>
1009557 | 2.NP_SO-102 | 988060 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | OS03.02.0284 | 0284 | Výchozí zdroj světla, <Unnamed>
1009560 | 2.NP_SO-102 | 988063 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | OS03.02.0285 | 0285 | Výchozí zdroj světla, <Unnamed>
1015305 | 3.NP_SO-102 | 988066 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0332 | 0332 | Výchozí zdroj světla, <Unnamed>
1015308 | 3.NP_SO-102 | 988069 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0333 | 0333 | Výchozí zdroj světla, <Unnamed>
1015311 | 3.NP_SO-102 | 1024265 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0334 | 0334 | Výchozí zdroj světla, <Unnamed>
1015314 | 3.NP_SO-102 | 1009545 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0335 | 0335 | Výchozí zdroj světla, <Unnamed>
1015360 | 3.NP_SO-102 | 1009548 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0337 | 0337 | Výchozí zdroj světla, <Unnamed>
1018825 | 3.NP_SO-102 | 1009551 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | OS03.02.0392 | 0392 | Výchozí zdroj světla, <Unnamed>
1018828 | 3.NP_SO-102 | 1009554 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | OS03.02.0393 | 0393 | Výchozí zdroj světla, <Unnamed>
1023676 | 4.NP_SO-102 | 1009557 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0443 | 0443 | Výchozí zdroj světla, <Unnamed>
1023679 | 4.NP_SO-102 | 1009560 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0444 | 0444 | Výchozí zdroj světla, <Unnamed>
1023682 | 4.NP_SO-102 | 1015305 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0445 | 0445 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1023685 | 4.NP_SO-102 | 1015308 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0446 | 0446 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1023688 | 4.NP_SO-102 | 1015311 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | OS03.02.0447 | 0447 | Výchozí zdroj světla, <Unnamed>
1024265 | 1.NP_SO-102 | PF_úniková tabulka (schody) | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.02.0453 | 0453 | Výchozí zdroj světla, <Unnamed>
1070205 | 1.NP_SO-102 | 1015314 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.02.0540 | 0540 | Výchozí zdroj světla, <Unnamed>
1070224 | 1.NP_SO-102 | 1015360 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.02.0541 | 0541 | Výchozí zdroj světla, <Unnamed>
1070696 | 1.NP_SO-102 | 1018825 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OS03.02.0564 | 0564 | Výchozí zdroj světla, <Unnamed>
1070704 | 1.NP_SO-102 | 1018828 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OS03.02.0565 | 0565 | Výchozí zdroj světla, <Unnamed>
1072222 | 4.NP_SO-102 | 1023676 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0642 | 0642 | Výchozí zdroj světla, <Unnamed>
1072399 | 4.NP_SO-102 | 1023679 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.02.0650 | 0650 | Výchozí zdroj světla, <Unnamed>
1072447 | 3.NP_SO-102 | 1023682 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0651 | 0651 | Výchozí zdroj světla, <Unnamed>
1072468 | 3.NP_SO-102 | 1023685 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.02.0652 | 0652 | Výchozí zdroj světla, <Unnamed>
