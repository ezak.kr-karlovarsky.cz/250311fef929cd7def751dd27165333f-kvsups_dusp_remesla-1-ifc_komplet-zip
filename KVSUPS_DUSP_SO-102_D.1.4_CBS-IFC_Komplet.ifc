Properties of the parts of a building model (IFC4), part 2 of 3

# IfcLightFixture: Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS (363)
Name (Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS:...) | In | NAPÁJENÍ_ČÍSLO OKRUHU = Číslo okruhu = Group | NAPÁJENÍ_ROZVADĚČ = Rozvaděč | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
1005923 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006180 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0254 | 0254 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006180 | 2.NP_SO-102 |  |  | 996464 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0255 | 0255 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006559 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004123 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0256 | 0256 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006607 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994979 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0257 | 0257 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006715 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1003753 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0258 | 0258 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006746 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1002887 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0259 | 0259 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006877 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010068 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0260 | 0260 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1006939 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995906 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0261 | 0261 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007000 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005522 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0262 | 0262 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007060 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996291 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0263 | 0263 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007115 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004381 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0264 | 0264 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007295 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005013 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0265 | 0265 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007501 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995328 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0266 | 0266 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1007960 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997668 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0267 | 0267 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008098 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996818 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0268 | 0268 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008199 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009224 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0269 | 0269 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008283 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008199 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0270 | 0270 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008463 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993026 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0271 | 0271 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008545 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008935 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0272 | 0272 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1008935 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008098 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0273 | 0273 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009129 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009195 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0274 | 0274 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009178 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008463 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0275 | 0275 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009195 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007960 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0276 | 0276 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009224 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993146 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0277 | 0277 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009342 | 2.NP_SO-102 | 38 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009419 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0278 | 0278 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009419 | 2.NP_SO-102 | 39 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997822 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0279 | 0279 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1009567 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1003080 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0286 | 0286 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010068 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007060 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0287 | 0287 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010509 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010714 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0288 | 0288 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010522 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012252 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0289 | 0289 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010624 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015327 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0290 | 0290 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010648 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012163 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0291 | 0291 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010714 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012000 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0292 | 0292 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010798 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011201 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1010970 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013252 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011085 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015044 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2150 | Fáze 1 | OS03.01.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011145 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014509 | 3.NP_SO-102 | Osamocené | 343.703 | Fáze 1 | OS03.01.0296 | 0296 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011201 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015454 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0297 | 0297 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011258 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012304 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0298 | 0298 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011328 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010648 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0299 | 0299 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1011485 | 3.NP_SO-102 |  |  | 1011328 | 3.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0300 | 0300 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01 | Fázování - Fáze demolice: Fáze 1
1011837 | 3.NP_SO-102 |  |  | 1012633 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0301 | 0301 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1011881 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010509 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | -141.418 | Fáze 1 | OS03.01.0302 | 0302 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012000 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013440 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | -58.9795 | Fáze 1 | OS03.01.0303 | 0303 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012140 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010970 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | -40.7364 | Fáze 1 | OS03.01.0304 | 0304 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012163 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010624 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0305 | 0305 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012252 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1068590 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0306 | 0306 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012304 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010522 | 3.NP_SO-102 | Osamocené | 261.486 | Fáze 1 | OS03.01.0307 | 0307 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012339 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014682 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0308 | 0308 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012572 | 3.NP_SO-102 | 24 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1010798 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1012633 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014918 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0310 | 0310 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013252 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011837 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0311 | 0311 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013440 | 3.NP_SO-102 | 22 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013894 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0312 | 0312 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013571 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014928 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0313 | 0313 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013760 | 3.NP_SO-102 |  |  | 1001663 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0314 | 0314 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013894 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015135 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0315 | 0315 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1013981 | 3.NP_SO-102 |  |  | 1015181 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0316 | 0316 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1014039 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000748 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0317 | 0317 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014423 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000238 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0318 | 0318 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014509 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015064 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0319 | 0319 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014647 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014039 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0320 | 0320 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014682 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014731 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0321 | 0321 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014731 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014423 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0322 | 0322 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014804 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014647 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0323 | 0323 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014918 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011145 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0324 | 0324 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1014928 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000544 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0325 | 0325 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015044 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012339 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0326 | 0326 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015064 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015200 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0327 | 0327 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015135 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013981 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0328 | 0328 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015154 | 3.NP_SO-102 | 20 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013571 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0329 | 0329 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015181 | 3.NP_SO-102 | 19 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1013760 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0330 | 0330 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015200 | 3.NP_SO-102 |  |  | 1068440 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1015327 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1015154 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0336 | 0336 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015454 | 3.NP_SO-102 | 23 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011085 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0363 | 0363 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1015467 | 3.NP_SO-102 | 21 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1014804 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0364 | 0364 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016025 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006559 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0365 | 0365 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016032 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004525 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0366 | 0366 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016412 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009342 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0367 | 0367 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016424 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017593 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0368 | 0368 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016567 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009178 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0369 | 0369 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016691 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017657 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0370 | 0370 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016770 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016881 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0371 | 0371 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016793 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016934 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0372 | 0372 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016881 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017730 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0373 | 0373 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1016934 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009129 | 3.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0374 | 0374 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1017516 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018276 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0375 | 0375 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1017593 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008545 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0376 | 0376 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1017614 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016793 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0377 | 0377 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1017657 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1008283 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0378 | 0378 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1017682 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016424 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0379 | 0379 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1017730 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016412 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0380 | 0380 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1018170 | 3.NP_SO-102 | 41 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016691 | 3.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0381 | 0381 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1018276 | 3.NP_SO-102 | 40 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016567 | 3.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0382 | 0382 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1018848 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1071636 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0394 | 0394 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1018856 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1019596 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0395 | 0395 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1018908 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012140 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0396 | 0396 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1018929 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011881 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0397 | 0397 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1019057 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1020185 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0398 | 0398 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1019596 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1012572 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0399 | 0399 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1019786 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1023177 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0400 | 0400 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1019948 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1019057 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0401 | 0401 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1020185 | 4.NP_SO-102 |  |  | 1023282 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0402 | 0402 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1020436 | 4.NP_SO-102 |  |  | 1021794 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0403 | 0403 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1020484 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018929 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0404 | 0404 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1020627 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018856 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0405 | 0405 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1020792 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1072286 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0406 | 0406 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1020815 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018908 | 4.NP_SO-102 | Osamocené | 125.184 | Fáze 1 | OS03.01.0407 | 0407 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1020857 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018848 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0408 | 0408 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1021225 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1020484 | 4.NP_SO-102 | Osamocené | 1945 | Fáze 1 | OS03.01.0409 | 0409 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1021324 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1071642 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0410 | 0410 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1021506 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1072103 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0411 | 0411 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1021794 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1019786 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0412 | 0412 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1021913 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1072279 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0413 | 0413 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022310 | 4.NP_SO-102 | 26 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1020815 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0414 | 0414 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1022400 | 4.NP_SO-102 | 28 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1021506 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0415 | 0415 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1022580 | 4.NP_SO-102 | 29 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1023564 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0416 | 0416 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022643 | 4.NP_SO-102 | 28 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1021913 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0417 | 0417 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022807 | 4.NP_SO-102 | 29 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022844 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0418 | 0418 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022844 | 4.NP_SO-102 | 28 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1020792 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0419 | 0419 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022867 | 4.NP_SO-102 | 29 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022400 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0420 | 0420 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1022954 | 4.NP_SO-102 | 29 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022643 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0421 | 0421 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1022984 | 4.NP_SO-102 | 28 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1020857 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0422 | 0422 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1023177 | 3.NP_SO-102 |  |  | 1011258 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 0 | Fáze 1 | OS03.01.0423 | 0423 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1023282 | 4.NP_SO-102 | 25 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1011485 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0424 | 0424 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1023564 | 4.NP_SO-102 | 27 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1021324 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0435 | 0435 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1024314 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998401 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0459 | 0459 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024323 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992142 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0460 | 0460 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024640 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025251 | 4.NP_SO-102 | Osamocené | 247.281 | Fáze 2 | OS03.01.0461 | 0461 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024655 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025078 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0462 | 0462 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024719 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025507 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0463 | 0463 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024805 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025571 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0464 | 0464 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1024900 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025834 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0465 | 0465 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1025039 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024719 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0466 | 0466 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025078 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016770 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0467 | 0467 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025251 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1026057 | 4.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0468 | 0468 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1025457 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024655 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0469 | 0469 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025507 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1018170 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0470 | 0470 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025571 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1026296 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0471 | 0471 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025779 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024640 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0472 | 0472 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025834 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1025984 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0473 | 0473 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025893 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024900 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0474 | 0474 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1025984 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017614 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0475 | 0475 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1026004 | 4.NP_SO-102 | 43 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024805 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0476 | 0476 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1026057 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017516 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0477 | 0477 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1026296 | 4.NP_SO-102 | 42 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1017682 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0487 | 0487 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1067722 | 2.NP_SO-102 |  |  | 1025039 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0489 | 0489 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1067729 | 2.NP_SO-102 |  |  | 1025457 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0490 | 0490 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1067866 | 3.NP_SO-102 |  |  | 1025779 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0491 | 0491 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1068440 | 2.NP_SO-102 |  |  | 1000619 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0493 | 0493 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1068590 | 3.NP_SO-102 |  |  | 1015467 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0494 | 0494 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1068946 | 4.NP_SO-102 |  |  | 1021225 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0497 | 0497 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1069345 | 2.NP_SO-102 |  |  | 1022310 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0505 | 0505 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1069379 | 2.NP_SO-102 |  |  | 1020627 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0506 | 0506 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1069481 | 2.NP_SO-102 |  |  | 1020436 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0507 | 0507 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069482 | 2.NP_SO-102 |  |  | 1019948 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0508 | 0508 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069534 | 3.NP_SO-102 |  |  | 1068946 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0509 | 0509 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069540 | 3.NP_SO-102 |  |  | 1069345 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0510 | 0510 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069617 | 2.NP_SO-102 |  |  | 1069379 | 2.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0511 | 0511 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1069618 | 2.NP_SO-102 |  |  | 1069481 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0512 | 0512 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069653 | 4.NP_SO-102 |  |  | 1069482 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0516 | 0516 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069654 | 4.NP_SO-102 |  |  | 1069534 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0517 | 0517 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069682 | -1.PP_SO-102 |  |  | 1069540 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0518 | 0518 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069731 | -1.PP_SO-102 |  |  | 1069617 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0519 | 0519 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1069844 | 1.NP_SO-102 |  |  | 1069653 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0521 | 0521 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
1070357 | 1.NP_SO-102 |  |  | 1069654 | 1.NP_SO-102 | Osamocené | 385.181 | Fáze 1 | OS03.01.0547 | 0547 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071113 | 2.NP_SO-102 |  |  | 1069682 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0593 | 0593 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071171 | 2.NP_SO-102 |  |  | 1069731 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0594 | 0594 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071402 | 2.NP_SO-102 |  |  | 1069782 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0602 | 0602 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071409 | 2.NP_SO-102 |  |  | 1069844 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0603 | 0603 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071415 | 2.NP_SO-102 |  |  | 1070357 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0604 | 0604 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071617 | 2.NP_SO-102 |  |  | 1071113 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2350 | Fáze 1 | OS03.01.0617 | 0617 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071624 | 2.NP_SO-102 |  |  | 1071171 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2350 | Fáze 1 | OS03.01.0618 | 0618 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071630 | 2.NP_SO-102 |  |  | 1071402 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0619 | 0619 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071636 | 2.NP_SO-102 |  |  | 1071409 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2350 | Fáze 1 | OS03.01.0620 | 0620 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1071642 | 1.NP_SO-102 |  |  | 1071415 | 1.NP_SO-102 | Osamocené | 4205.46 | Fáze 1 | OS03.01.0621 | 0621 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1072103 | 3.NP_SO-102 |  |  | 1071617 | 3.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0637 | 0637 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1072279 | 4.NP_SO-102 |  |  | 1071624 | 4.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0645 | 0645 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1072286 | 4.NP_SO-102 |  |  | 1071630 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0646 | 0646 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1107310 | -1.PP_SO-102 |  |  | 977560 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0653 | 0653 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1108059 | 1.NP_SO-102 |  |  | 994446 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0654 | 0654 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1108066 | 1.NP_SO-102 |  |  | 994446 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0655 | 0655 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1108087 | 1.NP_SO-102 |  |  | 994446 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0656 | 0656 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1108093 | 1.NP_SO-102 |  |  | 994446 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0657 | 0657 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56

# IfcLightFixture: PF_úniková tabulka (dveře doleva):PF_úniková tabulka (dveře doleva) (17)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře doleva); Označení typu: 05; Popis: Svítidlo; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře doleva)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: Q; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Přesunout s blízkými prvky: no
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 969988; Rodina: PF_úniková tabulka (dveře doleva); Rodina a typ: PF_úniková tabulka (dveře doleva): PF_úniková tabulka (dveře doleva); Typ: PF_úniková tabulka (dveře doleva); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:03
Name (PF_úniková tabulka (dveře doleva):PF_úniková tabulka (dveře doleva):...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení | Material
988014 | -1.PP_SO-102 | 1025893 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.05.0129 | 0129
1015378 | 3.NP_SO-102 | PF_úniková tabulka (dveře doleva) | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OS03.05.0342 | 0342 | Výchozí zdroj světla, <Unnamed>
1023662 | 4.NP_SO-102 | 988014 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OS03.05.0442 | 0442 | Výchozí zdroj světla, <Unnamed>
1024271 | 1.NP_SO-102 | 1026004 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.05.0455 | 0455 | Výchozí zdroj světla, <Unnamed>
1024274 | 1.NP_SO-102 | 1067722 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.05.0456 | 0456 | Výchozí zdroj světla, <Unnamed>
1024277 | 1.NP_SO-102 | 1067729 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.05.0457 | 0457 | Výchozí zdroj světla, <Unnamed>
1024302 | 1.NP_SO-102 | 1067866 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OS03.05.0458 | 0458 | Výchozí zdroj světla, <Unnamed>
1069196 | 2.NP_SO-102 | 1024271 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OS03.05.0498 | 0498 | Výchozí zdroj světla, <Unnamed>
1069918 | -1.PP_SO-102 | 1024274 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0524 | 0524 | Výchozí zdroj světla, <Unnamed>
1069941 | -1.PP_SO-102 | 1024277 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0525 | 0525 | Výchozí zdroj světla, <Unnamed>
1069951 | -1.PP_SO-102 | 1024302 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0526 | 0526 | Výchozí zdroj světla, <Unnamed>
1069970 | -1.PP_SO-102 | 1015378 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0527 | 0527 | Výchozí zdroj světla, <Unnamed>
1069971 | -1.PP_SO-102 | 1023662 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0528 | 0528 | Výchozí zdroj světla, <Unnamed>
1070007 | -1.PP_SO-102 | 1069196 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0529 | 0529 | Výchozí zdroj světla, <Unnamed>
1070008 | -1.PP_SO-102 | 1069918 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OS03.05.0530 | 0530 | Výchozí zdroj světla, <Unnamed>
1070018 | -1.PP_SO-102 | 1069941 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.05.0531 | 0531 | Výchozí zdroj světla, <Unnamed>
1070019 | -1.PP_SO-102 | 1069951 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OS03.05.0532 | 0532 | Výchozí zdroj světla, <Unnamed>

# IfcLightFixture: PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu) (225)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře dolu); Označení typu: 03; Popis: Svítidlo; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře dolu)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: Q; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Přesunout s blízkými prvky: no
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 971034; Rodina: PF_úniková tabulka (dveře dolu); Rodina a typ: PF_úniková tabulka (dveře dolu): PF_úniková tabulka (dveře dolu); Typ: PF_úniková tabulka (dveře dolu); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 06:52
Name (PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu):...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | Material
975316 | -2.PP_SO-102 | 1069970 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0008 | 0008
975319 | -2.PP_SO-102 | 1069971 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0009 | 0009 | Výchozí zdroj světla, <Unnamed>
975324 | -2.PP_SO-102 | 1070007 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1750 | Fáze 1 | OS03.03.0010 | 0010 | Výchozí zdroj světla, <Unnamed>
975327 | -2.PP_SO-102 | 1070008 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1750 | Fáze 1 | OS03.03.0011 | 0011 | Výchozí zdroj světla, <Unnamed>
975332 | -2.PP_SO-102 | 1070018 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0012 | 0012 | Výchozí zdroj světla, <Unnamed>
987844 | -1.PP_SO-102 | 1070019 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0085 | 0085 | Výchozí zdroj světla, <Unnamed>
987847 | -1.PP_SO-102 | PF_úniková tabulka (dveře dolu) | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0086 | 0086 | Výchozí zdroj světla, <Unnamed>
987850 | -1.PP_SO-102 | 975316 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0087 | 0087 | Výchozí zdroj světla, <Unnamed>
987853 | -1.PP_SO-102 | 975319 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0088 | 0088 | Výchozí zdroj světla, <Unnamed>
987856 | -1.PP_SO-102 | 975324 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0089 | 0089 | Výchozí zdroj světla, <Unnamed>
987859 | -1.PP_SO-102 | 975327 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0090 | 0090 | Výchozí zdroj světla, <Unnamed>
987862 | -1.PP_SO-102 | 975332 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0091 | 0091 | Výchozí zdroj světla, <Unnamed>
987865 | -1.PP_SO-102 | 987844 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0092 | 0092 | Výchozí zdroj světla, <Unnamed>
987868 | -1.PP_SO-102 | 987847 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0093 | 0093 | Výchozí zdroj světla, <Unnamed>
987871 | -1.PP_SO-102 | 987850 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0094 | 0094 | Výchozí zdroj světla, <Unnamed>
987874 | -1.PP_SO-102 | 987853 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0095 | 0095 | Výchozí zdroj světla, <Unnamed>
987877 | -1.PP_SO-102 | 987856 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0096 | 0096 | Výchozí zdroj světla, <Unnamed>
987880 | -1.PP_SO-102 | 987859 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0097 | 0097 | Výchozí zdroj světla, <Unnamed>
987883 | -1.PP_SO-102 | 987862 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0098 | 0098 | Výchozí zdroj světla, <Unnamed>
987886 | -1.PP_SO-102 | 987865 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0099 | 0099 | Výchozí zdroj světla, <Unnamed>
987889 | -1.PP_SO-102 | 987868 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0100 | 0100 | Výchozí zdroj světla, <Unnamed>
987892 | -1.PP_SO-102 | 987871 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0101 | 0101 | Výchozí zdroj světla, <Unnamed>
987895 | -1.PP_SO-102 | 987874 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0102 | 0102 | Výchozí zdroj světla, <Unnamed>
987898 | -1.PP_SO-102 | 987877 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0103 | 0103 | Výchozí zdroj světla, <Unnamed>
987901 | -1.PP_SO-102 | 987880 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0104 | 0104 | Výchozí zdroj světla, <Unnamed>
987904 | -1.PP_SO-102 | 987883 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0105 | 0105 | Výchozí zdroj světla, <Unnamed>
987907 | -1.PP_SO-102 | 987886 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0106 | 0106 | Výchozí zdroj světla, <Unnamed>
987910 | -1.PP_SO-102 | 987889 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0107 | 0107 | Výchozí zdroj světla, <Unnamed>
987913 | -1.PP_SO-102 | 987892 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0108 | 0108 | Výchozí zdroj světla, <Unnamed>
987916 | -1.PP_SO-102 | 987895 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0109 | 0109 | Výchozí zdroj světla, <Unnamed>
987919 | -1.PP_SO-102 | 987898 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0110 | 0110 | Výchozí zdroj světla, <Unnamed>
987922 | -1.PP_SO-102 | 987901 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0111 | 0111 | Výchozí zdroj světla, <Unnamed>
987925 | -1.PP_SO-102 | 987904 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0112 | 0112 | Výchozí zdroj světla, <Unnamed>
987928 | -1.PP_SO-102 | 987907 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0113 | 0113 | Výchozí zdroj světla, <Unnamed>
987931 | -1.PP_SO-102 | 987910 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0114 | 0114 | Výchozí zdroj světla, <Unnamed>
987934 | -1.PP_SO-102 | 987913 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 1 | OS03.03.0115 | 0115 | Výchozí zdroj světla, <Unnamed>
987937 | -1.PP_SO-102 | 987916 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0116 | 0116 | Výchozí zdroj světla, <Unnamed>
987940 | -1.PP_SO-102 | 987919 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0117 | 0117 | Výchozí zdroj světla, <Unnamed>
987943 | -1.PP_SO-102 | 987922 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0118 | 0118 | Výchozí zdroj světla, <Unnamed>
987949 | -1.PP_SO-102 | 987925 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0119 | 0119 | Výchozí zdroj světla, <Unnamed>
987952 | -1.PP_SO-102 | 987928 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0120 | 0120 | Výchozí zdroj světla, <Unnamed>
987955 | -1.PP_SO-102 | 987931 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0121 | 0121 | Výchozí zdroj světla, <Unnamed>
987958 | -1.PP_SO-102 | 987934 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0122 | 0122 | Výchozí zdroj světla, <Unnamed>
987961 | -1.PP_SO-102 | 987937 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0123 | 0123 | Výchozí zdroj světla, <Unnamed>
988017 | -1.PP_SO-102 | 987940 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2250 | Fáze 2 | OS03.03.0130 | 0130 | Výchozí zdroj světla, <Unnamed>
996492 | 1.NP_SO-102 | 987943 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0191 | 0191 | Výchozí zdroj světla, <Unnamed>
996495 | 1.NP_SO-102 | 987949 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0192 | 0192 | Výchozí zdroj světla, <Unnamed>
996498 | 1.NP_SO-102 | 987952 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0193 | 0193 | Výchozí zdroj světla, <Unnamed>
996501 | 1.NP_SO-102 | 987955 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0194 | 0194 | Výchozí zdroj světla, <Unnamed>
996507 | 1.NP_SO-102 | 987958 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0195 | 0195 | Výchozí zdroj světla, <Unnamed>
996510 | 1.NP_SO-102 | 987961 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0196 | 0196 | Výchozí zdroj světla, <Unnamed>
996522 | 1.NP_SO-102 | 988017 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0199 | 0199 | Výchozí zdroj světla, <Unnamed>
1015366 | 3.NP_SO-102 | 996522 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0338 | 0338 | Výchozí zdroj světla, <Unnamed>
1015369 | 3.NP_SO-102 | 1024247 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0339 | 0339 | Výchozí zdroj světla, <Unnamed>
1015372 | 3.NP_SO-102 | 1024250 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0340 | 0340 | Výchozí zdroj světla, <Unnamed>
1015375 | 3.NP_SO-102 | 1024253 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0341 | 0341 | Výchozí zdroj světla, <Unnamed>
1015381 | 3.NP_SO-102 | 1024256 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0343 | 0343 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1015387 | 3.NP_SO-102 | 1024259 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0344 | 0344 | Výchozí zdroj světla, <Unnamed>
1015390 | 3.NP_SO-102 | 1024268 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0345 | 0345 | Výchozí zdroj světla, <Unnamed>
1015393 | 3.NP_SO-102 | 1015366 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0346 | 0346 | Výchozí zdroj světla, <Unnamed>
1015396 | 3.NP_SO-102 | 1015369 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0347 | 0347 | Výchozí zdroj světla, <Unnamed>
1015399 | 3.NP_SO-102 | 1015372 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0348 | 0348 | Výchozí zdroj světla, <Unnamed>
1015402 | 3.NP_SO-102 | 1015375 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0349 | 0349 | Výchozí zdroj světla, <Unnamed>
1015405 | 3.NP_SO-102 | 1015381 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0350 | 0350 | Výchozí zdroj světla, <Unnamed>
1015408 | 3.NP_SO-102 | 1015387 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0351 | 0351 | Výchozí zdroj světla, <Unnamed>
1015411 | 3.NP_SO-102 | 1015390 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0352 | 0352 | Výchozí zdroj světla, <Unnamed>
1015414 | 3.NP_SO-102 | 1015393 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0353 | 0353 | Výchozí zdroj světla, <Unnamed>
1015417 | 3.NP_SO-102 | 1015396 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0354 | 0354 | Výchozí zdroj světla, <Unnamed>
1015420 | 3.NP_SO-102 | 1015399 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0355 | 0355 | Výchozí zdroj světla, <Unnamed>
1015423 | 3.NP_SO-102 | 1015402 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0356 | 0356 | Výchozí zdroj světla, <Unnamed>
1015426 | 3.NP_SO-102 | 1015405 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0357 | 0357 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1015429 | 3.NP_SO-102 | 1015408 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0358 | 0358 | Výchozí zdroj světla, <Unnamed> | Fázování - Fáze demolice: Fáze 1
1015432 | 3.NP_SO-102 | 1015411 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0359 | 0359 | Výchozí zdroj světla, <Unnamed>
1015435 | 3.NP_SO-102 | 1015414 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0360 | 0360 | Výchozí zdroj světla, <Unnamed>
1015438 | 3.NP_SO-102 | 1015417 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0361 | 0361 | Výchozí zdroj světla, <Unnamed>
1015447 | 3.NP_SO-102 | 1015420 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 1 | OS03.03.0362 | 0362 | Výchozí zdroj světla, <Unnamed>
1018789 | 3.NP_SO-102 | 1015429 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0383 | 0383 | Výchozí zdroj světla, <Unnamed>
1018792 | 3.NP_SO-102 | 1015432 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0384 | 0384 | Výchozí zdroj světla, <Unnamed>
1018795 | 3.NP_SO-102 | 1015435 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0385 | 0385 | Výchozí zdroj světla, <Unnamed>
1018798 | 3.NP_SO-102 | 1015438 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0386 | 0386 | Výchozí zdroj světla, <Unnamed>
1018801 | 3.NP_SO-102 | 1015447 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0387 | 0387 | Výchozí zdroj světla, <Unnamed>
1018804 | 3.NP_SO-102 | 1068850 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0388 | 0388 | Výchozí zdroj světla, <Unnamed>
1018816 | 3.NP_SO-102 | 1068836 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0390 | 0390 | Výchozí zdroj světla, <Unnamed>
1018819 | 3.NP_SO-102 | 1018789 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2250 | Fáze 2 | OS03.03.0391 | 0391 | Výchozí zdroj světla, <Unnamed>
