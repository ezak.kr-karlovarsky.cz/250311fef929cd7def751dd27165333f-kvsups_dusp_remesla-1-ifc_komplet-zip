Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: f8754d5b-abb0-4c66-90c0-f737cd6b3760, NumberOfSaves: 184], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:52:11
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: CENTÁLNÍ BATERIOVÝ SYSTÉM; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: CBS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Centrální bateriové systémy; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 12:29

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: CENTÁLNÍ BATERIOVÝ SYSTÉM; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: CBS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Centrální bateriové systémy; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 12:29

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-102
In: Budova E
LongName: 2.NP_SO-102; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:42
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (5)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:37
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | -4000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:38
1.NP_SO-102 | 1.NP_SO-102 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:38
3.NP_SO-102 | 3.NP_SO-102 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:38
4.NP_SO-102 | 4.NP_SO-102 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:39

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - R.CBS, Rozvaděč, rozvodnice.CC:Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda:682055
In: -2.PP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ANO
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; ÚČINÍK: 1
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V; POČET FÁZÍ: 3
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 450 mm; HLOUBKA: 400 mm; ŠÍŘKA: 800 mm; VÝŠKA: 2100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV01; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - R.CBS; Označení typu: 01; Popis: R.CBS; Popis sestavy: Požární; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV01 Uniformat (Uniformat); Group: <bez názvu>; 1; 2; 3; 4; 5; 6; 7; 8; 9; 10; 11; 12; 13; 14; 15; 16; 17; 18; 19; 20; 21; 22; 23; 24; 25; 26; 27; 28; 29; 30; 31; 32; 33; 34; 35; 36; 37; 38; 39; 40; 41; 42; 43
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.68 m2; NetVolume: 0.672 m3
Elektroinstalace – obvody - Distribuční systém: 400/230V; Klasifikace MCB: 1 A; Možnost číslování obvodu: Výchozí; Počet fází: 3; Počet vodičů: 4; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - NAPÁJENÍ_ČÍSLO OKRUHU: <bez názvu>; PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A proudu připojení přes kabelová oka: 0 A; Fáze A proudu větveného obvodu: 0 A; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B proudu připojení přes kabelová oka: 0 A; Fáze B proudu větveného obvodu: 0 A; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C proudu připojení přes kabelová oka: 0 A; Fáze C proudu větveného obvodu: 0 A; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Fáze proudu A: 0 A; Fáze proudu B: 0 A; Fáze proudu C: 0 A; Jiné připojené: 0 W; Odhadovaná spotřeba JIné: 0 W; Odhadovaný požadavek na proud JIné: 0 A; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W; Připojeno JIné: 0 W; Proud celkového zapojení: 0 A; Proud celkové odhadované spotřeby: 0 A; Proud připojení JIné: 0 A
Text - CCI Funkční systém: Q; CCI Komponenta: XDC; CCI Technický systém: ME; ID_import: 1070205
Vazby - Hostitel: Podlaží : -2.PP_SO-102; Odsazení od hostitele: 0 mm; Podlaží: -2.PP_SO-102; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.672 m3; Plocha: 2.84 m2
Identifikační data - Kód prvku: RV01.01.0001; Označení: 0001
Jiné - Id typu: 682034; Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - R.CBS; Typ: Rozvaděč NN - R.CBS; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:56

# IfcDistributionPort (364)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: ELECTRICAL
Name
Port_682055_1
Port_972138_1
Port_972151_1
Port_972264_1
Port_973682_1
Port_975154_1
Port_975183_1
Port_975339_1
Port_975356_1
Port_975364_1
Port_975487_1
Port_975721_1
Port_975845_1
Port_975995_1
Port_976117_1
Port_976330_1
Port_976661_1
Port_976917_1
Port_977138_1
Port_977349_1
Port_977513_1
Port_977560_1
Port_977600_1
Port_977756_1
Port_978002_1
Port_978173_1
Port_978187_1
Port_978401_1
Port_978716_1
Port_978914_1
Port_979035_1
Port_979314_1
Port_979365_1
Port_979439_1
Port_979506_1
Port_979707_1
Port_979718_1
Port_980251_1
Port_980318_1
Port_980678_1
Port_980783_1
Port_981092_1
Port_981253_1
Port_981495_1
Port_981788_1
Port_982591_1
Port_982977_1
Port_983264_1
Port_983306_1
Port_983570_1
Port_983808_1
Port_984901_1
Port_984990_1
Port_985138_1
Port_985399_1
Port_985663_1
Port_985777_1
Port_986090_1
Port_986177_1
Port_986236_1
Port_986248_1
Port_986447_1
Port_986527_1
Port_986678_1
Port_986688_1
Port_986823_1
Port_987063_1
Port_987073_1
Port_987142_1
Port_987324_1
Port_987498_1
Port_987730_1
Port_987790_1
Port_987804_1
Port_988024_1
Port_988076_1
Port_988084_1
Port_988238_1
Port_990192_1
Port_990209_1
Port_991001_1
Port_991010_1
Port_991264_1
Port_991583_1
Port_991604_1
Port_991792_1
Port_991840_1
Port_991977_1
Port_992142_1
Port_992171_1
Port_992475_1
Port_992589_1
Port_992601_1
Port_992724_1
Port_992855_1
Port_993026_1
Port_993071_1
Port_993146_1
Port_993250_1
Port_993307_1
Port_993324_1
Port_993344_1
Port_993362_1
Port_993618_1
Port_993638_1
Port_993726_1
Port_993743_1
Port_993973_1
Port_994002_1
Port_994446_1
Port_994584_1
Port_994659_1
Port_994769_1
Port_994979_1
Port_995166_1
Port_995284_1
Port_995328_1
Port_995348_1
Port_995797_1
Port_995843_1
Port_995906_1
Port_995927_1
Port_996052_1
Port_996291_1
Port_996345_1
Port_996353_1
Port_996464_1
Port_996535_1
Port_996548_1
Port_996818_1
Port_997002_1
Port_997200_1
Port_997286_1
Port_997312_1
Port_997668_1
Port_997822_1
Port_998190_1
Port_998203_1
Port_998291_1
Port_998305_1
Port_998377_1
Port_998401_1
Port_1000229_1
Port_1000238_1
Port_1000406_1
Port_1000544_1
Port_1000619_1
Port_1000748_1
Port_1000822_1
Port_1000877_1
Port_1001060_1
Port_1001108_1
Port_1001227_1
Port_1001357_1
Port_1001445_1
Port_1001507_1
Port_1001663_1
Port_1001705_1
Port_1001865_1
Port_1001886_1
Port_1001972_1
Port_1002444_1
Port_1002481_1
Port_1002887_1
Port_1002950_1
Port_1003021_1
Port_1003080_1
Port_1003753_1
Port_1004106_1
Port_1004123_1
Port_1004321_1
Port_1004381_1
Port_1004417_1
Port_1004525_1
Port_1004872_1
Port_1005013_1
Port_1005222_1
Port_1005469_1
Port_1005522_1
Port_1005666_1
Port_1005763_1
Port_1005923_1
Port_1006180_1
Port_1006559_1
Port_1006607_1
Port_1006715_1
Port_1006746_1
Port_1006877_1
Port_1006939_1
Port_1007000_1
Port_1007060_1
Port_1007115_1
Port_1007295_1
Port_1007501_1
Port_1007960_1
Port_1008098_1
Port_1008199_1
Port_1008283_1
Port_1008463_1
Port_1008545_1
Port_1008935_1
Port_1009129_1
Port_1009178_1
Port_1009195_1
Port_1009224_1
Port_1009342_1
Port_1009419_1
Port_1009567_1
Port_1010068_1
Port_1010509_1
Port_1010522_1
Port_1010624_1
Port_1010648_1
Port_1010714_1
Port_1010798_1
Port_1010970_1
Port_1011085_1
Port_1011145_1
Port_1011201_1
Port_1011258_1
Port_1011328_1
Port_1011485_1
Port_1011837_1
Port_1011881_1
Port_1012000_1
Port_1012140_1
Port_1012163_1
Port_1012252_1
Port_1012304_1
Port_1012339_1
Port_1012572_1
Port_1012633_1
Port_1013252_1
Port_1013440_1
Port_1013571_1
Port_1013760_1
Port_1013894_1
Port_1013981_1
Port_1014039_1
Port_1014423_1
Port_1014509_1
Port_1014647_1
Port_1014682_1
Port_1014731_1
Port_1014804_1
Port_1014918_1
Port_1014928_1
Port_1015044_1
Port_1015064_1
Port_1015135_1
Port_1015154_1
Port_1015181_1
Port_1015200_1
Port_1015327_1
Port_1015454_1
Port_1015467_1
Port_1016025_1
Port_1016032_1
Port_1016412_1
Port_1016424_1
Port_1016567_1
Port_1016691_1
Port_1016770_1
Port_1016793_1
Port_1016881_1
Port_1016934_1
Port_1017516_1
Port_1017593_1
Port_1017614_1
Port_1017657_1
Port_1017682_1
Port_1017730_1
Port_1018170_1
Port_1018276_1
Port_1018848_1
Port_1018856_1
Port_1018908_1
Port_1018929_1
Port_1019057_1
Port_1019596_1
Port_1019786_1
Port_1019948_1
Port_1020185_1
Port_1020436_1
Port_1020484_1
Port_1020627_1
Port_1020792_1
Port_1020815_1
Port_1020857_1
Port_1021225_1
Port_1021324_1
Port_1021506_1
Port_1021794_1
Port_1021913_1
Port_1022310_1
Port_1022400_1
Port_1022580_1
Port_1022643_1
Port_1022807_1
Port_1022844_1
Port_1022867_1
Port_1022954_1
Port_1022984_1
Port_1023177_1
Port_1023282_1
Port_1023564_1
Port_1024314_1
Port_1024323_1
Port_1024640_1
Port_1024655_1
Port_1024719_1
Port_1024805_1
Port_1024900_1
Port_1025039_1
Port_1025078_1
Port_1025251_1
Port_1025457_1
Port_1025507_1
Port_1025571_1
Port_1025779_1
Port_1025834_1
Port_1025893_1
Port_1025984_1
Port_1026004_1
Port_1026057_1
Port_1026296_1
Port_1067722_1
Port_1067729_1
Port_1067866_1
Port_1068440_1
Port_1068590_1
Port_1068946_1
Port_1069345_1
Port_1069379_1
Port_1069481_1
Port_1069482_1
Port_1069534_1
Port_1069540_1
Port_1069617_1
Port_1069618_1
Port_1069653_1
Port_1069654_1
Port_1069682_1
Port_1069731_1
Port_1069844_1
Port_1070357_1
Port_1071113_1
Port_1071171_1
Port_1071402_1
Port_1071409_1
Port_1071415_1
Port_1071617_1
Port_1071624_1
Port_1071630_1
Port_1071636_1
Port_1071642_1
Port_1072103_1
Port_1072279_1
Port_1072286_1
Port_1107310_1
Port_1108059_1
Port_1108066_1
Port_1108087_1
Port_1108093_1

# IfcDistributionSystem (44)
PredefinedType: ELECTRICAL
Name
<bez názvu>
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
25
26
27
28
29
30
31
32
33
34
35
36
37
38
39
40
41
42
43

# IfcLightFixture: Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS (363)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2250 mm
Type - Kóty - Délka: 262 mm; Šířka: 58 mm; Výška: 188 mm
Type - Identifikační data - Číslo OmniClass: 23.85.80.11.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OS03; Komentáře k typům: 230V, osvětlení; Model: Model; Nadpis OmniClass: Lighting Controls; Název typu: Nouzové svítidlo - CBS; Označení typu: 01; Popis: CBS; Popis sestavy: Nouzové; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: Nouzové svítidlo s konektorem_hranáté.CC
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - JMENOVITÝ PROUD: 0 A; POČET FÁZÍ: 1; PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - CCI Funkční systém: Q; CCI Komponenta: EAA; CCI Technický systém: ME
Elektrotechnika - NAPĚTÍ: 0 V
Grafika - Geometrie: yes
Kóty - Objem: 0.001487 m3
Jiné - FAKTOR ÚČINNOSTI: 0; Id typu: 967986; Rodina: Nouzové svítidlo s konektorem_hranáté.CC; Rodina a typ: Nouzové svítidlo s konektorem_hranáté.CC: Nouzové svítidlo - CBS; Typ: Nouzové svítidlo - CBS
Name (Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS:...) | In | NAPÁJENÍ_ČÍSLO OKRUHU = Číslo okruhu = Group | NAPÁJENÍ_ROZVADĚČ = Rozvaděč | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
972138 | -2.PP_SO-102 | 1 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975364 | -2.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0001 | 0001 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
972151 | -2.PP_SO-102 | 2 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024579 | -2.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0002 | 0002 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
972264 | -2.PP_SO-102 | 2 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1026447 | -2.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0003 | 0003 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
973682 | -2.PP_SO-102 | 2 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024611 | -2.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0004 | 0004 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
975154 | -2.PP_SO-102 | 1 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 988024 | -2.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
975183 | -2.PP_SO-102 | 1 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975487 | -2.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0006 | 0006 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975339 | -2.PP_SO-102 | 2 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1026500 | -2.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0013 | 0013 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975356 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 976661 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0014 | 0014 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975364 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 972151 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0015 | 0015 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975487 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 972264 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0016 | 0016 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975721 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 976917 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0017 | 0017 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975845 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | Nouzové svítidlo s konektorem_hranáté.CC | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0018 | 0018 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
975995 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 972138 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0019 | 0019 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
976117 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975995 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0020 | 0020 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
976330 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986248 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0021 | 0021 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
976661 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975339 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0022 | 0022 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
976917 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975845 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0023 | 0023 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
977138 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986688 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1100 | Fáze 1 | OS03.01.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
977349 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 983808 | -1.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0025 | 0025 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
977513 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 985777 | -1.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
977560 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991604 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0027 | 0027 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
977600 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991840 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2923.34 | Fáze 2 | OS03.01.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
977756 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977600 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0029 | 0029 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978002 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979314 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0030 | 0030 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978173 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979506 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0031 | 0031 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978187 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977560 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 0 | Fáze 2 | OS03.01.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978401 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993362 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978716 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993726 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0034 | 0034 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
978914 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977756 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0035 | 0035 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979035 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 980318 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0036 | 0036 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979314 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 980251 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0037 | 0037 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979365 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977947 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2930.32 | Fáze 2 | OS03.01.0038 | 0038 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979439 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 988076 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2922.36 | Fáze 2 | OS03.01.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979506 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978401 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2924.94 | Fáze 2 | OS03.01.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979707 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978914 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
979718 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978173 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
980251 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978716 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
980318 | -1.PP_SO-102 | 30 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993250 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 2 | OS03.01.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
980678 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 990209 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
980783 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 982591 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
981092 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 976330 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
981253 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986447 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
981495 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986236 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
981788 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977349 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
982591 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975183 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
982977 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975356 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
983264 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975721 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
983306 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977138 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
983570 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 983264 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
983808 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 980783 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
984901 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986823 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
984990 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 985138 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
985138 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 983306 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
985399 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987730 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
985663 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987324 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 3020.08 | Fáze 1 | OS03.01.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
985777 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986177 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986090 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 984990 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0063 | 0063 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986177 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 982977 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986236 | -1.PP_SO-102 | 4 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 975154 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0065 | 0065 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986248 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 976117 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0066 | 0066 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986447 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 983570 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0067 | 0067 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986527 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987073 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2979.16 | Fáze 1 | OS03.01.0068 | 0068 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986678 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 977513 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0069 | 0069 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986688 | -1.PP_SO-102 | 5 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 981495 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0070 | 0070 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
986823 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 981092 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0071 | 0071 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987063 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986090 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987073 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987804 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0078 | 0078 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987142 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 985663 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0079 | 0079 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987324 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986678 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0080 | 0080 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987498 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 990192 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0081 | 0081 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987730 | -1.PP_SO-102 | 7 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 981788 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0082 | 0082 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
987790 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 986527 | -1.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0083 | 0083 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
987804 | -1.PP_SO-102 | 6 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 981253 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0084 | 0084 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
988024 | -1.PP_SO-102 | 3 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 973682 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
988076 | -1.PP_SO-102 | 31 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978187 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
988084 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979707 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
988238 | -1.PP_SO-102 | 32 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979439 | -1.PP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
990192 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 984901 | -1.PP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
990209 | -1.PP_SO-102 | 8 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 985399 | -1.PP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
991001 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022580 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
991010 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 978002 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0145 | 0145 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
991264 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 988238 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0146 | 0146 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
991583 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022867 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
991604 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022954 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
991792 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 988084 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
991840 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022807 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0150 | 0150 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
991977 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993743 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
992142 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994446 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
992171 | 1.NP_SO-102 |  |  | 993344 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0153 | 0153 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
992475 | 1.NP_SO-102 |  |  | 991264 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
992589 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991010 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0155 | 0155 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
992601 | 1.NP_SO-102 |  |  | 993307 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0156 | 0156 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
992724 | 1.NP_SO-102 |  |  | 993324 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0157 | 0157 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Fázování - Fáze demolice: Fáze 1
992855 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997312 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993026 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997286 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993071 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997200 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0160 | 0160 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993146 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993071 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 339.817 | Fáze 2 | OS03.01.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993250 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993973 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0162 | 0162 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993307 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992589 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0163 | 0163 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993324 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979718 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0164 | 0164 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
993344 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991977 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
993362 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991001 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0166 | 0166 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993618 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992475 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2150 | Fáze 1 | OS03.01.0167 | 0167 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993638 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991792 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2150 | Fáze 1 | OS03.01.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993726 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 991583 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0169 | 0169 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993743 | 1.NP_SO-102 | 34 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 979365 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0170 | 0170 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
993973 | 1.NP_SO-102 | 33 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1022984 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0171 | 0171 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
994002 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995797 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0172 | 0172 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
994446 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992724 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0173 | 0173 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
994584 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995348 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0174 | 0174 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
994659 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995927 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0175 | 0175 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
994769 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987790 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0176 | 0176 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
994979 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994659 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0177 | 0177 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995166 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995843 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0178 | 0178 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995284 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987498 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0179 | 0179 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995328 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998377 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0180 | 0180 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995348 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987063 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0181 | 0181 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995797 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998203 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0182 | 0182 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995843 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996345 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0183 | 0183 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995906 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996535 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0184 | 0184 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
995927 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994584 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2400 | Fáze 1 | OS03.01.0185 | 0185 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996052 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995284 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0186 | 0186 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996291 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994002 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0187 | 0187 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996345 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 987142 | 1.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0188 | 0188 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996353 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998305 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0189 | 0189 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996464 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998190 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0190 | 0190 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996535 | 1.NP_SO-102 | 11 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 998291 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0200 | 0200 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
996548 | 1.NP_SO-102 | 35 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 993638 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0201 | 0201 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
996818 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024314 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0202 | 0202 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
997002 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992601 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0203 | 0203 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
997200 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996548 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0204 | 0204 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
997286 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1024323 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0205 | 0205 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
997312 | 1.NP_SO-102 | 36 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992171 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 2 | OS03.01.0206 | 0206 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
997668 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 997002 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0207 | 0207 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
997822 | 1.NP_SO-102 | 37 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 992855 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 2 | OS03.01.0208 | 0208 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
998190 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996353 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0209 | 0209 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
998203 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 994769 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0210 | 0210 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
998291 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 996052 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0211 | 0211 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
998305 | 1.NP_SO-102 | 9 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 980678 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0212 | 0212 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
998377 | 1.NP_SO-102 | 10 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 995166 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0213 | 0213 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
998401 | 1.NP_SO-102 |  |  | 993618 | 1.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0214 | 0214 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01 | Fázování - Fáze demolice: Fáze 1
1000229 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001357 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0215 | 0215 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000238 | 2.NP_SO-102 | 18 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000822 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0216 | 0216 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000406 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000877 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0217 | 0217 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000544 | 2.NP_SO-102 | 18 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001445 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0218 | 0218 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000619 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001108 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0219 | 0219 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000748 | 2.NP_SO-102 | 18 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001060 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0220 | 0220 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000822 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1002444 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0221 | 0221 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1000877 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001886 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0222 | 0222 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56 | Jiné - Páteřní trasa: no
1001060 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001865 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0223 | 0223 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001108 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1009567 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0224 | 0224 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001227 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005763 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0225 | 0225 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001357 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004872 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2150 | Fáze 1 | OS03.01.0226 | 0226 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001445 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000229 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0227 | 0227 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001507 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1002481 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0228 | 0228 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001663 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1000406 | 2.NP_SO-102 | Osamocené | 1945 | Fáze 1 | OS03.01.0229 | 0229 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001705 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004321 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0230 | 0230 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001865 | 2.NP_SO-102 | 17 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001507 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0231 | 0231 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001886 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1002950 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0232 | 0232 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1001972 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016032 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0233 | 0233 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1002444 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1003021 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0234 | 0234 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1002481 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001705 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0235 | 0235 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1002887 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005222 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0236 | 0236 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1002950 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006715 | 2.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0237 | 0237 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1003021 | 2.NP_SO-102 | 16 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001972 | 2.NP_SO-102 | <nepřiřazeno> | 2250 | Fáze 1 | OS03.01.0238 | 0238 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:01
1003080 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006746 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0239 | 0239 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1003753 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005666 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1300 | Fáze 1 | OS03.01.0240 | 0240 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004106 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005469 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1150 | Fáze 1 | OS03.01.0241 | 0241 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004123 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1005923 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0242 | 0242 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004321 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1016025 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0243 | 0243 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004381 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006607 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0244 | 0244 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004417 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007115 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0245 | 0245 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004525 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004417 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0246 | 0246 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1004872 | 2.NP_SO-102 | 15 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1004106 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0247 | 0247 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005013 | 1.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006939 | 1.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 3181.82 | Fáze 1 | OS03.01.0248 | 0248 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005222 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007295 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0249 | 0249 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005469 | 2.NP_SO-102 | 14 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1001227 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0250 | 0250 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005522 | 2.NP_SO-102 | 12 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007501 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2250 | Fáze 1 | OS03.01.0251 | 0251 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005666 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1006877 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0252 | 0252 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
1005763 | 2.NP_SO-102 | 13 | Rozvaděč NN - R.CBS, 230 V/400 V, Tři Fáze, 4 Vodiče, Hvězda | 1007000 | 2.NP_SO-102 | Osamocené | 2250 | Fáze 1 | OS03.01.0253 | 0253 | Fruhauf.vinarice@seznam.cz 2023.07.13 12:56
