Properties of the parts of a building model (IFC4), part 2 of 3

# IfcDistributionPort (765)
Name | PredefinedType | SystemType
Port_666340_0 | CABLECARRIER | CONVEYING
Port_666340_1 | CABLECARRIER | CONVEYING
Port_666341_0 | CABLECARRIER | CONVEYING
Port_666341_1 | CABLECARRIER | CONVEYING
Port_666392_0 | CABLECARRIER | CONVEYING
Port_666392_1 | CABLECARRIER | CONVEYING
Port_666393_0 | CABLECARRIER | CONVEYING
Port_666393_1 | CABLECARRIER | CONVEYING
Port_666420_0 | CABLECARRIER | CONVEYING
Port_666420_1 | CABLECARRIER | CONVEYING
Port_666421_0 | CABLECARRIER | CONVEYING
Port_666421_1 | CABLECARRIER | CONVEYING
Port_666429_0 | CABLECARRIER | CONVEYING
Port_666429_1 | CABLECARRIER | CONVEYING
Port_666430_0 | CABLECARRIER | CONVEYING
Port_666430_1 | CABLECARRIER | CONVEYING
Port_666601_1 | CABLE | DATA
Port_666602_1 | CABLE | DATA
Port_666603_1 | CABLE | DATA
Port_666707_1 | CABLE | DATA
Port_666782_1 | CABLE | DATA
Port_667028_1 | CABLE | DATA
Port_667029_1 | CABLE | DATA
Port_667046_1 | CABLE | DATA
Port_667054_1 | CABLE | DATA
Port_667138_1 | CABLE | DATA
Port_667192_1 | CABLE | DATA
Port_667322_1 | CABLE | DATA
Port_667340_1 | CABLE | DATA
Port_667378_1 | CABLE | DATA
Port_667406_1 | CABLE | DATA
Port_667430_1 | CABLE | DATA
Port_667466_1 | CABLE | DATA
Port_667520_1 | CABLE | DATA
Port_667564_1 | CABLE | DATA
Port_667604_1 | CABLE | DATA
Port_667682_1 | CABLE | DATA
Port_667710_1 | CABLE | DATA
Port_667752_1 | CABLE | DATA
Port_667774_1 | CABLE | DATA
Port_667810_1 | CABLE | DATA
Port_667861_1 | CABLE | DATA
Port_667905_1 | CABLE | DATA
Port_667948_1 | CABLE | DATA
Port_668055_1 | CABLE | DATA
Port_668088_1 | CABLE | DATA
Port_668120_1 | CABLE | DATA
Port_668152_1 | CABLE | DATA
Port_668240_1 | CABLE | DATA
Port_668352_1 | CABLE | DATA
Port_668378_1 | CABLE | DATA
Port_668402_1 | CABLE | DATA
Port_668472_1 | CABLE | DATA
Port_668502_1 | CABLE | DATA
Port_668584_1 | CABLE | DATA
Port_668612_1 | CABLE | DATA
Port_668734_1 | CABLE | DATA
Port_668770_1 | CABLE | DATA
Port_668792_1 | CABLE | DATA
Port_668830_1 | CABLE | DATA
Port_669012_1 | CABLE | DATA
Port_669186_1 | CABLE | DATA
Port_669230_1 | CABLE | DATA
Port_669322_1 | CABLE | DATA
Port_669370_1 | CABLE | DATA
Port_669454_1 | CABLE | DATA
Port_669489_1 | CABLE | DATA
Port_669547_1 | CABLE | DATA
Port_669593_1 | CABLE | DATA
Port_669695_1 | CABLE | DATA
Port_669736_1 | CABLE | DATA
Port_669766_1 | CABLE | DATA
Port_670067_1 | CABLE | DATA
Port_670141_1 | CABLE | DATA
Port_670165_1 | CABLE | DATA
Port_670251_1 | CABLE | DATA
Port_670273_1 | CABLE | DATA
Port_670305_1 | CABLE | DATA
Port_670333_1 | CABLE | DATA
Port_670390_1 | CABLE | DATA
Port_670484_1 | CABLE | DATA
Port_670504_1 | CABLE | DATA
Port_670592_1 | CABLE | DATA
Port_670645_1 | CABLE | DATA
Port_670665_1 | CABLE | DATA
Port_670691_1 | CABLE | DATA
Port_670708_1 | CABLE | DATA
Port_670734_1 | CABLE | DATA
Port_670764_1 | CABLE | DATA
Port_670784_1 | CABLE | DATA
Port_670823_1 | CABLE | DATA
Port_670887_1 | CABLE | DATA
Port_670933_1 | CABLE | DATA
Port_670978_1 | CABLE | DATA
Port_671003_1 | CABLE | DATA
Port_671031_1 | CABLE | DATA
Port_671343_1 | CABLE | DATA
Port_671460_1 | CABLE | DATA
Port_671689_1 | CABLE | DATA
Port_671798_1 | CABLE | DATA
Port_671840_1 | CABLE | DATA
Port_671904_1 | CABLE | DATA
Port_672003_1 | CABLE | DATA
Port_672168_1 | CABLE | DATA
Port_672188_1 | CABLE | DATA
Port_672264_1 | CABLE | DATA
Port_672282_1 | CABLE | DATA
Port_672425_1 | CABLE | DATA
Port_672445_1 | CABLE | DATA
Port_672526_1 | CABLE | DATA
Port_673059_1 | CABLE | DATA
Port_673072_1 | CABLE | DATA
Port_673190_1 | CABLE | DATA
Port_673191_1 | CABLE | DATA
Port_673270_1 | CABLE | DATA
Port_673271_1 | CABLE | DATA
Port_673272_1 | CABLE | DATA
Port_673333_1 | CABLE | DATA
Port_673411_1 | CABLE | DATA
Port_673529_0 | CABLECARRIER | CONVEYING
Port_673529_1 | CABLECARRIER | CONVEYING
Port_673670_0 | CABLECARRIER | CONVEYING
Port_673670_1 | CABLECARRIER | CONVEYING
Port_673775_0 | CABLECARRIER | CONVEYING
Port_673775_1 | CABLECARRIER | CONVEYING
Port_673977_1 | CABLE | DATA
Port_673985_1 | CABLE | DATA
Port_673989_1 | CABLE | DATA
Port_673993_1 | CABLE | DATA
Port_673999_1 | CABLE | DATA
Port_674005_1 | CABLE | DATA
Port_674009_1 | CABLE | DATA
Port_674013_1 | CABLE | DATA
Port_674017_1 | CABLE | DATA
Port_674023_1 | CABLE | DATA
Port_674044_1 | CABLE | DATA
Port_674045_1 | CABLE | DATA
Port_674059_1 | CABLE | DATA
Port_674060_1 | CABLE | DATA
Port_674074_1 | CABLE | DATA
Port_674075_1 | CABLE | DATA
Port_674089_1 | CABLE | DATA
Port_674090_1 | CABLE | DATA
Port_674104_1 | CABLE | DATA
Port_674105_1 | CABLE | DATA
Port_674119_1 | CABLE | DATA
Port_674120_1 | CABLE | DATA
Port_674172_1 | CABLE | DATA
Port_674180_1 | CABLE | DATA
Port_674229_1 | CABLE | DATA
Port_674239_1 | CABLE | DATA
Port_674443_1 | CABLE | DATA
Port_674444_1 | CABLE | DATA
Port_674445_1 | CABLE | DATA
Port_674446_1 | CABLE | DATA
Port_674463_1 | CABLE | DATA
Port_674464_1 | CABLE | DATA
Port_674465_1 | CABLE | DATA
Port_674466_1 | CABLE | DATA
Port_674483_1 | CABLE | DATA
Port_674484_1 | CABLE | DATA
Port_674485_1 | CABLE | DATA
Port_674486_1 | CABLE | DATA
Port_674501_1 | CABLE | DATA
Port_674502_1 | CABLE | DATA
Port_674503_1 | CABLE | DATA
Port_674504_1 | CABLE | DATA
Port_674519_1 | CABLE | DATA
Port_674520_1 | CABLE | DATA
Port_674521_1 | CABLE | DATA
Port_674522_1 | CABLE | DATA
Port_674539_1 | CABLE | DATA
Port_674540_1 | CABLE | DATA
Port_674541_1 | CABLE | DATA
Port_674542_1 | CABLE | DATA
Port_674557_1 | CABLE | DATA
Port_674558_1 | CABLE | DATA
Port_674559_1 | CABLE | DATA
Port_674560_1 | CABLE | DATA
Port_674575_1 | CABLE | DATA
Port_674576_1 | CABLE | DATA
Port_674577_1 | CABLE | DATA
Port_674578_1 | CABLE | DATA
Port_674599_1 | CABLE | DATA
Port_674600_1 | CABLE | DATA
Port_674601_1 | CABLE | DATA
Port_674602_1 | CABLE | DATA
Port_674617_1 | CABLE | DATA
Port_674618_1 | CABLE | DATA
Port_674619_1 | CABLE | DATA
Port_674620_1 | CABLE | DATA
Port_674707_1 | CABLE | DATA
Port_674708_1 | CABLE | DATA
Port_674709_1 | CABLE | DATA
Port_674710_1 | CABLE | DATA
Port_674745_1 | CABLE | DATA
Port_674776_1 | CABLE | DATA
Port_674793_1 | CABLE | DATA
Port_674808_1 | CABLE | DATA
Port_674825_1 | CABLE | DATA
Port_674842_1 | CABLE | DATA
Port_674857_1 | CABLE | DATA
Port_674874_1 | CABLE | DATA
Port_674891_1 | CABLE | DATA
Port_674908_1 | CABLE | DATA
Port_674939_1 | CABLE | DATA
Port_674956_1 | CABLE | DATA
Port_674971_1 | CABLE | DATA
Port_674988_1 | CABLE | DATA
Port_675005_1 | CABLE | DATA
Port_675024_1 | CABLE | DATA
Port_675043_1 | CABLE | DATA
Port_675058_1 | CABLE | DATA
Port_675077_1 | CABLE | DATA
Port_675108_1 | CABLE | DATA
Port_675126_1 | CABLE | DATA
Port_675134_1 | CABLE | DATA
Port_675142_1 | CABLE | DATA
Port_675173_1 | CABLE | DATA
Port_675174_1 | CABLE | DATA
Port_675175_1 | CABLE | DATA
Port_675176_1 | CABLE | DATA
Port_675191_1 | CABLE | DATA
Port_675192_1 | CABLE | DATA
Port_675193_1 | CABLE | DATA
Port_675194_1 | CABLE | DATA
Port_675300_1 | CABLE | DATA
Port_675311_1 | CABLE | DATA
Port_675534_1 | CABLE | DATA
Port_675544_1 | CABLE | DATA
Port_681069_1 | CABLE | DATA
Port_683392_1 | CABLE | SECURITY
Port_684526_1 | CABLE | SECURITY
Port_684544_1 | CABLE | SECURITY
Port_684615_1 | CABLE | SECURITY
Port_684636_1 | CABLE | SECURITY
Port_684678_1 | CABLE | SECURITY
Port_684703_1 | CABLE | SECURITY
Port_684710_1 | CABLE | DATA
Port_684710_2 | CABLE | ELECTRICAL
Port_684757_1 | CABLE | SECURITY
Port_684790_1 | CABLE | SECURITY
Port_684811_1 | CABLE | SECURITY
Port_684818_1 | CABLE | SECURITY
Port_684825_1 | CABLE | SECURITY
Port_684834_1 | CABLE | SECURITY
Port_684836_1 | CABLE | SECURITY
Port_684837_1 | CABLE | SECURITY
Port_684849_1 | CABLE | SECURITY
Port_684851_1 | CABLE | SECURITY
Port_684852_1 | CABLE | SECURITY
Port_688221_1 | CABLE | SECURITY
Port_688230_1 | CABLE | SECURITY
Port_688241_1 | CABLE | SECURITY
Port_688271_1 | CABLE | SECURITY
Port_688279_1 | CABLE | SECURITY
Port_688287_1 | CABLE | SECURITY
Port_688367_1 | CABLE | SECURITY
Port_688375_1 | CABLE | SECURITY
Port_688396_1 | CABLE | SECURITY
Port_688396_2 | CABLE | ELECTRICAL
Port_688396_3 | CABLE | DATA
Port_688417_1 | CABLE | SECURITY
Port_688417_2 | CABLE | ELECTRICAL
Port_688417_3 | CABLE | DATA
Port_688459_1 | CABLE | SECURITY
Port_688459_2 | CABLE | ELECTRICAL
Port_688459_3 | CABLE | DATA
Port_688465_1 | CABLE | SECURITY
Port_688465_2 | CABLE | ELECTRICAL
Port_688465_3 | CABLE | DATA
Port_688474_1 | CABLE | SECURITY
Port_688474_2 | CABLE | ELECTRICAL
Port_688474_3 | CABLE | DATA
Port_688480_1 | CABLE | SECURITY
Port_688480_2 | CABLE | ELECTRICAL
Port_688480_3 | CABLE | DATA
Port_688486_1 | CABLE | SECURITY
Port_688486_2 | CABLE | ELECTRICAL
Port_688486_3 | CABLE | DATA
Port_688492_1 | CABLE | SECURITY
Port_688492_2 | CABLE | ELECTRICAL
Port_688492_3 | CABLE | DATA
Port_688501_1 | CABLE | SECURITY
Port_688501_2 | CABLE | ELECTRICAL
Port_688501_3 | CABLE | DATA
Port_688507_1 | CABLE | SECURITY
Port_688507_2 | CABLE | ELECTRICAL
Port_688507_3 | CABLE | DATA
Port_688513_1 | CABLE | SECURITY
Port_688513_2 | CABLE | ELECTRICAL
Port_688513_3 | CABLE | DATA
Port_688525_1 | CABLE | SECURITY
Port_688525_2 | CABLE | ELECTRICAL
Port_688525_3 | CABLE | DATA
Port_688534_1 | CABLE | SECURITY
Port_688534_2 | CABLE | ELECTRICAL
Port_688534_3 | CABLE | DATA
Port_688540_1 | CABLE | SECURITY
Port_688540_2 | CABLE | ELECTRICAL
Port_688540_3 | CABLE | DATA
Port_688546_1 | CABLE | SECURITY
Port_688546_2 | CABLE | ELECTRICAL
Port_688546_3 | CABLE | DATA
Port_688552_1 | CABLE | SECURITY
Port_688552_2 | CABLE | ELECTRICAL
Port_688552_3 | CABLE | DATA
Port_688561_1 | CABLE | SECURITY
Port_688561_2 | CABLE | ELECTRICAL
Port_688561_3 | CABLE | DATA
Port_688570_1 | CABLE | SECURITY
Port_688570_2 | CABLE | ELECTRICAL
Port_688570_3 | CABLE | DATA
Port_688582_1 | CABLE | SECURITY
Port_688582_2 | CABLE | ELECTRICAL
Port_688582_3 | CABLE | DATA
Port_688588_1 | CABLE | SECURITY
Port_688588_2 | CABLE | ELECTRICAL
Port_688588_3 | CABLE | DATA
Port_688606_1 | CABLE | SECURITY
Port_688606_2 | CABLE | ELECTRICAL
Port_688606_3 | CABLE | DATA
Port_688973_1 | CABLE | SECURITY
Port_688975_1 | CABLE | SECURITY
Port_688976_1 | CABLE | SECURITY
Port_688984_1 | CABLE | SECURITY
Port_688986_1 | CABLE | SECURITY
Port_688987_1 | CABLE | SECURITY
Port_689027_1 | CABLE | SECURITY
Port_689102_1 | CABLE | SECURITY
Port_689104_1 | CABLE | SECURITY
Port_689105_1 | CABLE | SECURITY
Port_689106_1 | CABLE | SECURITY
Port_689120_1 | CABLE | SECURITY
Port_689121_1 | CABLE | SECURITY
Port_689122_1 | CABLE | SECURITY
Port_689220_1 | CABLE | SECURITY
Port_689222_1 | CABLE | SECURITY
Port_689223_1 | CABLE | SECURITY
Port_693059_1 | CABLE | DATA
Port_693063_1 | CABLE | DATA
Port_693067_1 | CABLE | DATA
Port_693071_1 | CABLE | DATA
Port_693075_1 | CABLE | DATA
Port_693079_1 | CABLE | DATA
Port_693083_1 | CABLE | DATA
Port_693087_1 | CABLE | DATA
Port_693091_1 | CABLE | DATA
Port_694600_1 | CABLE | SECURITY
Port_694600_2 | CABLE | ELECTRICAL
Port_694627_1 | CABLE | SECURITY
Port_694627_2 | CABLE | ELECTRICAL
Port_694657_1 | CABLE | SECURITY
Port_694657_2 | CABLE | ELECTRICAL
Port_694669_1 | CABLE | SECURITY
Port_694669_2 | CABLE | ELECTRICAL
Port_694675_1 | CABLE | SECURITY
Port_694675_2 | CABLE | ELECTRICAL
Port_694719_1 | CABLE | SECURITY
Port_694719_2 | CABLE | ELECTRICAL
Port_694725_1 | CABLE | SECURITY
Port_694725_2 | CABLE | ELECTRICAL
Port_694751_1 | CABLE | SECURITY
Port_694774_1 | CABLE | SECURITY
Port_694792_1 | CABLE | SECURITY
Port_694792_2 | CABLE | ELECTRICAL
Port_694798_1 | CABLE | SECURITY
Port_694798_2 | CABLE | ELECTRICAL
Port_694825_1 | CABLE | SECURITY
Port_694825_2 | CABLE | ELECTRICAL
Port_694841_1 | CABLE | SECURITY
Port_694841_2 | CABLE | ELECTRICAL
Port_694847_1 | CABLE | SECURITY
Port_694847_2 | CABLE | ELECTRICAL
Port_694887_1 | CABLE | SECURITY
Port_694887_2 | CABLE | ELECTRICAL
Port_694893_1 | CABLE | SECURITY
Port_694893_2 | CABLE | ELECTRICAL
Port_694899_1 | CABLE | SECURITY
Port_694899_2 | CABLE | ELECTRICAL
Port_694905_1 | CABLE | SECURITY
Port_694905_2 | CABLE | ELECTRICAL
Port_694911_1 | CABLE | SECURITY
Port_694911_2 | CABLE | ELECTRICAL
Port_695161_1 | CABLE | SECURITY
Port_695191_1 | CABLE | SECURITY
Port_695191_2 | CABLE | ELECTRICAL
Port_695221_1 | CABLE | SECURITY
Port_695248_1 | CABLE | SECURITY
Port_695336_1 | CABLE | SECURITY
Port_695360_1 | CABLE | SECURITY
Port_695382_1 | CABLE | SECURITY
Port_695410_1 | CABLE | SECURITY
Port_695410_2 | CABLE | ELECTRICAL
Port_695469_1 | CABLE | SECURITY
Port_695469_2 | CABLE | ELECTRICAL
Port_695469_3 | CABLE | DATA
Port_695481_1 | CABLE | SECURITY
Port_695481_2 | CABLE | ELECTRICAL
Port_695481_3 | CABLE | DATA
Port_695555_1 | CABLE | SECURITY
Port_695555_2 | CABLE | ELECTRICAL
Port_695555_3 | CABLE | DATA
Port_712484_1 | CABLE | SECURITY
Port_712484_2 | CABLE | ELECTRICAL
Port_712484_3 | CABLE | DATA
Port_712494_1 | CABLE | SECURITY
Port_712494_2 | CABLE | ELECTRICAL
Port_712494_3 | CABLE | DATA
Port_712521_1 | CABLE | SECURITY
Port_712521_2 | CABLE | ELECTRICAL
Port_712521_3 | CABLE | DATA
Port_712541_1 | CABLE | DATA
Port_712549_1 | CABLE | DATA
Port_712586_1 | CABLE | DATA
Port_712587_1 | CABLE | DATA
Port_712623_1 | CABLE | DATA
Port_712687_0 | CABLECARRIER | CONVEYING
Port_712687_1 | CABLECARRIER | CONVEYING
Port_712767_0 | CABLECARRIER | CONVEYING
Port_712767_1 | CABLECARRIER | CONVEYING
Port_712860_1 | CABLECARRIER | CONVEYING
Port_759329_0 | CABLECARRIER | CONVEYING
Port_712860_2 | CABLECARRIER | CONVEYING
Port_759371_0 | CABLECARRIER | CONVEYING
Port_712932_1 | CABLE | DATA
Port_712944_1 | CABLE | DATA
Port_712952_1 | CABLE | DATA
Port_712991_1 | CABLE | DATA
Port_713031_1 | CABLE | DATA
Port_713039_1 | CABLE | DATA
Port_713047_1 | CABLE | DATA
Port_713076_0 | CABLECARRIER | CONVEYING
Port_713076_1 | CABLECARRIER | CONVEYING
Port_713077_1 | CABLE | DATA
Port_713079_1 | CABLE | DATA
Port_713080_1 | CABLE | DATA
Port_713081_1 | CABLE | DATA
Port_713082_1 | CABLE | DATA
Port_713083_1 | CABLE | DATA
Port_713146_0 | CABLECARRIER | CONVEYING
Port_713146_1 | CABLECARRIER | CONVEYING
Port_713147_1 | CABLE | DATA
Port_713149_1 | CABLE | DATA
Port_713174_6 | CABLE | DATA
Port_713174_7 | CABLE | ELECTRICAL
Port_713209_6 | CABLE | DATA
Port_713209_7 | CABLE | ELECTRICAL
Port_725036_1 | CABLE | DATA
Port_725037_1 | CABLE | DATA
Port_725051_1 | CABLE | DATA
Port_725052_1 | CABLE | DATA
Port_725062_1 | CABLE | DATA
Port_725134_0 | CABLECARRIER | CONVEYING
Port_761283_2 | CABLECARRIER | CONVEYING
Port_725134_1 | CABLECARRIER | CONVEYING
Port_725135_1 | CABLE | DATA
Port_725159_0 | CABLECARRIER | CONVEYING
Port_761291_1 | CABLECARRIER | CONVEYING
Port_725159_1 | CABLECARRIER | CONVEYING
Port_725321_1 | CABLE | DATA
Port_749437_1 | CABLE | DATA
Port_749438_1 | CABLE | DATA
Port_749439_1 | CABLE | DATA
Port_749944_1 | CABLE | DATA
Port_749945_1 | CABLE | DATA
Port_749946_1 | CABLE | DATA
Port_749947_1 | CABLE | DATA
Port_749961_1 | CABLE | DATA
Port_749962_1 | CABLE | DATA
Port_749963_1 | CABLE | DATA
Port_749964_1 | CABLE | DATA
Port_750434_1 | CABLE | DATA
Port_750446_1 | CABLE | DATA
Port_750456_1 | CABLE | DATA
Port_752097_0 | CABLECARRIER | CONVEYING
Port_752097_1 | CABLECARRIER | CONVEYING
Port_752132_0 | CABLECARRIER | CONVEYING
Port_752132_1 | CABLECARRIER | CONVEYING
Port_752308_0 | CABLECARRIER | CONVEYING
Port_752308_1 | CABLECARRIER | CONVEYING
Port_752363_0 | CABLECARRIER | CONVEYING
Port_752363_1 | CABLECARRIER | CONVEYING
Port_752666_1 | CABLE | DATA
Port_752676_1 | CABLE | DATA
Port_752683_1 | CABLE | DATA
Port_752693_1 | CABLE | DATA
Port_752700_1 | CABLE | DATA
Port_752707_1 | CABLE | DATA
Port_752714_1 | CABLE | DATA
Port_752721_1 | CABLE | DATA
Port_753763_1 | CABLE | SECURITY
Port_753763_2 | CABLE | ELECTRICAL
Port_753786_1 | CABLE | SECURITY
Port_753794_1 | CABLE | SECURITY
Port_753816_1 | CABLE | SECURITY
Port_753828_1 | CABLE | SECURITY
Port_753861_1 | CABLE | SECURITY
Port_753869_1 | CABLE | SECURITY
Port_753877_1 | CABLE | SECURITY
Port_753902_1 | CABLE | SECURITY
Port_753902_2 | CABLE | ELECTRICAL
Port_753939_1 | CABLE | SECURITY
Port_753939_2 | CABLE | ELECTRICAL
Port_753947_1 | CABLE | SECURITY
Port_753947_2 | CABLE | ELECTRICAL
Port_753982_1 | CABLE | SECURITY
Port_753992_1 | CABLE | SECURITY
Port_754084_1 | CABLE | SECURITY
Port_754086_1 | CABLE | SECURITY
Port_754086_2 | CABLE | ELECTRICAL
Port_754087_1 | CABLE | SECURITY
Port_754088_1 | CABLE | SECURITY
Port_754101_1 | CABLE | SECURITY
Port_754102_1 | CABLE | SECURITY
Port_754102_2 | CABLE | ELECTRICAL
Port_754103_1 | CABLE | SECURITY
Port_754104_1 | CABLE | SECURITY
Port_754165_1 | CABLE | DATA
Port_754173_1 | CABLE | DATA
Port_754244_1 | CABLE | SECURITY
Port_754295_1 | CABLE | SECURITY
Port_754297_1 | CABLE | SECURITY
Port_754298_1 | CABLE | SECURITY
Port_754298_2 | CABLE | ELECTRICAL
Port_754338_1 | CABLE | SECURITY
Port_754363_1 | CABLE | SECURITY
Port_754364_1 | CABLE | SECURITY
Port_754365_1 | CABLE | SECURITY
Port_754365_2 | CABLE | ELECTRICAL
Port_754428_1 | CABLE | SECURITY
Port_754428_2 | CABLE | ELECTRICAL
Port_754429_1 | CABLE | SECURITY
Port_754430_1 | CABLE | SECURITY
Port_754431_1 | CABLE | SECURITY
Port_754440_1 | CABLE | SECURITY
Port_754440_2 | CABLE | ELECTRICAL
Port_754441_1 | CABLE | SECURITY
Port_754442_1 | CABLE | SECURITY
Port_754443_1 | CABLE | SECURITY
Port_754485_1 | CABLE | SECURITY
Port_754485_2 | CABLE | ELECTRICAL
Port_754486_1 | CABLE | SECURITY
Port_754487_1 | CABLE | SECURITY
Port_754646_1 | CABLE | SECURITY
Port_754646_2 | CABLE | ELECTRICAL
Port_754673_1 | CABLE | SECURITY
Port_754704_1 | CABLE | SECURITY
Port_754706_1 | CABLE | SECURITY
Port_754707_1 | CABLE | SECURITY
Port_754707_2 | CABLE | ELECTRICAL
Port_754708_1 | CABLE | SECURITY
Port_754717_1 | CABLE | SECURITY
Port_754718_1 | CABLE | SECURITY
Port_754719_1 | CABLE | SECURITY
Port_754719_2 | CABLE | ELECTRICAL
Port_754720_1 | CABLE | SECURITY
Port_754729_1 | CABLE | SECURITY
Port_754730_1 | CABLE | SECURITY
Port_754731_1 | CABLE | SECURITY
Port_754731_2 | CABLE | ELECTRICAL
Port_754732_1 | CABLE | SECURITY
Port_754741_1 | CABLE | SECURITY
Port_754742_1 | CABLE | SECURITY
Port_754743_1 | CABLE | SECURITY
Port_754743_2 | CABLE | ELECTRICAL
Port_754744_1 | CABLE | SECURITY
Port_754803_1 | CABLE | SECURITY
Port_754804_1 | CABLE | SECURITY
Port_754805_1 | CABLE | SECURITY
Port_754806_1 | CABLE | SECURITY
Port_754806_2 | CABLE | ELECTRICAL
Port_754815_1 | CABLE | SECURITY
Port_754816_1 | CABLE | SECURITY
Port_754817_1 | CABLE | SECURITY
Port_754818_1 | CABLE | SECURITY
Port_754818_2 | CABLE | ELECTRICAL
Port_754827_1 | CABLE | SECURITY
Port_754828_1 | CABLE | SECURITY
Port_754829_1 | CABLE | SECURITY
Port_754830_1 | CABLE | SECURITY
Port_754830_2 | CABLE | ELECTRICAL
Port_754839_1 | CABLE | SECURITY
Port_754840_1 | CABLE | SECURITY
Port_754841_1 | CABLE | SECURITY
Port_754842_1 | CABLE | SECURITY
Port_754842_2 | CABLE | ELECTRICAL
Port_754949_1 | CABLE | SECURITY
Port_754951_1 | CABLE | SECURITY
Port_754952_1 | CABLE | SECURITY
Port_754953_1 | CABLE | SECURITY
Port_754953_2 | CABLE | ELECTRICAL
Port_758706_1 | CABLECARRIER | CONVEYING
Port_758706_2 | CABLECARRIER | CONVEYING
Port_758737_1 | CABLECARRIER | CONVEYING
Port_758737_2 | CABLECARRIER | CONVEYING
Port_758796_0 | CABLECARRIER | CONVEYING
Port_758796_1 | CABLECARRIER | CONVEYING
Port_758893_1 | CABLECARRIER | CONVEYING
Port_758942_0 | CABLECARRIER | CONVEYING
Port_758893_2 | CABLECARRIER | CONVEYING
Port_758942_1 | CABLECARRIER | CONVEYING
Port_759167_1 | CABLECARRIER | CONVEYING
Port_759168_0 | CABLECARRIER | CONVEYING
Port_759167_2 | CABLECARRIER | CONVEYING
Port_759168_1 | CABLECARRIER | CONVEYING
Port_759206_0 | CABLECARRIER | CONVEYING
Port_759206_1 | CABLECARRIER | CONVEYING
Port_759268_0 | CABLECARRIER | CONVEYING
Port_759268_1 | CABLECARRIER | CONVEYING
Port_759329_1 | CABLECARRIER | CONVEYING
Port_759371_1 | CABLECARRIER | CONVEYING
Port_759460_0 | CABLECARRIER | CONVEYING
Port_759460_1 | CABLECARRIER | CONVEYING
Port_759544_1 | CABLECARRIER | CONVEYING
Port_759544_2 | CABLECARRIER | CONVEYING
Port_759611_1 | CABLECARRIER | CONVEYING
Port_759611_2 | CABLECARRIER | CONVEYING
Port_759654_1 | CABLECARRIER | CONVEYING
Port_759654_2 | CABLECARRIER | CONVEYING
Port_759750_0 | CABLECARRIER | CONVEYING
Port_759750_1 | CABLECARRIER | CONVEYING
Port_759833_1 | CABLECARRIER | CONVEYING
Port_759833_2 | CABLECARRIER | CONVEYING
Port_759850_0 | CABLECARRIER | CONVEYING
Port_759834_0 | CABLECARRIER | CONVEYING
Port_759834_1 | CABLECARRIER | CONVEYING
Port_759850_1 | CABLECARRIER | CONVEYING
Port_759898_1 | CABLECARRIER | CONVEYING
Port_759898_2 | CABLECARRIER | CONVEYING
Port_759901_0 | CABLECARRIER | CONVEYING
Port_759899_1 | CABLECARRIER | CONVEYING
Port_759899_2 | CABLECARRIER | CONVEYING
Port_759902_0 | CABLECARRIER | CONVEYING
Port_759901_1 | CABLECARRIER | CONVEYING
Port_760273_1 | CABLECARRIER | CONVEYING
Port_759902_1 | CABLECARRIER | CONVEYING
Port_760274_2 | CABLECARRIER | CONVEYING
Port_759903_0 | CABLECARRIER | CONVEYING
Port_760273_2 | CABLECARRIER | CONVEYING
Port_759903_1 | CABLECARRIER | CONVEYING
Port_760274_1 | CABLECARRIER | CONVEYING
Port_760127_0 | CABLECARRIER | CONVEYING
Port_760127_1 | CABLECARRIER | CONVEYING
Port_760319_1 | CABLE | DATA
Port_760320_1 | CABLECARRIER | CONVEYING
Port_760320_2 | CABLECARRIER | CONVEYING
Port_760322_0 | CABLECARRIER | CONVEYING
Port_760321_1 | CABLECARRIER | CONVEYING
Port_760321_2 | CABLECARRIER | CONVEYING
Port_760323_0 | CABLECARRIER | CONVEYING
Port_760322_1 | CABLECARRIER | CONVEYING
Port_760325_1 | CABLECARRIER | CONVEYING
Port_760323_1 | CABLECARRIER | CONVEYING
Port_760326_2 | CABLECARRIER | CONVEYING
Port_760324_0 | CABLECARRIER | CONVEYING
Port_760325_2 | CABLECARRIER | CONVEYING
Port_760324_1 | CABLECARRIER | CONVEYING
Port_760326_1 | CABLECARRIER | CONVEYING
Port_760382_0 | CABLECARRIER | CONVEYING
Port_760382_1 | CABLECARRIER | CONVEYING
Port_760662_0 | CABLECARRIER | CONVEYING
Port_760662_1 | CABLECARRIER | CONVEYING
Port_760699_1 | CABLECARRIER | CONVEYING
Port_760699_2 | CABLECARRIER | CONVEYING
Port_760769_1 | CABLECARRIER | CONVEYING
Port_760769_2 | CABLECARRIER | CONVEYING
Port_760889_0 | CABLECARRIER | CONVEYING
Port_761012_2 | CABLECARRIER | CONVEYING
Port_760889_1 | CABLECARRIER | CONVEYING
Port_760918_0 | CABLECARRIER | CONVEYING
Port_761012_1 | CABLECARRIER | CONVEYING
Port_760918_1 | CABLECARRIER | CONVEYING
Port_761039_1 | CABLECARRIER | CONVEYING
Port_761039_2 | CABLECARRIER | CONVEYING
Port_761059_0 | CABLECARRIER | CONVEYING
Port_761059_1 | CABLECARRIER | CONVEYING
Port_761283_1 | CABLECARRIER | CONVEYING
Port_761392_1 | CABLECARRIER | CONVEYING
Port_761291_2 | CABLECARRIER | CONVEYING
Port_761392_2 | CABLECARRIER | CONVEYING

# IfcElectricAppliance: Datová zásuvka RJ45.CC:Dvojzásuvka (11)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 600 mm
Type - Kóty - DÉLKA: 20 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová dvojzásuvka, RJ 45; Model: Model; Název typu: Dvojzásuvka; Označení typu: 07; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; d: -20 mm; l2: -28 mm; -l2: 28 mm; Název rodiny: Datová zásuvka RJ45.CC; R: 5 mm; Symbol: Datová dvojzásuvka 2x RJ45.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000147409 m3
Jiné - Rodina: Datová zásuvka RJ45.CC; Typ: Dvojzásuvka; Id typu: 286800; Rodina a typ: Datová zásuvka RJ45.CC: Dvojzásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29
Name (Datová zásuvka RJ45.CC:Dvojzásuvka:...) | Hostitel | Kód prvku | Označení
673977 | Podlaží : 1.NP_SO-101 | ZZ03.07.0170 | 0170
673985 | Podlaží : 1.NP_SO-101 | ZZ03.07.0171 | 0171
673989 | Podlaží : 1.NP_SO-101 | ZZ03.07.0172 | 0172
673993 | Podlaží : 1.NP_SO-101 | ZZ03.07.0173 | 0173
673999 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.07.0174 | 0174
674005 | Podlaží : 1.NP_SO-101 | ZZ03.07.0175 | 0175
674009 | Podlaží : 1.NP_SO-101 | ZZ03.07.0176 | 0176
674013 | Podlaží : 1.NP_SO-101 | ZZ03.07.0177 | 0177
674017 | Podlaží : 1.NP_SO-101 | ZZ03.07.0178 | 0178
674023 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.07.0179 | 0179
760319 | Podlaží : 1.NP_SO-101 | ZZ03.07.0337 | 0337

# IfcElectricAppliance: Datová zásuvka RJ45.CC:Jednozásuvka (34)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 20 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová jednozásuvka, RJ 45; Model: Model; Název typu: Jednozásuvka; Označení typu: 02; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; d: -20 mm; l2: -28 mm; -l2: 28 mm; Název rodiny: Datová zásuvka RJ45.CC; R: 5 mm; Symbol: Datová jednozásuvka 1x RJ45.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000147409 m3
Jiné - Id typu: 286798; Rodina: Datová zásuvka RJ45.CC; Rodina a typ: Datová zásuvka RJ45.CC: Jednozásuvka; Typ: Jednozásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29
Name (Datová zásuvka RJ45.CC:Jednozásuvka:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
657259 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0002 | 0002
658530 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0004 | 0004
658803 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0006 | 0006
658908 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0008 | 0008
658939 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0010 | 0010
658951 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0012 | 0012
658963 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0014 | 0014
659029 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0016 | 0016
659040 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0018 | 0018
659177 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0020 | 0020
661919 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3400 | ZZ03.02.0025 | 0025
661921 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0027 | 0027
661925 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0029 | 0029
661927 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | ZZ03.02.0031 | 0031
661935 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | ZZ03.02.0033 | 0033
661937 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | ZZ03.02.0035 | 0035
661939 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | ZZ03.02.0037 | 0037
661941 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | ZZ03.02.0039 | 0039
661943 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3300 | ZZ03.02.0041 | 0041
661951 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | ZZ03.02.0043 | 0043
661953 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | ZZ03.02.0045 | 0045
661955 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | ZZ03.02.0047 | 0047
661957 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | ZZ03.02.0049 | 0049
661959 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | ZZ03.02.0051 | 0051
661967 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | ZZ03.02.0053 | 0053
661973 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | ZZ03.02.0055 | 0055
661975 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | ZZ03.02.0057 | 0057
665911 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0064 | 0064
665949 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | ZZ03.02.0066 | 0066
667029 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | ZZ03.02.0073 | 0073
673191 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | ZZ03.02.0164 | 0164
712587 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3300 | ZZ03.02.0289 | 0289
754165 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0335 | 0335
754173 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | ZZ03.02.0336 | 0336

# IfcElectricAppliance: Datová zásuvka do PK.CC:Dvojzásuvka 2x modul (4)
In: 4.NP_SO-101
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Typ symbolu: Datová dvojzásuvka 2x RJ45.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 45 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka 2x modul; Označení typu: 08; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 4.NP_SO-101; Vztažné podlaží: 4.NP_SO-101; Hostitel: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.00002025 m3
Jiné - Rodina: Datová zásuvka do PK.CC; Id typu: 318541; Rodina a typ: Datová zásuvka do PK.CC: Dvojzásuvka 2x modul; Typ: Dvojzásuvka 2x modul; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:28
Name (Datová zásuvka do PK.CC:Dvojzásuvka 2x modul:...) | Výška od podlaží (mm) | Kód prvku | Označení
675300 | 2000 | ZZ03.08.0271 | 0271
675311 | 2000 | ZZ03.08.0272 | 0272
675534 | 300 | ZZ03.08.0273 | 0273
675544 | 300 | ZZ03.08.0274 | 0274

# IfcElectricAppliance: Datová zásuvka do PK.CC:Jednozásuvka 1x modul (112)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: no; Jednozásuvka: yes; Typ symbolu: Datová jednozásuvka 1x RJ45.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 22.5 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Jednozásuvka 1x modul; Označení typu: 05; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000010125 m3
Jiné - Id typu: 318548; Rodina: Datová zásuvka do PK.CC; Rodina a typ: Datová zásuvka do PK.CC: Jednozásuvka 1x modul; Typ: Jednozásuvka 1x modul; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:28
Name (Datová zásuvka do PK.CC:Jednozásuvka 1x modul:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Hostitel | Kód prvku | Označení
663075 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.05.0060 | 0060
663076 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.05.0061 | 0061
666601 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.05.0067 | 0067
666602 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.05.0068 | 0068
673270 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0165 | 0165
673271 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0166 | 0166
674044 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0180 | 0180
674045 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0181 | 0181
674059 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0182 | 0182
674060 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0183 | 0183
674074 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0184 | 0184
674075 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0185 | 0185
674089 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0186 | 0186
674090 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0187 | 0187
674104 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0188 | 0188
674105 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0189 | 0189
674119 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0190 | 0190
674120 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0191 | 0191
674172 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0192 | 0192
674180 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0193 | 0193
674229 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0194 | 0194
674239 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0195 | 0195
674443 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0196 | 0196
674444 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0197 | 0197
674445 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0198 | 0198
674446 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0199 | 0199
674463 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0200 | 0200
674464 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0201 | 0201
674465 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0202 | 0202
674466 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0203 | 0203
674483 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0204 | 0204
674484 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0205 | 0205
674485 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0206 | 0206
674486 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0207 | 0207
674501 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0208 | 0208
674502 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0209 | 0209
674503 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0210 | 0210
674504 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0211 | 0211
674519 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0212 | 0212
674520 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0213 | 0213
674521 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0214 | 0214
674522 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0215 | 0215
674539 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0216 | 0216
674540 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0217 | 0217
674541 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0218 | 0218
674542 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0219 | 0219
674557 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0220 | 0220
674558 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0221 | 0221
674559 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0222 | 0222
674560 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0223 | 0223
674575 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0224 | 0224
674576 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0225 | 0225
674577 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0226 | 0226
674578 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0227 | 0227
674599 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0228 | 0228
674600 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0229 | 0229
674601 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0230 | 0230
674602 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0231 | 0231
674617 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0232 | 0232
674618 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0233 | 0233
674619 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0234 | 0234
674620 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0235 | 0235
674707 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0236 | 0236
674708 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0237 | 0237
674709 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0238 | 0238
674710 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0239 | 0239
674745 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0240 | 0240
674776 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0241 | 0241
674793 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0242 | 0242
674808 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0243 | 0243
674825 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0244 | 0244
674842 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0245 | 0245
674857 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0246 | 0246
674874 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0247 | 0247
674891 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0248 | 0248
674908 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0249 | 0249
674939 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0250 | 0250
674956 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0251 | 0251
674971 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0252 | 0252
674988 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0253 | 0253
675005 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0254 | 0254
675024 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0255 | 0255
675043 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0256 | 0256
675058 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0257 | 0257
675077 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.05.0258 | 0258
675108 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0259 | 0259
675126 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0260 | 0260
675134 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0261 | 0261
675142 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0262 | 0262
675173 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0263 | 0263
675174 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0264 | 0264
675175 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0265 | 0265
675176 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0266 | 0266
675191 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0267 | 0267
675192 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0268 | 0268
675193 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0269 | 0269
675194 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0270 | 0270
725036 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | ZZ03.05.0306 | 0306
725037 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | ZZ03.05.0307 | 0307
725051 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | ZZ03.05.0308 | 0308
725052 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | ZZ03.05.0309 | 0309
749944 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0316 | 0316
749945 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0317 | 0317
749946 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0318 | 0318
749947 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0319 | 0319
749961 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0320 | 0320
749962 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0321 | 0321
749963 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0322 | 0322
749964 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | Podlaží : 3.NP_SO-101 | ZZ03.05.0323 | 0323
750434 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0324 | 0324
750446 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0325 | 0325
750456 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | ZZ03.05.0326 | 0326

# IfcElectricAppliance: Datová zásuvka_vícerámečky.CC:Dvojzásuvka (113)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 2556.9 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Šířka: 45 mm; Typ symbolu: Datová dvojzásuvka 2x RJ45.CC
Type - Kóty - Hloubka: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: druhá klapka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka; Označení typu: 03; Popis: Vypínač; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka_vícerámečky.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00002025 m3
Jiné - Id typu: 364876; Rodina: Datová zásuvka_vícerámečky.CC; Rodina a typ: Datová zásuvka_vícerámečky.CC: Dvojzásuvka; Typ: Dvojzásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29
Name (Datová zásuvka_vícerámečky.CC:Dvojzásuvka:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
659192 | 1.NP_SO-101 | 1.NP_SO-101 | <nepřiřazeno> | 2557 | ZZ03.03.0021 | 0021
663039 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2556.9 | ZZ03.03.0059 | 0059
666707 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ03.03.0070 | 0070
667046 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0074 | 0074
667054 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0075 | 0075
667138 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0076 | 0076
667192 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0077 | 0077
667322 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0078 | 0078
667340 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0079 | 0079
667378 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0080 | 0080
667406 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0081 | 0081
667430 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0082 | 0082
667466 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0083 | 0083
667520 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0084 | 0084
667564 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0085 | 0085
667604 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0086 | 0086
667682 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0087 | 0087
667710 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0088 | 0088
667752 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0089 | 0089
667774 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0090 | 0090
667810 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0091 | 0091
667861 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0092 | 0092
667905 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0093 | 0093
667948 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0094 | 0094
668055 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0095 | 0095
668088 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0096 | 0096
668120 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0097 | 0097
668152 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0098 | 0098
668240 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0099 | 0099
668352 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0100 | 0100
668378 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0101 | 0101
668402 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0102 | 0102
668472 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0103 | 0103
668502 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0104 | 0104
668584 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0105 | 0105
668612 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0106 | 0106
668734 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0107 | 0107
668770 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0108 | 0108
668792 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0109 | 0109
668830 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0110 | 0110
669012 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0111 | 0111
669186 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0112 | 0112
669230 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0113 | 0113
669322 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0114 | 0114
669370 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0115 | 0115
669454 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0116 | 0116
669489 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0117 | 0117
669547 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0118 | 0118
669593 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0119 | 0119
669695 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0120 | 0120
669736 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0121 | 0121
669766 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0122 | 0122
670067 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0123 | 0123
670141 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0124 | 0124
670165 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0125 | 0125
670251 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0126 | 0126
670273 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0127 | 0127
670305 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0128 | 0128
670333 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0129 | 0129
670390 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0130 | 0130
670484 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0131 | 0131
670504 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0132 | 0132
670592 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0133 | 0133
670645 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0134 | 0134
670665 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0135 | 0135
670691 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0136 | 0136
670708 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0137 | 0137
670734 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0138 | 0138
670764 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0139 | 0139
670784 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0140 | 0140
670823 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0141 | 0141
670887 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0142 | 0142
670933 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0143 | 0143
670978 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0144 | 0144
671003 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ03.03.0145 | 0145
671031 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0146 | 0146
671343 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0147 | 0147
671460 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0148 | 0148
671689 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0149 | 0149
671798 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0150 | 0150
671840 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0151 | 0151
671904 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 4600 | ZZ03.03.0152 | 0152
672003 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0153 | 0153
672168 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0154 | 0154
672188 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0155 | 0155
672264 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0156 | 0156
672282 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0157 | 0157
672425 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0158 | 0158
672445 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0159 | 0159
672526 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 750 | ZZ03.03.0160 | 0160
673059 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 300 | ZZ03.03.0161 | 0161
673072 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 300 | ZZ03.03.0162 | 0162
673333 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ03.03.0168 | 0168
712623 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0290 | 0290
712932 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0291 | 0291
712944 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0292 | 0292
712952 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0293 | 0293
712991 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0294 | 0294
713031 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0295 | 0295
713039 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0296 | 0296
713047 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | ZZ03.03.0297 | 0297
713077 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0298 | 0298
713079 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0299 | 0299
713080 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0300 | 0300
713081 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0301 | 0301
713082 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0302 | 0302
713083 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0303 | 0303
713147 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0304 | 0304
713149 | 2.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0305 | 0305
725062 | 1.NP_SO-101 |  | <nepřiřazeno> | 0 | ZZ03.03.0310 | 0310
725135 | 1.NP_SO-101 |  | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ03.03.0311 | 0311
725321 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | ZZ03.03.0312 | 0312
749437 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2696.94 | ZZ03.03.0313 | 0313

# IfcElectricAppliance: Digitální hodiny.CC:Digitální hodiny.CC (9)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN00; Komentáře k typům: digitální; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Digitální hodiny.CC; Označení typu: 09; Popis: Hodiny; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Digitální hodiny.CC
Classification: PN00 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: PGK; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - HLOUBKA: 100 mm; Objem: 0.0149092 m3; Posun písma od středu: 170 mm; ŠÍŘKA: 400 mm; VÝŠKA: 400 mm
Jiné - a: 143.333 mm; Id typu: 681053; Rodina: Digitální hodiny.CC; Rodina a typ: Digitální hodiny.CC: Digitální hodiny.CC; Typ: Digitální hodiny.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29; Výška písma: 113.333 mm
Name (Digitální hodiny.CC:Digitální hodiny.CC:...) | In | Podlaží | Hostitel | Kód prvku | Označení
681069 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PN00.09.0275 | 0275
752666 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PN00.09.0327 | 0327
752676 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | PN00.09.0328 | 0328
752683 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | PN00.09.0329 | 0329
752693 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PN00.09.0330 | 0330
752700 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | PN00.09.0331 | 0331
752707 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PN00.09.0332 | 0332
752714 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PN00.09.0333 | 0333
752721 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PN00.09.0334 | 0334

# IfcElectricAppliance: Dveřní interkom.CC:Dveřní interkom.CC, Dveřní interkom.CC:Dveřní interkom.CC:684710
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1; NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 30 mm; Hloubka zapuštění: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.17.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL02; Komentáře k typům: dveřní; Model: Model; Nadpis OmniClass: Broadcasting Receiving Equipment; Název typu: Dveřní interkom.CC; Označení typu: 10; Popis: Interkom; Popis sestavy: Dveřní interkom; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Dveřní interkom.CC
Classification: OL02 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: SZA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 660 mm; Výška od podlaží: 660 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0005874 m3; ŠÍŘKA: 100 mm; VÝŠKA: 200 mm
Identifikační data - Kód prvku: OL02.10.0276; Označení: 0276
Jiné - Id typu: 679089; Rodina: Dveřní interkom.CC; Rodina a typ: Dveřní interkom.CC: Dveřní interkom.CC; Typ: Dveřní interkom.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:02

# IfcElectricAppliance: HDMI zásuvka do PK.CC:Jednozásuvka 1x modul (3)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: no; Jednozásuvka: yes; Typ symbolu: HDMI zásuvka.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 22.5 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Jednozásuvka 1x modul; Označení typu: 06; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: HDMI zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000010125 m3
Jiné - Typ: Jednozásuvka 1x modul; Id typu: 663147; Rodina: HDMI zásuvka do PK.CC; Rodina a typ: HDMI zásuvka do PK.CC: Jednozásuvka 1x modul; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
