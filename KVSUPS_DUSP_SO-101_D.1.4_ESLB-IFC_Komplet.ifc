Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 7176480a-5191-497f-b5a5-ae5390110ef5, NumberOfSaves: 138], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-13T16:52:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject
Phase: SpD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.12 04:18

# IfcBuilding, Budova E
LongName: Budova E
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.12 04:18

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-101
In: Budova E
LongName: 2.NP_SO-101; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-101
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:47
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (4)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:47
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm)
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150
1.NP_SO-101 | 1.NP_SO-101 | -7.27687e-10 | 0
3.NP_SO-101 | 3.NP_SO-101 | 8000 | 8000
4.NP_SO-101 | 4.NP_SO-101 | 12000 | 12000

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1, Datový rozvaděč rack.CC:Rack 48U 600x800_1:713174
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 800 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1; Označení typu: 01; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Elektrické vybavení; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 400 V; POČET FÁZÍ: 3
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Id typu: 713175; Rodina: Datový rozvaděč rack.CC; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1; Typ: Rack 48U 600x800_1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_3A.1, Datový rozvaděč rack.CC:Rack 48U 600x800_3A.1:713209
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 800 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_3A.1; Označení typu: 02; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Elektrické vybavení; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL
Vazby - Podlaží: 3.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 3.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 713206; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_3A.1; Typ: Rack 48U 600x800_3A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:29; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Dveřní modul.CC:Dveřní modul Vertikální (31)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Horizontální: no; Symbol: yes; Vertikální: yes
Type - Kóty - Hloubka: 40 mm; Šířka: 200 mm; Výška: 140 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL00; Komentáře k typům: dveřní, vertikální; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Dveřní modul Vertikální; Označení typu: 01; Popis: Modul; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Dveřní modul.CC
Classification: OL00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0938603 m2; NetVolume: 0.0011287 m3
Text - CCI Funkční systém: M; CCI Komponenta: KEC; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0011287 m3
Jiné - Id typu: 677876; Rodina: Dveřní modul.CC; Rodina a typ: Dveřní modul.CC: Dveřní modul Vertikální; Typ: Dveřní modul Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
Name (Dveřní modul.CC:Dveřní modul Vertikální:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
683392 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1900 | OL00.01.0001 | 0001
684703 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0007 | 0007
684811 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0010 | 0010
684836 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0014 | 0014
684851 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0017 | 0017
688367 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0025 | 0025
688375 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0026 | 0026
688975 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OL00.01.0049 | 0049
688986 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0052 | 0052
689104 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0056 | 0056
689120 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0059 | 0059
689222 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0063 | 0063
695161 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0084 | 0084
695336 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0088 | 0088
753982 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0109 | 0109
753992 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | OL00.01.0110 | 0110
754087 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0113 | 0113
754103 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2500 | OL00.01.0117 | 0117
754244 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OL00.01.0119 | 0119
754338 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OL00.01.0123 | 0123
754431 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OL00.01.0130 | 0130
754443 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OL00.01.0134 | 0134
754706 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0141 | 0141
754718 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0145 | 0145
754730 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0149 | 0149
754742 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0153 | 0153
754803 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0156 | 0156
754815 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0160 | 0160
754827 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0164 | 0164
754839 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OL00.01.0168 | 0168
754951 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | OL00.01.0173 | 0173

# IfcBuildingElementProxy: Elektromechanický zámek.CC:Elektromechanický zámek.CC (36)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL03; Komentáře k typům: elektromechanický; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Elektromechanický zámek.CC; Označení typu: 02; Popis: Zámek; Popis sestavy: Elektrický otevírač dveří; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Elektromechanický zámek.CC
Classification: OL03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0504504 m2; NetVolume: 0.000356042 m3
Text - CCI Funkční systém: M; CCI Komponenta: QSA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Viditelnost zámku: yes
Kóty - Objem: 0.000356042 m3
Jiné - Id typu: 676716; Rodina: Elektromechanický zámek.CC; Rodina a typ: Elektromechanický zámek.CC: Elektromechanický zámek.CC; Typ: Elektromechanický zámek.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:01
Name (Elektromechanický zámek.CC:Elektromechanický zámek.CC:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
684526 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 273.915 | OL03.02.0002 | 0002
684615 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0004 | 0004
684818 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0011 | 0011
684825 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0012 | 0012
684837 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0015 | 0015
684852 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0018 | 0018
688271 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0022 | 0022
688279 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1070 | OL03.02.0023 | 0023
688287 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0024 | 0024
688976 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0050 | 0050
688987 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0053 | 0053
689105 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0057 | 0057
689121 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0060 | 0060
689223 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0064 | 0064
694774 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0073 | 0073
695221 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0086 | 0086
695360 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0089 | 0089
753816 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0101 | 0101
753828 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 950 | OL03.02.0102 | 0102
754088 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0114 | 0114
754104 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 950 | OL03.02.0118 | 0118
754297 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0121 | 0121
754364 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0125 | 0125
754430 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0129 | 0129
754442 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0133 | 0133
754487 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 950 | OL03.02.0137 | 0137
754673 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0139 | 0139
754708 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0143 | 0143
754720 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0147 | 0147
754732 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0151 | 0151
754744 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0155 | 0155
754804 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0157 | 0157
754816 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0161 | 0161
754828 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0165 | 0165
754840 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 950 | OL03.02.0169 | 0169
754952 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 950 | OL03.02.0174 | 0174

# IfcBuildingElementProxy: Kamery.CC:Venkovní pevná DOME_nástěnná (3)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Typ symbolu: Kamera venkovní pevná DOME.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.17.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: DV01; Komentáře k typům: venkovní, DOME; Model: Model; Nadpis OmniClass: Video Surveillance; Název typu: Venkovní pevná DOME_nástěnná; Označení typu: 07; Popis: Kamera; Popis sestavy: Kamera; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; FAKTOR ÚČINNOSTI: 1; DOME: yes; Nástěnná: yes; Pevná: no; PTZ (otočná): no; Název rodiny: Kamery.CC
Classification: DV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0329857 m2; NetVolume: 0.000480116 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BXC; CCI Technický systém: JL
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000480116 m3
Jiné - Rodina: Kamery.CC; úhel: 180 deg; Id typu: 688041; Rodina a typ: Kamery.CC: Venkovní pevná DOME_nástěnná; Typ: Venkovní pevná DOME_nástěnná; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:07
Name (Kamery.CC:Venkovní pevná DOME_nástěnná:...) | Kód prvku | Označení
695469 | DV01.07.0092 | 0092
695481 | DV01.07.0093 | 0093
695555 | DV01.07.0094 | 0094

# IfcBuildingElementProxy: Kamery.CC:Venkovní pevná DOME_stropní, Kamery.CC:Venkovní pevná DOME_stropní:688606
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Typ symbolu: Kamera venkovní pevná DOME.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.17.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: DV01; Komentáře k typům: venkovní, DOME; Model: Model; Nadpis OmniClass: Video Surveillance; Název typu: Venkovní pevná DOME_stropní; Označení typu: 05; Popis: Kamera; Popis sestavy: Kamera; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; FAKTOR ÚČINNOSTI: 1; DOME: yes; Pevná: no; PTZ (otočná): no; Nástěnná: no; Název rodiny: Kamery.CC
Classification: DV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0329857 m2; NetVolume: 0.000480116 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BXC; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 1877.16 mm; Výška od podlaží: 1877.16 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000480116 m3
Identifikační data - Kód prvku: DV01.05.0047; Označení: 0047
Jiné - Rodina: Kamery.CC; Id typu: 688037; Rodina a typ: Kamery.CC: Venkovní pevná DOME_stropní; Typ: Venkovní pevná DOME_stropní; úhel: 90 deg; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:07

# IfcBuildingElementProxy: Kamery.CC:Vnitřní pevná DOME_nástěnná (23)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Typ symbolu: Kamera vnitřní pevná DOME.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.17.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: DV01; Komentáře k typům: venkovní, DOME; Model: Model; Nadpis OmniClass: Video Surveillance; Název typu: Vnitřní pevná DOME_nástěnná; Označení typu: 04; Popis: Kamera; Popis sestavy: Kamera; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; FAKTOR ÚČINNOSTI: 1; DOME: yes; Nástěnná: yes; Název rodiny: Kamery.CC; Pevná: no; PTZ (otočná): no
Classification: DV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0329857 m2; NetVolume: 0.000480116 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BXC; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000480116 m3
Jiné - Id typu: 688043; Rodina: Kamery.CC; Rodina a typ: Kamery.CC: Vnitřní pevná DOME_nástěnná; Typ: Vnitřní pevná DOME_nástěnná; úhel: 180 deg; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:07
Name (Kamery.CC:Vnitřní pevná DOME_nástěnná:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
688396 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 3000 | DV01.04.0027 | 0027
688417 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | DV01.04.0028 | 0028
688459 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | DV01.04.0029 | 0029
688465 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | DV01.04.0030 | 0030
688474 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | DV01.04.0031 | 0031
688480 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | DV01.04.0032 | 0032
688486 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | DV01.04.0033 | 0033
688492 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | DV01.04.0034 | 0034
688501 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0035 | 0035
688507 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0036 | 0036
688513 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0037 | 0037
688525 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0038 | 0038
688534 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0039 | 0039
688540 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0040 | 0040
688546 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0041 | 0041
688552 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0042 | 0042
688561 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0043 | 0043
688570 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3000 | DV01.04.0044 | 0044
688582 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | DV01.04.0045 | 0045
688588 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | DV01.04.0046 | 0046
712484 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0095 | 0095
712494 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | DV01.04.0096 | 0096
712521 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | DV01.04.0097 | 0097

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 12 modulů (25)
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 12
Type - Kóty - DÉLKA: 215 mm; HLOUBKA: 50 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 12 modulů; Označení typu: 05; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 90 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.26051 m2
Text - CCI Funkční systém: M; CCI Komponenta: XGB; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - Materiál: Červená
Grafika - Úhel natočení: 0 deg; Víko: no; SESTAVA_POPIS: PPXX
Kóty - Objem: 0.00109618 m3
Jiné - Rodina: Podlahová krabice.CC; H: -55 mm; iD: 225 mm; Id typu: 318547; iH: 40 mm; iS: 265 mm; O: -40 mm; oD: 235 mm; oS: 275 mm; pm: 4; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 12 modulů; Typ: Podlahová krabice - 12 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:11
Name (Podlahová krabice.CC:Podlahová krabice - 12 modulů:...) | In | NetVolume (m3) | Podlaží | Hostitel | Kód prvku | Označení
674039 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0008 | 0008
674054 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0009 | 0009
674069 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0010 | 0010
674084 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0011 | 0011
674099 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0012 | 0012
674114 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0013 | 0013
674438 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0014 | 0014
674458 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0015 | 0015
674478 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0016 | 0016
674496 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0017 | 0017
674514 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0018 | 0018
674534 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0019 | 0019
674594 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0020 | 0020
674612 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0021 | 0021
674702 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0022 | 0022
675103 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0023 | 0023
675168 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0024 | 0024
675186 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0025 | 0025
725031 | -1.PP_SO-101 | 0.00109617 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PQ00.05.0026 | 0026
725046 | -1.PP_SO-101 | 0.00109617 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | PQ00.05.0027 | 0027
749943 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0029 | 0029
749960 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.05.0030 | 0030
750433 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0031 | 0031
750445 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0032 | 0032
750455 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.05.0033 | 0033

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 18 modulů (2)
In: 2.NP_SO-101
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 18
Type - Kóty - DÉLKA: 255 mm; HLOUBKA: 65 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 18 modulů; Označení typu: 03; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 135 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.32467 m2; NetVolume: 0.00134997 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGB; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-101; Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - Materiál: Červená
Grafika - SESTAVA_POPIS: PPXX; Úhel natočení: 0 deg; Víko: no
Kóty - Objem: 0.00134997 m3
Jiné - H: -70 mm; iD: 265 mm; Id typu: 330022; iH: 40 mm; iS: 265 mm; O: -55 mm; oD: 275 mm; oS: 275 mm; pm: 6; Rodina: Podlahová krabice.CC; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 18 modulů; Typ: Podlahová krabice - 18 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:17
Name (Podlahová krabice.CC:Podlahová krabice - 18 modulů:...) | Kód prvku | Označení
663068 | PQ00.03.0003 | 0003
666594 | PQ00.03.0004 | 0004

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 2x, Vícerámečky, vodovné.CC:Vícerámečky - 2x:673037
In: 2.NP_SO-101
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 2x; Označení typu: 04; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P5: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 2; P2: 71 mm; P3: 0 mm; P4: 0 mm; ST: 35.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.02017 m2; NetVolume: 0.00004015 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-101; Vztažné podlaží: 2.NP_SO-101; Hostitel: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt; Výška od podlaží: 300 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.00004015 m3
Identifikační data - Kód prvku: MT00.04.0006; Označení: 0006
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 358944; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 2x; S: 151 mm; Typ: Vícerámečky - 2x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:13

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 4x (3)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 2556.9 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 4x; Označení typu: 02; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 4; P2: 71 mm; P3: 142 mm; P4: 213 mm; P5: 0 mm; ST: 106.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03801 m2; NetVolume: 0.0000767 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Hostitel: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt; Výška od podlaží: 2556.9 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000767 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 361876; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 4x; S: 293 mm; Typ: Vícerámečky - 4x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 4x:...) | In | Podlaží = Vztažné podlaží | Kód prvku | Označení
662926 | 2.NP_SO-101 | 2.NP_SO-101 | MT00.02.0002 | 0002
666673 | 2.NP_SO-101 | 2.NP_SO-101 | MT00.02.0005 | 0005
673284 | 1.NP_SO-101 | 1.NP_SO-101 | MT00.02.0007 | 0007

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 5x (2)
In: 1.NP_SO-101
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 5x; Označení typu: 01; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: Vícerámečky, vodovné.CC; P: 5; P2: 71 mm; P3: 142 mm; P4: 213 mm; P5: 284 mm; P6: 0 mm; ST: 142 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.04693 m2; NetVolume: 0.000094975 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000094975 m3
Jiné - Id typu: 362928; Rodina: Vícerámečky, vodovné.CC; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 5x; S: 364 mm; Typ: Vícerámečky - 5x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 5x:...) | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
659187 | Osamocené | 2556.94 | MT00.01.0001 | 0001
749397 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2656.94 | MT00.01.0028 | 0028

# IfcBuildingElementProxy: Závrtný kontakt do oken.CC:Závrtný kontakt do oken.CC (41)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1500 mm
Type - Grafika - Posun horizontální: 0
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN07; Komentáře k typům: závrtný; Model: Model; Nadpis OmniClass: Presence Detection/Registration; Název typu: Závrtný kontakt do oken.CC; Označení typu: 03; Popis: Magnetický kontakt; Popis sestavy: Magnetický kontakt; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Závrtný kontakt do oken.CC
Classification: PN07 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0319957 m2; NetVolume: 0.000169111 m3
Text - CCI Funkční systém: M; CCI Komponenta: BED; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun vertikální: 0
Kóty - Objem: 0.000169111 m3
Jiné - Id typu: 682189; Rodina: Závrtný kontakt do oken.CC; Rodina a typ: Závrtný kontakt do oken.CC: Závrtný kontakt do oken.CC; Typ: Závrtný kontakt do oken.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:13
Name (Závrtný kontakt do oken.CC:Závrtný kontakt do oken.CC:...) | In | Odsazení od hostitele (mm) | Pracovní rovina | Výška od podlaží (mm) | Kód prvku | Označení
684544 | 1.NP_SO-101 | 1470 | <nepřiřazeno> | 1670 | PN07.03.0003 | 0003 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
684636 | -1.PP_SO-101 | -270 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 1240 | PN07.03.0005 | 0005 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
684678 | -1.PP_SO-101 | 0 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 1510 | PN07.03.0006 | 0006 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
684757 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 1970 | PN07.03.0008 | 0008 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
684790 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 1970 | PN07.03.0009 | 0009 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
684834 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 1970 | PN07.03.0013 | 0013 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
684849 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 1970 | PN07.03.0016 | 0016 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
688221 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0019 | 0019 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
688230 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0020 | 0020 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
688241 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0021 | 0021 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
688973 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0048 | 0048
688984 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0051 | 0051
689027 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0054 | 0054
689102 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0055 | 0055
689106 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0058 | 0058
689122 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0061 | 0061
689220 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0062 | 0062
694751 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0072 | 0072
695248 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 1970 | PN07.03.0087 | 0087 | Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
695382 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0090 | 0090 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
753786 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0099 | 0099 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
753794 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0100 | 0100 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
753861 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0103 | 0103 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
753869 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0104 | 0104 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
753877 | -1.PP_SO-101 | -270 | <nepřiřazeno> | 1970 | PN07.03.0105 | 0105 | Vazby - Podlaží: -1.PP_SO-101; Vztažné podlaží: -1.PP_SO-101
754084 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 0 | PN07.03.0111 | 0111
754101 | 1.NP_SO-101 | 1355 | <nepřiřazeno> | 0 | PN07.03.0115 | 0115
754295 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0120 | 0120
754363 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0124 | 0124
754429 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0128 | 0128
754441 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0132 | 0132
754486 | 2.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0136 | 0136
754704 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0140 | 0140
754717 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0144 | 0144
754729 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0148 | 0148
754741 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0152 | 0152
754805 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0158 | 0158
754817 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0162 | 0162
754829 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0166 | 0166
754841 | 3.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0170 | 0170
754949 | 4.NP_SO-101 | 0 | <nepřiřazeno> | 0 | PN07.03.0172 | 0172

# IfcBuildingElementProxy: Čtečka karet.CC:Typ 2 (40)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 1500 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 50 mm; Hloubka zapuštění: 35.4392 mm; ŠÍŘKA: 100 mm; VÝŠKA: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL01; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Typ 2; Označení typu: 06; Popis: Popis; Popis sestavy: Čtečka karet; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Čtečka karet.CC
Classification: OL01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.070267 m2; NetVolume: 0.00100006 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BYA; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00100006 m3
Jiné - Id typu: 694584; Rodina: Čtečka karet.CC; Rodina a typ: Čtečka karet.CC: Typ 2; Typ: Typ 2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:14
Name (Čtečka karet.CC:Typ 2:...) | In | Podlaží | Hostitel | Kód prvku | Označení
694600 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0065 | 0065
694627 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0066 | 0066
694657 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0067 | 0067
694669 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0068 | 0068
694675 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0069 | 0069
694719 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0070 | 0070
694725 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0071 | 0071
694792 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0074 | 0074
694798 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0075 | 0075
694825 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0076 | 0076
694841 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0077 | 0077
694847 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0078 | 0078
694887 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0079 | 0079
694893 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0080 | 0080
694899 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0081 | 0081
694905 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0082 | 0082
694911 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0083 | 0083
695191 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0085 | 0085
695410 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0091 | 0091
753763 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0098 | 0098
753902 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0106 | 0106
753939 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0107 | 0107
753947 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OL01.06.0108 | 0108
754086 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0112 | 0112
754102 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OL01.06.0116 | 0116
754298 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0122 | 0122
754365 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0126 | 0126
754428 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0127 | 0127
754440 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0131 | 0131
754485 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OL01.06.0135 | 0135
754646 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0138 | 0138
754707 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0142 | 0142
754719 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0146 | 0146
754731 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0150 | 0150
754743 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0154 | 0154
754806 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0159 | 0159
754818 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0163 | 0163
754830 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0167 | 0167
754842 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OL01.06.0171 | 0171
754953 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | OL01.06.0175 | 0175

# IfcCableCarrierFitting: Parapetní žlab_Koleno:Standardní, Parapetní žlab_Koleno:Standardní:712860
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Kód sestavy: KT01; Název typu: Standardní; Označení typu: 01; Popis sestavy: Oblouk žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Parapetní žlab_Koleno
Classification: KT01 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 662.5 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Délka lávky: 100 mm; Objem: 0.0020305 m3; Poloměr ohybu: 131 mm; Šířka lávky: 62 mm; Tloušťka: 2.54 mm; Úhel: 90 deg; Velikost: 62 mmx125 mmø-62 mmx125 mmø; Výška lávky: 125 mm
Identifikační data - Kód prvku: KT01.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Délka 1: 131 mm; Délka 2: 102.54 mm; Délka 3: 56.92 mm; Id typu: 15977; Max. úhel segmentace: 90 deg; Odsazení: 62.5 mm; Ohyb nebo tvarovka: Tvarovka; Rodina: Parapetní žlab_Koleno; Rodina a typ: Parapetní žlab_Koleno: Standardní; Štítek poloměru ohybu: 131 mm; Typ: Standardní; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:57

# IfcCableCarrierFitting: Žlab_Horizontální koleno:Standard (23)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.17; Kód sestavy: KT01; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: Standard; Označení typu: 02; Popis sestavy: Oblouk žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Žlab_Horizontální koleno
Classification: KT01 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Angle: 90 deg; Tloušťka: 2.54 mm; Tray Length: 5 mm
Jiné - Páteřní trasa: yes; Ohyb nebo tvarovka: Tvarovka; Id typu: 15956; Rodina: Žlab_Horizontální koleno; Rodina a typ: Žlab_Horizontální koleno: Standard; Typ: Standard
Name (Žlab_Horizontální koleno:Standard:...) | In | Podlaží | Výška od podlaží (mm) | Objem (m3) | Poloměr ohybu (mm) | Tray Height (mm) | Tray Width (mm) | Velikost | Kód prvku | Označení | Bend Radius Label (mm) | Center to End (mm)
758706 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.0004676 | 2 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0002 | 0002 | 53.175 | 58.175
758737 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.0004676 | 2 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0003 | 0003 | 53.175 | 58.175
758893 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.0004676 | 2 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0004 | 0004 | 53.175 | 58.175
759167 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.0004676 | 2 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0005 | 0005 | 53.175 | 58.175
759544 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0006 | 0006 | 36.175 | 41.175
759611 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0007 | 0007 | 36.175 | 41.175
759654 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0008 | 0008 | 36.175 | 41.175
759833 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0009 | 0009 | 36.175 | 41.175
759898 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0010 | 0010 | 36.175 | 41.175
759899 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0011 | 0011 | 36.175 | 41.175
760273 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0012 | 0012 | 36.175 | 41.175
760274 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0013 | 0013 | 36.175 | 41.175
760320 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0014 | 0014 | 36.175 | 41.175
760321 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0015 | 0015 | 36.175 | 41.175
760325 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0016 | 0016 | 36.175 | 41.175
760326 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT01.02.0017 | 0017 | 36.175 | 41.175
760699 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT01.02.0018 | 0018 | 34.175 | 39.175
760769 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT01.02.0019 | 0019 | 34.175 | 39.175
761012 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT01.02.0020 | 0020 | 34.175 | 39.175
761039 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT01.02.0021 | 0021 | 34.175 | 39.175
761283 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0022 | 0022 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 03:49
761291 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0023 | 0023 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 03:49
761392 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT01.02.0024 | 0024 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 03:49

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Kabelový žlab (22)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Spojení: Žlab_Spojka: Standard; Horizontální ohyb: Žlab_Horizontální koleno: Standard; Kříž: Žlab_Horizontální křížení: 300mm Radius; Přechod: Žlab_Redukce: Standard; T-spoj: Žlab_Horizontální odbočka: 300mm Radius; Vertikální vnější ohyb: Žlab_Svislé vnější koleno: R=300; Vertikální vnitřní ohyb: Žlab_Svislé vnitřní koleno: R=300
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ03; Komentáře k typům: 8 m;-1PP; Název typu: Kabelový žlab; Označení typu: 02; Popis: Kabelový žlab; Popis sestavy: Kabelová lávka a žebřík; Výrobce: KOPOS
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ03 Uniformat (Uniformat)
Qto_CableCarrierSegmentBaseQuantities - Length: 50 mm
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Horní výška: 775 mm; Koncová střední výška: 750 mm; Počáteční střední výška: 750 mm; Spodní výška: 725 mm; Střední výška: 750 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Šířka: 100 mm; Velikost: 100 mmx50 mmø; Výška: 50 mm
Jiné - Páteřní trasa: yes; Rodina: Kabelová lávka s tvarovkami; Id typu: 1976; Rodina a typ: Kabelová lávka s tvarovkami: Kabelový žlab; Typ: Kabelový žlab; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:57
Name (Kabelová lávka s tvarovkami:Kabelový žlab:...) | In | CrossSectionArea (m2) | OuterSurfaceArea (m2) | Referenční podlaží | Délka (mm) | Kód prvku | Označení
665984 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0004 | 0004
666201 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0005 | 0005
666209 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0006 | 0006
666245 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0007 | 0007
666270 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0008 | 0008
666303 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0009 | 0009
666340 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0010 | 0010
666341 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0011 | 0011
666392 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0012 | 0012
666393 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0013 | 0013
666420 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0014 | 0014
666421 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0015 | 0015
666429 | 2.NP_SO-101 | 0.35 | 0.36 | 2.NP_SO-101 | 3500 | KZ03.02.0016 | 0016
666430 | 2.NP_SO-101 | 0.35 | 0.36 | 2.NP_SO-101 | 3500 | KZ03.02.0017 | 0017
713076 | 2.NP_SO-101 | 0.271487 | 0.281487 | 2.NP_SO-101 | 2714.87 | KZ03.02.0023 | 0023
713146 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0024 | 0024
725134 | 1.NP_SO-101 | 0.232 | 0.242 | 1.NP_SO-101 | 2320 | KZ03.02.0025 | 0025
725159 | 1.NP_SO-101 | 0.25 | 0.26 | 1.NP_SO-101 | 2500 | KZ03.02.0026 | 0026
758796 | 2.NP_SO-101 | 0.320474 | 0.330474 | 2.NP_SO-101 | 3204.74 | KZ03.02.0031 | 0031
758942 | 2.NP_SO-101 | 0.00636686 | 0.0163669 | 2.NP_SO-101 | 63.6686 | KZ03.02.0032 | 0032
759168 | 2.NP_SO-101 | 0.00636686 | 0.0163669 | 2.NP_SO-101 | 63.6686 | KZ03.02.0033 | 0033
759206 | 2.NP_SO-101 | 0.0687556 | 0.0787556 | 2.NP_SO-101 | 687.556 | KZ03.02.0034 | 0034

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Parapetní žlab (31)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: Parapetní žlab_Koleno: Standardní; Spojení: Žlab_Spojka: Standard; T-spoj: Parapetní žlab_Odbočka: Standardní
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ04; Model: PK; Název typu: Parapetní žlab; Označení typu: 01; Popis: Parapetní kanál; Popis sestavy: Parapetní kanály
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ04 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Jiné - Id typu: 16025; Páteřní trasa: yes; Rodina: Kabelová lávka s tvarovkami; Rodina a typ: Kabelová lávka s tvarovkami: Parapetní žlab; Typ: Parapetní žlab; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:57
Name (Kabelová lávka s tvarovkami:Parapetní žlab:...) | In | Length (mm) = Výška (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | Horní výška (mm) | Koncová střední výška (mm) = Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Délka (mm) | Šířka (mm) | Velikost | Kód prvku | Označení
665005 | 2.NP_SO-101 | 125 | 0.17552 | 0.72324 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 2830.96 | 62 | 62 mmx125 mmø | KZ04.01.0001 | 0001
665017 | 2.NP_SO-101 | 125 | 0.186 | 0.7655 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 3000 | 62 | 62 mmx125 mmø | KZ04.01.0002 | 0002
665568 | 2.NP_SO-101 | 125 | 0.152881 | 0.631956 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 2465.83 | 62 | 62 mmx125 mmø | KZ04.01.0003 | 0003
673529 | 1.NP_SO-101 | 214 | 0.0764825 | 0.524225 | 707 | 600 | 1.NP_SO-101 | 493 | 1158.83 | 66 | 66 mmx214 mmø | KZ04.01.0018 | 0018
673670 | 1.NP_SO-101 | 214 | 0.165 | 1.09825 | 707 | 600 | 1.NP_SO-101 | 493 | 2500 | 66 | 66 mmx214 mmø | KZ04.01.0019 | 0019
673775 | 1.NP_SO-101 | 214 | 0.2772 | 1.82585 | 707 | 600 | 1.NP_SO-101 | 493 | 4200 | 66 | 66 mmx214 mmø | KZ04.01.0020 | 0020
712687 | 2.NP_SO-101 | 125 | 0.0502338 | 0.218056 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 810.222 | 62 | 62 mmx125 mmø | KZ04.01.0021 | 0021
712767 | 2.NP_SO-101 | 125 | 0.34844 | 1.4205 | 725 | 662.5 | 2.NP_SO-101 | 600 | 5620 | 62 | 62 mmx125 mmø | KZ04.01.0022 | 0022
752097 | 3.NP_SO-101 | 125 | 0.0917419 | 0.385427 | 1112.5 | 1050 | 3.NP_SO-101 | 987.5 | 1479.71 | 62 | 62 mmx125 mmø | KZ04.01.0027 | 0027
752132 | 3.NP_SO-101 | 125 | 0.093 | 0.3905 | 1112.5 | 1050 | 3.NP_SO-101 | 987.5 | 1500 | 62 | 62 mmx125 mmø | KZ04.01.0028 | 0028
752308 | 4.NP_SO-101 | 125 | 0.7998 | 3.2405 | 872.5 | 810 | 4.NP_SO-101 | 747.5 | 12900 | 62 | 62 mmx125 mmø | KZ04.01.0029 | 0029
752363 | 4.NP_SO-101 | 125 | 0.73408 | 2.9755 | 872.5 | 810 | 4.NP_SO-101 | 747.5 | 11840 | 62 | 62 mmx125 mmø | KZ04.01.0030 | 0030
759268 | 2.NP_SO-101 | 125 | 0.295116 | 1.20548 | 725 | 662.5 | 2.NP_SO-101 | 600 | 4759.94 | 62 | 62 mmx125 mmø | KZ04.01.0035 | 0035
759329 | 2.NP_SO-101 | 125 | 0.0511317 | 0.221676 | 725 | 662.5 | 2.NP_SO-101 | 600 | 824.705 | 62 | 62 mmx125 mmø | KZ04.01.0036 | 0036
759371 | 2.NP_SO-101 | 125 | 0.014818 | 0.07525 | 725 | 662.5 | 2.NP_SO-101 | 600 | 239 | 62 | 62 mmx125 mmø | KZ04.01.0037 | 0037
759460 | 1.NP_SO-101 | 214 | 0.122563 | 0.823053 | 707 | 600 | 1.NP_SO-101 | 493 | 1857.02 | 66 | 66 mmx214 mmø | KZ04.01.0038 | 0038
759750 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0039 | 0039
759834 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0040 | 0040
759850 | 1.NP_SO-101 | 214 | 0.0399702 | 0.287449 | 707 | 600 | 1.NP_SO-101 | 493 | 605.609 | 66 | 66 mmx214 mmø | KZ04.01.0041 | 0041
759901 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0042 | 0042
759902 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0043 | 0043
759903 | 1.NP_SO-101 | 214 | 0.0502926 | 0.354388 | 707 | 600 | 1.NP_SO-101 | 493 | 762.009 | 66 | 66 mmx214 mmø | KZ04.01.0044 | 0044
760127 | 1.NP_SO-101 | 214 | 0.077031 | 0.527782 | 707 | 600 | 1.NP_SO-101 | 493 | 1167.14 | 66 | 66 mmx214 mmø | KZ04.01.0045 | 0045
760322 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0046 | 0046
760323 | 1.NP_SO-101 | 214 | 0.0165124 | 0.135328 | 707 | 600 | 1.NP_SO-101 | 493 | 250.188 | 66 | 66 mmx214 mmø | KZ04.01.0047 | 0047
760324 | 1.NP_SO-101 | 214 | 0.0502926 | 0.354388 | 707 | 600 | 1.NP_SO-101 | 493 | 762.009 | 66 | 66 mmx214 mmø | KZ04.01.0048 | 0048
760382 | 1.NP_SO-101 | 214 | 0.117037 | 0.787217 | 707 | 600 | 1.NP_SO-101 | 493 | 1773.29 | 66 | 66 mmx214 mmø | KZ04.01.0049 | 0049
760662 | 2.NP_SO-101 | 125 | 0.133847 | 0.555205 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 2158.82 | 62 | 62 mmx125 mmø | KZ04.01.0050 | 0050
760889 | 2.NP_SO-101 | 125 | 0.0317223 | 0.143413 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 511.65 | 62 | 62 mmx125 mmø | KZ04.01.0051 | 0051
760918 | 2.NP_SO-101 | 125 | 0.0105872 | 0.0581905 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 170.762 | 62 | 62 mmx125 mmø | KZ04.01.0052 | 0052
761059 | 2.NP_SO-101 | 125 | 0.0105872 | 0.0581905 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 170.762 | 62 | 62 mmx125 mmø | KZ04.01.0053 | 0053

# IfcDistributionPort (765)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_657258_1 | CABLE | DATA
Port_657259_1 | CABLE | DATA
Port_658529_1 | CABLE | DATA
Port_658530_1 | CABLE | DATA
Port_658802_1 | CABLE | DATA
Port_658803_1 | CABLE | DATA
Port_658907_1 | CABLE | DATA
Port_658908_1 | CABLE | DATA
Port_658938_1 | CABLE | DATA
Port_658939_1 | CABLE | DATA
Port_658950_1 | CABLE | DATA
Port_658951_1 | CABLE | DATA
Port_658962_1 | CABLE | DATA
Port_658963_1 | CABLE | DATA
Port_659028_1 | CABLE | DATA
Port_659029_1 | CABLE | DATA
Port_659039_1 | CABLE | DATA
Port_659040_1 | CABLE | DATA
Port_659176_1 | CABLE | DATA
Port_659177_1 | CABLE | DATA
Port_659192_1 | CABLE | DATA
Port_659193_1 | CABLE | DATA
Port_661862_1 | CABLE | DATA
Port_661918_1 | CABLE | DATA
Port_661919_1 | CABLE | DATA
Port_661920_1 | CABLE | DATA
Port_661921_1 | CABLE | DATA
Port_661924_1 | CABLE | DATA
Port_661925_1 | CABLE | DATA
Port_661926_1 | CABLE | DATA
Port_661927_1 | CABLE | DATA
Port_661934_1 | CABLE | DATA
Port_661935_1 | CABLE | DATA
Port_661936_1 | CABLE | DATA
Port_661937_1 | CABLE | DATA
Port_661938_1 | CABLE | DATA
Port_661939_1 | CABLE | DATA
Port_661940_1 | CABLE | DATA
Port_661941_1 | CABLE | DATA
Port_661942_1 | CABLE | DATA
Port_661943_1 | CABLE | DATA
Port_661950_1 | CABLE | DATA
Port_661951_1 | CABLE | DATA
Port_661952_1 | CABLE | DATA
Port_661953_1 | CABLE | DATA
Port_661954_1 | CABLE | DATA
Port_661955_1 | CABLE | DATA
Port_661956_1 | CABLE | DATA
Port_661957_1 | CABLE | DATA
Port_661958_1 | CABLE | DATA
Port_661959_1 | CABLE | DATA
Port_661966_1 | CABLE | DATA
Port_661967_1 | CABLE | DATA
Port_661972_1 | CABLE | DATA
Port_661973_1 | CABLE | DATA
Port_661974_1 | CABLE | DATA
Port_661975_1 | CABLE | DATA
Port_663015_1 | CABLE | DATA
Port_663039_1 | CABLE | DATA
Port_663075_1 | CABLE | DATA
Port_663076_1 | CABLE | DATA
Port_663077_1 | CABLE | DATA
Port_665005_0 | CABLECARRIER | CONVEYING
Port_665005_1 | CABLECARRIER | CONVEYING
Port_665017_0 | CABLECARRIER | CONVEYING
Port_665017_1 | CABLECARRIER | CONVEYING
Port_665568_0 | CABLECARRIER | CONVEYING
Port_665568_1 | CABLECARRIER | CONVEYING
Port_665910_1 | CABLE | DATA
Port_665911_1 | CABLE | DATA
Port_665948_1 | CABLE | DATA
Port_665949_1 | CABLE | DATA
Port_665984_0 | CABLECARRIER | CONVEYING
Port_665984_1 | CABLECARRIER | CONVEYING
Port_666201_0 | CABLECARRIER | CONVEYING
Port_666201_1 | CABLECARRIER | CONVEYING
Port_666209_0 | CABLECARRIER | CONVEYING
Port_666209_1 | CABLECARRIER | CONVEYING
Port_666245_0 | CABLECARRIER | CONVEYING
Port_666245_1 | CABLECARRIER | CONVEYING
Port_666270_0 | CABLECARRIER | CONVEYING
Port_666270_1 | CABLECARRIER | CONVEYING
Port_666303_0 | CABLECARRIER | CONVEYING
Port_666303_1 | CABLECARRIER | CONVEYING
