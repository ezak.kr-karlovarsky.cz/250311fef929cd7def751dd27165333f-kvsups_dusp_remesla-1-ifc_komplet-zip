Properties of the parts of a building model (IFC4), part 3 of 3

# IfcElectricAppliance: HDMI zásuvka do PK.CC:Jednozásuvka 1x modul (3)
Name (HDMI zásuvka do PK.CC:Jednozásuvka 1x modul:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Hostitel | Kód prvku | Označení
663077 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.06.0062 | 0062
666603 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | ZZ03.06.0069 | 0069
673272 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ03.06.0167 | 0167

# IfcElectricAppliance: HDMI zásuvka_vícerámečky.CC:Dvojzásuvka (7)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 2556.9 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Šířka: 45 mm; Typ symbolu: HDMI zásuvka.CC
Type - Kóty - Hloubka: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: druhá klapka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka; Označení typu: 04; Popis: Vypínač; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: HDMI zásuvka_vícerámečky.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00002025 m3
Jiné - Typ: Dvojzásuvka; Id typu: 659264; Rodina: HDMI zásuvka_vícerámečky.CC; Rodina a typ: HDMI zásuvka_vícerámečky.CC: Dvojzásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
Name (HDMI zásuvka_vícerámečky.CC:Dvojzásuvka:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
659193 | 1.NP_SO-101 | 1.NP_SO-101 | <nepřiřazeno> | 2557 | ZZ03.04.0022 | 0022
661862 | 1.NP_SO-101 | 1.NP_SO-101 | <nepřiřazeno> | 2557 | ZZ03.04.0023 | 0023
663015 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2556.9 | ZZ03.04.0058 | 0058
666782 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ03.04.0071 | 0071
673411 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ03.04.0169 | 0169
749438 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2696.94 | ZZ03.04.0314 | 0314
749439 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2696.94 | ZZ03.04.0315 | 0315

# IfcElectricAppliance: Telefony.CC:Typ 1 - Horizontální (11)
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol typ 1: yes; Symbol typ2: no; Typ 1 - Horizontální: yes; Typ 1 - Vertikální: no; Typ 2 - Horizontální: no; Typ 2 - Vertikální: no
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SB00; Komentáře k typům: typ 1, horizontální; Model: Model; Nadpis OmniClass: Audio Information, Sound Signals; Název typu: Typ 1 - Horizontální; Označení typu: 11; Popis: Telefon; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Telefony.CC
Classification: SB00 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: TFE; CCI Technický systém: JL
Vazby - Podlaží: 3.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 3.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00146351 m3; Šířka Typ 1: 150 mm; Šířka Typ 2: 60 mm; Výška: 150 mm
Jiné - Id typu: 693037; Rodina: Telefony.CC; Rodina a typ: Telefony.CC: Typ 1 - Horizontální; Typ: Typ 1 - Horizontální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:13
Name (Telefony.CC:Typ 1 - Horizontální:...) | Kód prvku | Označení
693059 | SB00.11.0277 | 0277
693063 | SB00.11.0278 | 0278
693067 | SB00.11.0279 | 0279
693071 | SB00.11.0280 | 0280
693075 | SB00.11.0281 | 0281
693079 | SB00.11.0282 | 0282
693083 | SB00.11.0283 | 0283
693087 | SB00.11.0284 | 0284
693091 | SB00.11.0285 | 0285
712541 | SB00.11.0286 | 0286
712549 | SB00.11.0287 | 0287

# IfcElectricAppliance: WiFi.CC:WiFi Router Vertikální (32)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Horizontální: no; Symbol: yes; Vertikální: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.50.17.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SB00; Komentáře k typům: vertikální; Model: Model; Nadpis OmniClass: Network Routers; Název typu: WiFi Router Vertikální; Označení typu: 01; Popis: WiFi; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: WiFi.CC
Classification: SB00 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: KEC; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 220 mm; Objem: 0.00292104 m3; ŠÍŘKA: 220 mm; VÝŠKA: 60 mm
Jiné - Id typu: 657295; Rodina: WiFi.CC; Rodina a typ: WiFi.CC: WiFi Router Vertikální; Typ: WiFi Router Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:13
Name (WiFi.CC:WiFi Router Vertikální:...) | In | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Kód prvku | Označení
657258 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0001 | 0001
658529 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0003 | 0003
658802 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0005 | 0005
658907 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0007 | 0007
658938 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0009 | 0009
658950 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0011 | 0011
658962 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0013 | 0013
659028 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0015 | 0015
659039 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | -1.PP_SO-101 | SB00.01.0017 | 0017
659176 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0019 | 0019
661918 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3400 | 1.NP_SO-101 | SB00.01.0024 | 0024
661920 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0026 | 0026
661924 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0028 | 0028
661926 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3300 | 1.NP_SO-101 | SB00.01.0030 | 0030
661934 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3400 | 2.NP_SO-101 | SB00.01.0032 | 0032
661936 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | 2.NP_SO-101 | SB00.01.0034 | 0034
661938 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | 2.NP_SO-101 | SB00.01.0036 | 0036
661940 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | 2.NP_SO-101 | SB00.01.0038 | 0038
661942 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3300 | 2.NP_SO-101 | SB00.01.0040 | 0040
661950 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | 3.NP_SO-101 | SB00.01.0042 | 0042
661952 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | 3.NP_SO-101 | SB00.01.0044 | 0044
661954 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3500 | 3.NP_SO-101 | SB00.01.0046 | 0046
661956 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | 3.NP_SO-101 | SB00.01.0048 | 0048
661958 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2500 | 3.NP_SO-101 | SB00.01.0050 | 0050
661966 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | 4.NP_SO-101 | SB00.01.0052 | 0052
661972 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | 4.NP_SO-101 | SB00.01.0054 | 0054
661974 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 2500 | 4.NP_SO-101 | SB00.01.0056 | 0056
665910 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0063 | 0063
665948 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | 2.NP_SO-101 | SB00.01.0065 | 0065
667028 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3500 | 2.NP_SO-101 | SB00.01.0072 | 0072
673190 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | 1.NP_SO-101 | SB00.01.0163 | 0163
712586 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3300 | 2.NP_SO-101 | SB00.01.0288 | 0288
