Properties of the parts of a building model (IFC4), part 15 of 26

# IfcPipeFitting: M_Koleno, obecné:Standardní (577)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | CCI Funkční systém | CCI Komponenta | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13162407 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 2.NP_SO-101 | 3325 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0434 | 0434 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13162419 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 2.NP_SO-101 | 3325 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0435 | 0435 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13162427 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 2.NP_SO-101 | 3325 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0436 | 0436 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13162786 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 2.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0438 | 0438 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13162788 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 2.NP_SO-101 | 3325 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0439 | 0439 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13163338 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3635.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0440 | 0440 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13163513 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0441 | 0441 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13163591 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0443 | 0443 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13163760 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0446 | 0446 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13163938 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2728.34 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0447 | 0447 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13163986 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0448 | 0448 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13164304 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 3015.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0449 | 0449 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13164318 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 3015.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0450 | 0450 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13164326 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 3015.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0451 | 0451 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13164336 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 3015.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0452 | 0452 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13164437 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 3015.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0453 | 0453 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13164487 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0454 | 0454 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13173549 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0465 | 0465 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13173695 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0467 | 0467 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13173753 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0468 | 0468 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13190168 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1351.26 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0469 | 0469 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13190253 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1559.23 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0471 | 0471 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13190318 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1553.74 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0472 | 0472 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13190377 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1383.31 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0473 | 0473 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13190381 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1550.92 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0474 | 0474 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13190661 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0475 | 0475 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13191504 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0482 | 0482 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13191609 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0483 | 0483 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13192056 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 50 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0486 | 0486 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13192148 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 50 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0488 | 0488 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13198774 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0494 | 0494 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13198776 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0495 | 0495 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199359 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3318.14 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0500 | 0500 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199363 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3318.14 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0501 | 0501 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199487 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3318.14 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0502 | 0502 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199491 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3318.14 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0503 | 0503 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199669 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 800 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0505 | 0505 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199677 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0506 | 0506 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199679 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0507 | 0507 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199714 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0508 | 0508 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13199802 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 1000 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0509 | 0509 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13202960 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1660.58 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0513 | 0513 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203145 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -479.847 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0514 | 0514 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203157 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -637.503 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0515 | 0515 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203241 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -469.321 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0516 | 0516 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203598 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1304.61 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0517 | 0517 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203602 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1506.58 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0518 | 0518 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203677 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -275.827 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0519 | 0519 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13203730 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -253.286 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0521 | 0521 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13205198 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 3321.06 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0522 | 0522 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13205382 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 3460.89 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0524 | 0524 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13207380 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1446.82 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0525 | 0525 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13207397 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1653.19 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0526 | 0526 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13207401 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1693.36 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0527 | 0527 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13207749 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -555.224 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0528 | 0528 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13214505 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2430.82 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0529 | 0529 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216873 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | 2856.48 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0534 | 0534 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13217140 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2427.01 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000888097 | 31.2355 | 44.9848 | ø135-ø135 | 22.885 | 138.175 | TT01.02.0535 | 0535 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10
13217579 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 3306.68 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0536 | 0536 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13217586 | 3.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 3.NP_SO-101 | 3327.41 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000530284 | 28.0149 | 47.9898 | ø110-ø110 | 20.1507 | 113.175 | TT01.02.0538 | 0538 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13217817 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 2.NP_SO-101 | 3440.69 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0539 | 0539 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13217821 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 2.NP_SO-101 | 3440.69 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0540 | 0540 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13217823 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 2.NP_SO-101 | 3449.2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0541 | 0541 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13219153 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1646.46 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497096 | 26.0608 | 44.9864 | ø110-ø110 | 18.7451 | 113.175 | TT01.02.0542 | 0542 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13219192 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1640.58 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0543 | 0543 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13221870 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1787.05 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497393 | 26.0781 | 45.0132 | ø110-ø110 | 18.7576 | 113.175 | TT01.02.0547 | 0547 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13228154 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1567.22 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000981838 | 61.6907 | 88.8537 | ø110-ø110 | 44.3732 | 113.175 | TT01.02.0548 | 0548 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13229529 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0557 | 0557 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13231854 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0564 | 0564 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13231856 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0565 | 0565 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13233971 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0566 | 0566 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13233991 | 2.NP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0567 | 0567 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13234021 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 2.NP_SO-101 | 3401.81 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.000035934 | 23.919 | 90.2556 | ø32-ø32 | 14.0325 | 34.925 | TT01.02.0568 | 0568 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13234026 | 2.NP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0569 | 0569 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13234031 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0570 | 0570 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13234039 | 2.NP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0571 | 0571 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13234168 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 580 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0572 | 0572 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151 | Mechanické – tok - Tlaková ztráta: 0 Pa
13234175 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 580 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0574 | 0574 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13234220 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 60.7992 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0576 | 0576 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13234865 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1580.4 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0579 | 0579 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13234869 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1592.52 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0580 | 0580 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13234905 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1535.47 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0581 | 0581 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13234970 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1571.73 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000441974 | 22.9061 | 39.9979 | ø110-ø110 | 16.476 | 113.175 | TT01.02.0582 | 0582 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235200 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1566.58 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0584 | 0584 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13235204 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1577.24 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497145 | 26.0636 | 44.9908 | ø110-ø110 | 18.7472 | 113.175 | TT01.02.0585 | 0585 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13235580 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1664.88 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0588 | 0588 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235641 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1703.43 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0589 | 0589 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235672 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1693.43 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00098185 | 61.6919 | 88.8547 | ø110-ø110 | 44.374 | 113.175 | TT01.02.0590 | 0590 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235676 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1721.72 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0591 | 0591 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235885 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1638.56 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0593 | 0593 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235889 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1656.78 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497132 | 26.0629 | 44.9896 | ø110-ø110 | 18.7466 | 113.175 | TT01.02.0594 | 0594 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13235914 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1717.95 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0595 | 0595 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13236025 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1736.15 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497148 | 26.0639 | 44.9911 | ø110-ø110 | 18.7473 | 113.175 | TT01.02.0596 | 0596 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13236538 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1471.24 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0598 | 0598 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13236542 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1530.86 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0599 | 0599 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13238782 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3373.7 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.0003767 | 46.008 | 88.8541 | ø78-ø78 | 31.827 | 81.175 | TT01.02.0600 | 0600 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239090 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3531.16 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000852665 | 15.3001 | 45.0002 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.0602 | 0602 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239109 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3414.11 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000830951 | 14.8691 | 43.8542 | ø58-ø58 | 9.85033 | 61.175 | TT01.02.0603 | 0603 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239392 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3510.28 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.0605 | 0605 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239418 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3560.18 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.0607 | 0607 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239640 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3364.15 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0610 | 0610 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239749 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3373.02 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190728 | 19.4366 | 44.9885 | ø78-ø78 | 13.4457 | 81.175 | TT01.02.0612 | 0612 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239875 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3574.96 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.000085263 | 15.2994 | 44.9983 | ø58-ø58 | 10.1354 | 61.175 | TT01.02.0613 | 0613 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239894 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3456.25 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000830951 | 14.8691 | 43.8542 | ø58-ø58 | 9.85033 | 61.175 | TT01.02.0614 | 0614 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239899 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3382.45 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0615 | 0615 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13240018 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3560.18 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.0616 | 0616 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13240317 | 1.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 1.NP_SO-101 | 3586.73 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.0618 | 0618 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13240600 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3263.89 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190725 | 19.4362 | 44.9877 | ø78-ø78 | 13.4454 | 81.175 | TT01.02.0622 | 0622 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13240721 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3255.26 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000194398 | 19.8534 | 45.8542 | ø78-ø78 | 13.734 | 81.175 | TT01.02.0623 | 0623 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242383 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0625 | 0625 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13242396 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119342 | 33.131 | 89.644 | ø50-ø50 | 21.4563 | 53.975 | TT01.02.0627 | 0627 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13261779 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1407.37 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0629 | 0629 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13261786 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1544.47 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0630 | 0630 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13262447 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0643 | 0643 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13262772 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | -1.PP_SO-101 | 2400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0646 | 0646 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13262774 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | -1.PP_SO-101 | 2400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0647 | 0647 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13264534 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0656 | 0656 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13264542 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0657 | 0657 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13264676 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0660 | 0660 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13265034 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0664 | 0664 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13267758 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2417.73 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0665 | 0665 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13267910 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2425.98 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190711 | 19.4347 | 44.9845 | ø78-ø78 | 13.4444 | 81.175 | TT01.02.0666 | 0666 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13268067 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2445.56 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0667 | 0667 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13271544 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2386.8 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000169544 | 17.08 | 39.9917 | ø78-ø78 | 11.8154 | 81.175 | TT01.02.0668 | 0668 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273413 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 629.221 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000248443 | 26.3412 | 58.6021 | ø78-ø78 | 18.2221 | 81.175 | TT01.02.0671 | 0671 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273425 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 634.676 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190686 | 19.4319 | 44.9787 | ø78-ø78 | 13.4424 | 81.175 | TT01.02.0672 | 0672 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273543 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3353.32 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0673 | 0673 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273554 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3343.43 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0674 | 0674 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273715 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2624.48 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190712 | 19.4348 | 44.9848 | ø78-ø78 | 13.4445 | 81.175 | TT01.02.0675 | 0675 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13273998 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3264.04 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0676 | 0676 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13274370 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3331.5 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190758 | 19.44 | 44.9956 | ø78-ø78 | 13.4481 | 81.175 | TT01.02.0678 | 0678 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13274510 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 2956.22 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0679 | 0679 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13274659 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3319.2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190682 | 19.4314 | 44.9776 | ø78-ø78 | 13.4421 | 81.175 | TT01.02.0680 | 0680 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13274663 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3304.56 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0681 | 0681 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275510 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 2610.42 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0682 | 0682 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275552 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 2843.48 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0683 | 0683 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275635 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 3590.39 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0684 | 0684 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275639 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 3453.06 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0685 | 0685 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275718 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | 3113.91 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0686 | 0686 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13275981 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3327.77 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8543 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0695 | 0695 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13276211 | 2.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 2.NP_SO-101 | -53.9576 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0696 | 0696 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13276216 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3626.04 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0697 | 0697 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13277816 | -1.PP_SO-101 | ø200 mm-ø200 mm | G | WPA | JD | -1.PP_SO-101 | 2221.08 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 100 | 200 | 0.00287704 | 45.3613 | 44.9905 | ø200-ø200 | 34.1853 | 206.375 | TT01.02.0698 | 0698 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 10
13277950 | -1.PP_SO-101 | ø250 mm-ø250 mm | G | WPA | JD | -1.PP_SO-101 | -1204.29 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 125 | 250 | 0.00550376 | 55.8799 | 44.9905 | ø250-ø250 | 42.6002 | 257.175 | TT01.02.0699 | 0699 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 10
13277962 | -1.PP_SO-101 | ø250 mm-ø250 mm | G | WPA | JD | -1.PP_SO-101 | -1151.65 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 125 | 250 | 0.00550376 | 55.8799 | 44.9905 | ø250-ø250 | 42.6002 | 257.175 | TT01.02.0700 | 0700 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 10
13278255 | -1.PP_SO-101 | ø200 mm-ø200 mm | G | WPA | JD | -1.PP_SO-101 | 2204.84 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 100 | 200 | 0.00287704 | 45.3613 | 44.9905 | ø200-ø200 | 34.1853 | 206.375 | TT01.02.0701 | 0701 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 10
13278259 | -1.PP_SO-101 | ø200 mm-ø200 mm | G | WPA | JD | -1.PP_SO-101 | 2163.36 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 100 | 200 | 0.0056821 | 107.369 | 88.8542 | ø200-ø200 | 80.9155 | 206.375 | TT01.02.0702 | 0702 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 10
13278352 | -1.PP_SO-101 | ø250 mm-ø250 mm | G | WPA | JD | -1.PP_SO-101 | -695.038 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 125 | 250 | 0.00550492 | 55.8929 | 45 | ø250-ø250 | 42.6101 | 257.175 | TT01.02.0703 | 0703 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 10
13278357 | -1.PP_SO-101 | ø250 mm-ø250 mm | G | WPA | JD | -1.PP_SO-101 | -1130.36 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 125 | 250 | 0.00536476 | 54.3187 | 43.8542 | ø250-ø250 | 41.41 | 257.175 | TT01.02.0704 | 0704 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 10
13278558 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2251.5 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00088821 | 31.2399 | 44.9905 | ø135-ø135 | 22.8882 | 138.175 | TT01.02.0706 | 0706 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10
13278775 | -1.PP_SO-101 | ø160 mm-ø160 mm | G | WPA | JD | -1.PP_SO-101 | 2386.35 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0710 | 0710 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278786 | -1.PP_SO-101 | ø160 mm-ø160 mm | G | WPA | JD | -1.PP_SO-101 | 2380.5 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0711 | 0711 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13279264 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | 2644 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0716 | 0716 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13279268 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | 2644 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0717 | 0717 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13279337 | -1.PP_SO-101 | ø160 mm-ø160 mm | G | WPA | JD | -1.PP_SO-101 | 2356.58 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 80 | 160 | 0.00146375 | 36.9724 | 45.6076 | ø160-ø160 | 27.4421 | 163.175 | TT01.02.0720 | 0720 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13280987 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 373.839 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4422 | 45.0001 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0727 | 0727 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281068 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 236.735 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000183492 | 18.6226 | 43.2816 | ø78-ø78 | 12.8826 | 81.175 | TT01.02.0728 | 0728 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281083 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 230.675 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000182533 | 18.5155 | 43.0556 | ø78-ø78 | 12.8085 | 81.175 | TT01.02.0729 | 0729 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281087 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 48.5429 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0730 | 0730 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281517 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3403.5 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0731 | 0731 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281521 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2401.78 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0732 | 0732 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13287012 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1743.35 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497078 | 26.0598 | 44.9848 | ø110-ø110 | 18.7444 | 113.175 | TT01.02.0733 | 0733 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13287322 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1687.21 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0734 | 0734 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13287326 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1455.83 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0735 | 0735 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13287623 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1487.95 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0737 | 0737 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13287627 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1691.04 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000484294 | 25.3185 | 43.8278 | ø110-ø110 | 18.2112 | 113.175 | TT01.02.0738 | 0738 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288069 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 34.7775 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0739 | 0739 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288493 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3272.97 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0740 | 0740 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288497 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3257.1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0082 | 88.8544 | ø78-ø78 | 31.8272 | 81.175 | TT01.02.0741 | 0741 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288532 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 2992.97 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0742 | 0742 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288543 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 2996.57 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0743 | 0743 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288780 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 3222.17 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0744 | 0744 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288964 | 4.NP_SO-101 | ø58 mm-ø58 mm | G | WPA | JD | 4.NP_SO-101 | 236.781 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.000168998 | 36.4185 | 89.1892 | ø58-ø58 | 24.1262 | 61.175 | TT01.02.0745 | 0745 | no | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288990 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 229.671 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0747 | 0747 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13288998 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 114.008 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0748 | 0748 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13289031 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 91.9983 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0749 | 0749 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13289132 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 3.NP_SO-101 | 3002.17 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0750 | 0750 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13289209 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 16.0641 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0751 | 0751 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
