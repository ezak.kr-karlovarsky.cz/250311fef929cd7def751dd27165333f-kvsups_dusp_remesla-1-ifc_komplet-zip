Properties of the parts of a building model (IFC4), part 20 of 26

# IfcPipeSegment: Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná) (64)
Name (Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná):...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Řez | Drsnost (mm) | Materiál | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení
13428504 | 3.NP_SO-101 | 142.104 | 0.00061566 | 0.0125001 | ø28 mm | 0 | 3.NP_SO-101 |  | 3614.04 | 3614.04 | 3471.94 | 3471.94 | 173 | 0.1 | Kov, ocel | 11471.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0895 | 0895
13428823 | 3.NP_SO-101 | 1291.38 | 0.00061566 | 0.113596 | ø28 mm | 0.004 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 185 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0900 | 0900
13428877 | 3.NP_SO-101 | 156.125 | 0.00061566 | 0.0137335 | ø28 mm | 0 | 3.NP_SO-101 |  | 3628.06 | 3628.06 | 3471.94 | 3471.94 | 185 | 0.1 | Kov, ocel | 11471.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0901 | 0901
13434717 | 3.NP_SO-101 | 521.38 | 0.00061566 | 0.045863 | ø28 mm | 0.004 | 3.NP_SO-101 | 0 | 3264 | 3250 | 3250 | 3236 | 187 | 0.1 | Kov, ocel | 11237.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0934 | 0934
13434972 | 3.NP_SO-101 | 156.125 | 0.00061566 | 0.0137335 | ø28 mm | 0 | 3.NP_SO-101 |  | 3428.06 | 3271.94 | 3428.06 | 3271.94 | 187 | 0.1 | Kov, ocel | 11271.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0943 | 0943
13435165 | 3.NP_SO-101 | 156.125 | 0.00061566 | 0.0137335 | ø28 mm | 0 | 3.NP_SO-101 |  | 3428.06 | 3428.06 | 3271.94 | 3271.94 | 187 | 0.1 | Kov, ocel | 11271.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0948 | 0948

# IfcPipeSegment: Typy trubek:PP-RCT (581)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR10; Komentáře k typům: Pipes Plain End, welded sockets; Model: EVO; Název typu: PP-RCT; Označení typu: 02; Popis: PP-RCT; Popis sestavy: Polypropylene Random Cristallinity Temperature (PP RCT); Výrobce: Wavin
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR10 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ přípoje: Obecné
Jiné - Rodina: Typy trubek; Id typu: 9442190; Rodina a typ: Typy trubek: PP-RCT; Typ: PP-RCT
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Reynoldsovo číslo = Třecí faktor = Tření = Doplňkový průtok (m3/s) = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
12915234 | 4.NP_SO-101 | 3209.04 | 0.000804127 | 0.322608 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2882.85 | -326.188 | 2882.85 | -326.187 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11673.8 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3209.04 | ø32 | 24.8 | TR10.02.0015 | 0015 | yes | WS_Studená vnitřní 151 | Identifikační data - Komentáře: V1
12915236 | 4.NP_SO-101 | 3037.06 | 0.0004908 | 0.23853 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2707.7 | -329.362 | 2707.7 | -329.362 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11670.6 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3037.06 | ø25 | 19.4 | TR10.02.0016 | 0016 | yes | WS_Cirkulace vnitřní 2
12915456 | 1.NP_SO-101 | 401.137 | 0.000804127 | 0.0403266 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | -112.497 | -513.634 | -112.497 | -513.634 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -513.634 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 401.137 | ø32 | 24.8 | TR10.02.0017 | 0017 | yes | WS_Cirkulace vnitřní 2
12915507 | 3.NP_SO-101 | 4562.69 | 0.00125645 | 0.573365 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3639.68 | 3639.68 | -923.017 | -923.017 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7076.98 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4562.69 | ø40 | 31 | TR10.02.0018 | 0018 | yes | WS_Studená vnitřní 151 | Identifikační data - Komentáře: V1
12915511 | 3.NP_SO-101 | 4569.04 | 0.000804127 | 0.45933 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3642.85 | 3642.85 | -926.192 | -926.192 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7073.81 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4569.04 | ø32 | 24.8 | TR10.02.0019 | 0019 | yes | WS_"Jiný typ" studená vnitřní 1 | Identifikační data - Komentáře: P1
12915513 | 3.NP_SO-101 | 4392.69 | 0.00125645 | 0.552001 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3639.68 | -753.013 | 3639.68 | -753.013 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7246.99 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4392.69 | ø40 | 31 | TR10.02.0020 | 0020 | yes | WS_Teplá vnitřní 155
13048821 | -1.PP_SO-101 | 5048.81 | 0.0019632 | 0.793066 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2525 | 2500 | 2500 | 2475 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -669.4 | PP–RCT S4 | 50 | 150 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5048.81 | ø50 | 38.8 | TR10.02.0025 | 0025 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13048975 | -1.PP_SO-101 | 5236.19 | 0.000804127 | 0.526399 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -862.4 | PP–RCT S4 | 32 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5236.19 | ø32 | 24.8 | TR10.02.0026 | 0026 | yes | WS_Cirkulace vnitřní 2 | 0
13049179 | -1.PP_SO-101 | 5166.18 | 0.0004908 | 0.405751 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 5 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5166.18 | ø25 | 19.4 | TR10.02.0027 | 0027 | no | WS_Teplá vnitřní 155 | 0
13049191 | -1.PP_SO-101 | 563.581 | 0.0004908 | 0.0442636 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 5 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 563.581 | ø25 | 19.4 | TR10.02.0028 | 0028 | no | WS_Teplá vnitřní 155 | 0
13049201 | -1.PP_SO-101 | 1779.36 | 0.0004908 | 0.139751 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 5 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1779.36 | ø25 | 19.4 | TR10.02.0029 | 0029 | no | WS_Teplá vnitřní 155 | 0
13049307 | -1.PP_SO-101 | 5286.18 | 0.0004908 | 0.415176 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 263 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5286.18 | ø25 | 19.4 | TR10.02.0030 | 0030 | no | WS_Studená vnitřní 151 | 0
13049319 | -1.PP_SO-101 | 554.753 | 0.0004908 | 0.0435702 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 263 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 554.753 | ø25 | 19.4 | TR10.02.0031 | 0031 | no | WS_Studená vnitřní 151 | 0
13049329 | -1.PP_SO-101 | 1948.51 | 0.0004908 | 0.153035 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 263 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1948.51 | ø25 | 19.4 | TR10.02.0032 | 0032 | no | WS_Studená vnitřní 151 | 0
13049878 | -1.PP_SO-101 | 832.378 | 0.0004908 | 0.0653748 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1667.74 | 1655.24 | 1655.24 | 1642.74 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1504.46 | PP–RCT S4 | 25 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 832.378 | ø25 | 19.4 | TR10.02.0033 | 0033 | no | WS_Studená vnitřní 151 | 0
13050046 | -1.PP_SO-101 | 1009.01 | 0.0004908 | 0.0792471 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1667.74 | 1655.24 | 1655.24 | 1642.74 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1504.46 | PP–RCT S4 | 25 | 303 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1009.01 | ø25 | 19.4 | TR10.02.0034 | 0034 | no | WS_Studená vnitřní 151 | 0
13050070 | -1.PP_SO-101 | 625.869 | 0.000314112 | 0.0393245 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1740 | 1730 | 1730 | 1720 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1427.7 | PP–RCT S4 | 20 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 625.869 | ø20 | 15.4 | TR10.02.0035 | 0035 | no | WS_Teplá vnitřní 155 | 0
13050078 | -1.PP_SO-101 | 146.025 | 0.0004908 | 0.0114688 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1742.5 | 1730 | 1730 | 1717.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1429.7 | PP–RCT S4 | 25 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 146.025 | ø25 | 19.4 | TR10.02.0036 | 0036 | no | WS_Teplá vnitřní 155 | 0
13050211 | -1.PP_SO-101 | 465.869 | 0.000314112 | 0.0292714 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1665.24 | 1655.24 | 1655.24 | 1645.24 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1502.46 | PP–RCT S4 | 20 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 465.869 | ø20 | 15.4 | TR10.02.0037 | 0037 | no | WS_Studená vnitřní 151 | 0
13050217 | -1.PP_SO-101 | 1365.87 | 0.000314112 | 0.0858201 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1665.24 | 1655.24 | 1655.24 | 1645.24 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1502.46 | PP–RCT S4 | 20 | 372 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1365.87 | ø20 | 15.4 | TR10.02.0038 | 0038 | no | WS_Studená vnitřní 151 | 0
13050244 | -1.PP_SO-101 | 865.869 | 0.000314112 | 0.0544041 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1740 | 1730 | 1730 | 1720 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1427.7 | PP–RCT S4 | 20 | 161 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 865.869 | ø20 | 15.4 | TR10.02.0039 | 0039 | no | WS_Teplá vnitřní 155 | 0
13050267 | -1.PP_SO-101 | 1282.54 | 0.000314112 | 0.0805842 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1740 | 1730 | 1730 | 1720 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1427.7 | PP–RCT S4 | 20 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1282.54 | ø20 | 15.4 | TR10.02.0040 | 0040 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13050320 | -1.PP_SO-101 | 1475.43 | 0.0004908 | 0.11588 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1667.74 | 1655.24 | 1655.24 | 1642.74 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1504.46 | PP–RCT S4 | 25 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1475.43 | ø25 | 19.4 | TR10.02.0041 | 0041 | no | WS_Studená vnitřní 151 | 0
13050330 | -1.PP_SO-101 | 1099.36 | 0.0004908 | 0.0863435 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1667.74 | 1655.24 | 1655.24 | 1642.74 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1504.46 | PP–RCT S4 | 25 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1099.36 | ø25 | 19.4 | TR10.02.0042 | 0042 | no | WS_Studená vnitřní 151 | 0
13050352 | -1.PP_SO-101 | 753.786 | 0.0004908 | 0.0592022 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 375 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 753.786 | ø25 | 19.4 | TR10.02.0043 | 0043 | yes | WS_Studená vnitřní 151 | 0
13050361 | -1.PP_SO-101 | 6665.47 | 0.0004908 | 0.523505 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 364 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6665.47 | ø25 | 19.4 | TR10.02.0044 | 0044 | no | WS_Studená vnitřní 151 | 0 | Identifikační data - Komentáře: max. odběr plynu 25m3/hod
13050426 | -1.PP_SO-101 | 1165.87 | 0.000314112 | 0.0732537 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.7 | PP–RCT S4 | 20 | 376 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1165.87 | ø20 | 15.4 | TR10.02.0045 | 0045 | no | WS_Studená vnitřní 151 | 0
13050440 | -1.PP_SO-101 | 367.124 | 0.0004908 | 0.0288338 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 367.124 | ø25 | 19.4 | TR10.02.0046 | 0046 | yes | WS_Teplá vnitřní 155 | 0
13050564 | -1.PP_SO-101 | 1292.53 | 0.000314112 | 0.0812121 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1292.53 | ø20 | 15.4 | TR10.02.0047 | 0047 | no | WS_Teplá vnitřní 155 | 0
13050681 | -1.PP_SO-101 | 4509.28 | 0.000804127 | 0.453322 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -862.4 | PP–RCT S4 | 32 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4509.28 | ø32 | 24.8 | TR10.02.0048 | 0048 | no | WS_Teplá vnitřní 155 | 0
13050767 | -1.PP_SO-101 | 4389.28 | 0.000804127 | 0.441259 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.4 | PP–RCT S4 | 32 | 299 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4389.28 | ø32 | 24.8 | TR10.02.0049 | 0049 | no | WS_Studená vnitřní 151 | 0
13050938 | -1.PP_SO-101 | 4205.2 | 0.000804127 | 0.422753 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2516 | 2500 | 2500 | 2484 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -662.4 | PP–RCT S4 | 32 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4205.2 | ø32 | 24.8 | TR10.02.0050 | 0050 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13050947 | -1.PP_SO-101 | 1970.91 | 0.000314112 | 0.123836 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 106 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1970.91 | ø20 | 15.4 | TR10.02.0051 | 0051 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051075 | -1.PP_SO-101 | 2349.66 | 0.000314112 | 0.147634 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1740 | 1730 | 1730 | 1720 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1427.7 | PP–RCT S4 | 20 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2349.66 | ø20 | 15.4 | TR10.02.0052 | 0052 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051144 | -1.PP_SO-101 | 1942.54 | 0.000314112 | 0.122053 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 106 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1942.54 | ø20 | 15.4 | TR10.02.0053 | 0053 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051166 | -1.PP_SO-101 | 1169.04 | 0.0004908 | 0.0918165 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1169.04 | ø25 | 19.4 | TR10.02.0054 | 0054 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051361 | -1.PP_SO-101 | 1065.87 | 0.000314112 | 0.0669705 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 133 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1065.87 | ø20 | 15.4 | TR10.02.0055 | 0055 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051367 | -1.PP_SO-101 | 1965.87 | 0.000314112 | 0.123519 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1965.87 | ø20 | 15.4 | TR10.02.0056 | 0056 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051386 | -1.PP_SO-101 | 2980.42 | 0.0004908 | 0.234081 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 107 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2980.42 | ø25 | 19.4 | TR10.02.0057 | 0057 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051394 | -1.PP_SO-101 | 4178.91 | 0.000804127 | 0.42011 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2516 | 2500 | 2500 | 2484 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -662.4 | PP–RCT S4 | 32 | 135 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4178.91 | ø32 | 24.8 | TR10.02.0058 | 0058 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051455 | -1.PP_SO-101 | 2205.59 | 0.000804127 | 0.22173 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -862.4 | PP–RCT S4 | 32 | 157 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2205.59 | ø32 | 24.8 | TR10.02.0059 | 0059 | yes | WS_Teplá vnitřní 155 | 0
13051459 | -1.PP_SO-101 | 2549.29 | 0.0004908 | 0.200221 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2549.29 | ø25 | 19.4 | TR10.02.0060 | 0060 | no | WS_Teplá vnitřní 155 | 0
13051519 | -1.PP_SO-101 | 217.441 | 0.000314112 | 0.0136622 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 217.441 | ø20 | 15.4 | TR10.02.0061 | 0061 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13051528 | -1.PP_SO-101 | 3926.02 | 0.0004908 | 0.308349 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3926.02 | ø25 | 19.4 | TR10.02.0062 | 0062 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051588 | -1.PP_SO-101 | 925.544 | 0.000314112 | 0.0581536 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2410 | 2400 | 2400 | 2390 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -757.7 | PP–RCT S4 | 20 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 925.544 | ø20 | 15.4 | TR10.02.0063 | 0063 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051594 | -1.PP_SO-101 | 916.576 | 0.0004908 | 0.0719877 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 916.576 | ø25 | 19.4 | TR10.02.0064 | 0064 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051602 | -1.PP_SO-101 | 405.869 | 0.000314112 | 0.0255015 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 149 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 405.869 | ø20 | 15.4 | TR10.02.0065 | 0065 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051635 | -1.PP_SO-101 | 275.318 | 0.000314112 | 0.0172987 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 148 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 275.318 | ø20 | 15.4 | TR10.02.0066 | 0066 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051669 | -1.PP_SO-101 | 2355.4 | 0.000804127 | 0.236791 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2516 | 2500 | 2500 | 2484 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -662.4 | PP–RCT S4 | 32 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2355.4 | ø32 | 24.8 | TR10.02.0067 | 0067 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13051683 | -1.PP_SO-101 | 1649.98 | 0.00125645 | 0.207342 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | -1.PP_SO-101 | 2520 | 2500 | 2500 | 2480 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -665.5 | PP–RCT S4 | 40 | 216 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1649.98 | ø40 | 31 | TR10.02.0068 | 0068 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13051692 | -1.PP_SO-101 | 1522.54 | 0.000314112 | 0.0956639 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 100 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1522.54 | ø20 | 15.4 | TR10.02.0069 | 0069 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051748 | -1.PP_SO-101 | 7412.69 | 0.000804127 | 0.745205 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2516 | 2500 | 2500 | 2484 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -662.4 | PP–RCT S4 | 32 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7412.69 | ø32 | 24.8 | TR10.02.0070 | 0070 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13051756 | -1.PP_SO-101 | 20581.7 | 0.0019632 | 3.23297 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2525 | 2500 | 2500 | 2475 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -669.4 | PP–RCT S4 | 50 | 150 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 20581.7 | ø50 | 38.8 | TR10.02.0071 | 0071 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13051795 | -1.PP_SO-101 | 1156.34 | 0.000314112 | 0.0726552 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1156.34 | ø20 | 15.4 | TR10.02.0072 | 0072 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051848 | -1.PP_SO-101 | 2658.73 | 0.000314112 | 0.167053 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2658.73 | ø20 | 15.4 | TR10.02.0073 | 0073 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051857 | -1.PP_SO-101 | 1625.08 | 0.000314112 | 0.102106 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.08 | ø20 | 15.4 | TR10.02.0074 | 0074 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051869 | -1.PP_SO-101 | 398.002 | 0.000314112 | 0.0250072 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 398.002 | ø20 | 15.4 | TR10.02.0075 | 0075 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051924 | -1.PP_SO-101 | 1333.84 | 0.000314112 | 0.0838074 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 100 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1333.84 | ø20 | 15.4 | TR10.02.0076 | 0076 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13051941 | -1.PP_SO-101 | 3752.38 | 0.0004908 | 0.294711 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.698 | PP–RCT S4 | 25 | 272 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3752.38 | ø25 | 19.4 | TR10.02.0077 | 0077 | no | WS_Studená vnitřní 151 | 0
13052028 | -1.PP_SO-101 | 350.902 | 0.0004908 | 0.0275598 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1667.74 | 1655.24 | 1655.24 | 1642.74 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1504.46 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 350.902 | ø25 | 19.4 | TR10.02.0078 | 0078 | no | WS_Studená vnitřní 151 | 0
13052057 | -1.PP_SO-101 | 21165.4 | 0.0019632 | 3.32465 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -869.4 | PP–RCT S4 | 50 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21165.4 | ø50 | 38.8 | TR10.02.0079 | 0079 | yes | WS_Studená vnitřní 151 | 0
13052070 | -1.PP_SO-101 | 2206.5 | 0.000314112 | 0.138639 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 278 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2206.5 | ø20 | 15.4 | TR10.02.0080 | 0080 | no | WS_Studená vnitřní 151 | 0
13052082 | -1.PP_SO-101 | 990.41 | 0.000314112 | 0.0622293 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.7 | PP–RCT S4 | 20 | 278 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 990.41 | ø20 | 15.4 | TR10.02.0081 | 0081 | no | WS_Studená vnitřní 151 | 0
13052096 | -1.PP_SO-101 | 641.22 | 0.000314112 | 0.0402891 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.7 | PP–RCT S4 | 20 | 278 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 641.22 | ø20 | 15.4 | TR10.02.0082 | 0082 | no | WS_Studená vnitřní 151 | 0
13052106 | -1.PP_SO-101 | 397.416 | 0.000314112 | 0.0249704 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.7 | PP–RCT S4 | 20 | 278 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 397.416 | ø20 | 15.4 | TR10.02.0083 | 0083 | no | WS_Studená vnitřní 151 | 0
13052164 | -1.PP_SO-101 | 733.363 | 0.000314112 | 0.0460786 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2460 | 2450 | 2450 | 2440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -707.7 | PP–RCT S4 | 20 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 733.363 | ø20 | 15.4 | TR10.02.0084 | 0084 | no | WS_Teplá vnitřní 155 | 0
13052172 | -1.PP_SO-101 | 665.075 | 0.000314112 | 0.0417879 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2460 | 2450 | 2450 | 2440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -707.7 | PP–RCT S4 | 20 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 665.075 | ø20 | 15.4 | TR10.02.0085 | 0085 | no | WS_Teplá vnitřní 155 | 0
13052182 | -1.PP_SO-101 | 270.598 | 0.000314112 | 0.0170022 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2460 | 2450 | 2450 | 2440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -707.7 | PP–RCT S4 | 20 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 270.598 | ø20 | 15.4 | TR10.02.0086 | 0086 | no | WS_Teplá vnitřní 155 | 0
13052274 | -1.PP_SO-101 | 6635 | 0.000804127 | 0.667023 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -862.4 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6635 | ø32 | 24.8 | TR10.02.0087 | 0087 | yes | WS_Teplá vnitřní 155 | 0
13052288 | -1.PP_SO-101 | 3451.57 | 0.0004908 | 0.271086 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2462.5 | 2450 | 2450 | 2437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -709.7 | PP–RCT S4 | 25 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3451.57 | ø25 | 19.4 | TR10.02.0088 | 0088 | no | WS_Teplá vnitřní 155 | 0
13052386 | -1.PP_SO-101 | 2537.35 | 0.000804127 | 0.255082 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.399 | PP–RCT S4 | 32 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2537.35 | ø32 | 24.8 | TR10.02.0089 | 0089 | no | WS_Studená vnitřní 151 | 0
13052390 | -1.PP_SO-101 | 1558.72 | 0.0004908 | 0.122422 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 272 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1558.72 | ø25 | 19.4 | TR10.02.0090 | 0090 | no | WS_Studená vnitřní 151 | 0
13052400 | -1.PP_SO-101 | 2298.72 | 0.0004908 | 0.180541 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 272 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2298.72 | ø25 | 19.4 | TR10.02.0091 | 0091 | no | WS_Studená vnitřní 151 | 0
13052408 | -1.PP_SO-101 | 1099.36 | 0.0004908 | 0.0863437 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 272 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1099.36 | ø25 | 19.4 | TR10.02.0092 | 0092 | no | WS_Studená vnitřní 151 | 0
13052447 | -1.PP_SO-101 | 2039.04 | 0.000314112 | 0.128116 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2460 | 2450 | 2450 | 2440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -707.7 | PP–RCT S4 | 20 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2039.04 | ø20 | 15.4 | TR10.02.0093 | 0093 | no | WS_Teplá vnitřní 155 | 0
13052457 | -1.PP_SO-101 | 1498.73 | 0.0004908 | 0.11771 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2462.5 | 2450 | 2450 | 2437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -709.7 | PP–RCT S4 | 25 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1498.73 | ø25 | 19.4 | TR10.02.0094 | 0094 | no | WS_Teplá vnitřní 155 | 0
13052467 | -1.PP_SO-101 | 2318.72 | 0.0004908 | 0.182112 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2462.5 | 2450 | 2450 | 2437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -709.7 | PP–RCT S4 | 25 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2318.72 | ø25 | 19.4 | TR10.02.0095 | 0095 | no | WS_Teplá vnitřní 155 | 0
13052475 | -1.PP_SO-101 | 1194.36 | 0.0004908 | 0.093805 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2462.5 | 2450 | 2450 | 2437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -709.7 | PP–RCT S4 | 25 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1194.36 | ø25 | 19.4 | TR10.02.0096 | 0096 | no | WS_Teplá vnitřní 155 | 0
13053052 | 4.NP_SO-101 | 532.375 | 0.000804127 | 0.0535202 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 532.375 | ø32 | 24.8 | TR10.02.0097 | 0097 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053241 | 4.NP_SO-101 | 3315.04 | 0.000804127 | 0.333265 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3315.04 | ø32 | 24.8 | TR10.02.0098 | 0098 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053255 | 4.NP_SO-101 | 6952.38 | 0.000804127 | 0.698929 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6952.38 | ø32 | 24.8 | TR10.02.0099 | 0099 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053266 | 4.NP_SO-101 | 5164.71 | 0.000804127 | 0.519213 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5164.71 | ø32 | 24.8 | TR10.02.0100 | 0100 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053278 | 4.NP_SO-101 | 200.206 | 0.000804127 | 0.0201269 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 200.206 | ø32 | 24.8 | TR10.02.0101 | 0101 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053338 | 4.NP_SO-101 | 413.273 | 0.0004908 | 0.0324584 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2986.19 | 2973.69 | 2973.69 | 2961.19 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14964 | PP–RCT S4 | 25 | 18 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 413.273 | ø25 | 19.4 | TR10.02.0102 | 0102 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053346 | 4.NP_SO-101 | 373.012 | 0.0004908 | 0.0292963 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2986.19 | 2973.69 | 2973.69 | 2961.19 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14964 | PP–RCT S4 | 25 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 373.012 | ø25 | 19.4 | TR10.02.0103 | 0103 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053421 | 4.NP_SO-101 | 603.006 | 0.000804127 | 0.0606208 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2922.66 | 2906.66 | 2906.66 | 2890.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14894.3 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 603.006 | ø32 | 24.8 | TR10.02.0104 | 0104 | no | WS_Studená vnitřní 151 | 0 | Identifikační data - Komentáře: V1
13053443 | 4.NP_SO-101 | 6958.73 | 0.0004908 | 0.546537 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6958.73 | ø25 | 19.4 | TR10.02.0105 | 0105 | no | WS_Studená vnitřní 151 | 0
13053451 | 4.NP_SO-101 | 2858.73 | 0.0004908 | 0.224524 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2858.73 | ø25 | 19.4 | TR10.02.0106 | 0106 | no | WS_Studená vnitřní 151 | 0
13053474 | 4.NP_SO-101 | 1490.79 | 0.0004908 | 0.117087 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1490.79 | ø25 | 19.4 | TR10.02.0107 | 0107 | no | WS_Studená vnitřní 151 | 0
13053482 | 4.NP_SO-101 | 148.398 | 0.0019632 | 0.0233103 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 4.NP_SO-101 | 2931.66 | 2906.66 | 2906.66 | 2881.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14887.3 | PP–RCT S4 | 50 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 148.398 | ø50 | 38.8 | TR10.02.0108 | 0108 | no | WS_Studená vnitřní 151 | 0
13053533 | 4.NP_SO-101 | 206.819 | 0.000314112 | 0.0129948 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2916.66 | 2906.66 | 2906.66 | 2896.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14899 | PP–RCT S4 | 20 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 206.819 | ø20 | 15.4 | TR10.02.0109 | 0109 | no | WS_Studená vnitřní 151 | 0
13053579 | 4.NP_SO-101 | 3618.1 | 0.0004908 | 0.284165 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3618.1 | ø25 | 19.4 | TR10.02.0110 | 0110 | no | WS_Studená vnitřní 151 | 0
13053599 | 4.NP_SO-101 | 683.006 | 0.000804127 | 0.0686633 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2864.34 | 2848.34 | 2848.34 | 2832.34 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14835.9 | PP–RCT S4 | 32 | 19 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 683.006 | ø32 | 24.8 | TR10.02.0111 | 0111 | no | WS_Teplá vnitřní 155 | 0
13053621 | 4.NP_SO-101 | 6918.73 | 0.0004908 | 0.543395 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6918.73 | ø25 | 19.4 | TR10.02.0112 | 0112 | no | WS_Teplá vnitřní 155 | 0
13053629 | 4.NP_SO-101 | 2858.73 | 0.0004908 | 0.224524 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2858.73 | ø25 | 19.4 | TR10.02.0113 | 0113 | no | WS_Teplá vnitřní 155 | 0
13053639 | 4.NP_SO-101 | 1592.33 | 0.0004908 | 0.125061 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1592.33 | ø25 | 19.4 | TR10.02.0114 | 0114 | no | WS_Teplá vnitřní 155 | 0
13053667 | 4.NP_SO-101 | 765.869 | 0.000314112 | 0.048121 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2983.69 | 2973.69 | 2973.69 | 2963.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14966 | PP–RCT S4 | 20 | 21 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 765.869 | ø20 | 15.4 | TR10.02.0115 | 0115 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053939 | 4.NP_SO-101 | 325.764 | 0.0004908 | 0.0255855 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2986.19 | 2973.69 | 2973.69 | 2961.19 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14964 | PP–RCT S4 | 25 | 213 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 325.764 | ø25 | 19.4 | TR10.02.0116 | 0116 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13053975 | 4.NP_SO-101 | 40.4687 | 0.0004908 | 0.00317841 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2740.84 | 2728.34 | 2728.34 | 2715.84 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 14718.6 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 40.4687 | ø25 | 19.4 | TR10.02.0117 | 0117 | yes | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2 | 0
13054025 | 4.NP_SO-101 | 3024.36 | 0.000804127 | 0.304042 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2698.18 | -326.188 | 2698.18 | -326.188 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11673.8 | PP–RCT S4 | 32 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3024.36 | ø32 | 24.8 | TR10.02.0118 | 0118 | yes | WS_Teplá vnitřní 155
13054039 | 4.NP_SO-101 | 66.025 | 0.000804127 | 0.00663756 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2824.53 | 2758.5 | 2824.53 | 2758.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14758.5 | PP–RCT S4 | 32 | 19 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 66.025 | ø32 | 24.8 | TR10.02.0119 | 0119 | yes | WS_Teplá vnitřní 155
13054082 | 4.NP_SO-101 | 2889.46 | 0.0004908 | 0.226937 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2889.46 | ø25 | 19.4 | TR10.02.0120 | 0120 | no | WS_Teplá vnitřní 155 | 0
13054096 | 4.NP_SO-101 | 1355.08 | 0.000314112 | 0.0851421 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2858.34 | 2848.34 | 2848.34 | 2838.34 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14840.6 | PP–RCT S4 | 20 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1355.08 | ø20 | 15.4 | TR10.02.0121 | 0121 | no | WS_Teplá vnitřní 155 | 0
13054185 | 4.NP_SO-101 | 1442.54 | 0.000314112 | 0.0906373 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2858.34 | 2848.34 | 2848.34 | 2838.34 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14840.6 | PP–RCT S4 | 20 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1442.54 | ø20 | 15.4 | TR10.02.0122 | 0122 | no | WS_Teplá vnitřní 155 | 0
13054214 | 4.NP_SO-101 | 4646.18 | 0.0004908 | 0.36491 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4646.18 | ø25 | 19.4 | TR10.02.0123 | 0123 | no | WS_Teplá vnitřní 155 | 0
13054222 | 4.NP_SO-101 | 3706.18 | 0.0004908 | 0.291083 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3706.18 | ø25 | 19.4 | TR10.02.0124 | 0124 | no | WS_Teplá vnitřní 155 | 0
13054255 | 4.NP_SO-101 | 2898.73 | 0.0004908 | 0.227665 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2898.73 | ø25 | 19.4 | TR10.02.0125 | 0125 | no | WS_Studená vnitřní 151 | 0
13054267 | 4.NP_SO-101 | 1159.92 | 0.000314112 | 0.0728796 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2916.66 | 2906.66 | 2906.66 | 2896.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14899 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1159.92 | ø20 | 15.4 | TR10.02.0126 | 0126 | no | WS_Studená vnitřní 151 | 0
13054279 | 4.NP_SO-101 | 7656.19 | 0.000314112 | 0.481052 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2916.66 | 2906.66 | 2906.66 | 2896.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14899 | PP–RCT S4 | 20 | 71 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7656.19 | ø20 | 15.4 | TR10.02.0127 | 0127 | no | WS_Studená vnitřní 151 | 0
13054345 | 4.NP_SO-101 | 261.978 | 0.0004908 | 0.0205757 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 261.978 | ø25 | 19.4 | TR10.02.0128 | 0128 | no | WS_Studená vnitřní 151 | 0
13054375 | 4.NP_SO-101 | 1531.81 | 0.000314112 | 0.0962462 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2916.66 | 2906.66 | 2906.66 | 2896.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14899 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1531.81 | ø20 | 15.4 | TR10.02.0129 | 0129 | no | WS_Studená vnitřní 151 | 0
13054401 | 4.NP_SO-101 | 7631.05 | 0.000314112 | 0.479473 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2916.66 | 2906.66 | 2906.66 | 2896.66 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14899 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7631.05 | ø20 | 15.4 | TR10.02.0130 | 0130 | no | WS_Teplá vnitřní 155 | 0
13054457 | 4.NP_SO-101 | 31.2954 | 0.000314112 | 0.00196635 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2858.34 | 2848.34 | 2848.34 | 2838.34 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14840.6 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 31.2954 | ø20 | 15.4 | TR10.02.0131 | 0131 | no | WS_Teplá vnitřní 155 | 0
13054458 | 4.NP_SO-101 | 68.0176 | 0.000314112 | 0.00427367 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 4.NP_SO-101 | 2908.62 | 2901.55 | 2853.45 | 2846.38 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14848 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 68.0176 | ø20 | 15.4 | TR10.02.0132 | 0132 | no | WS_Teplá vnitřní 155 | 100
13054462 | 4.NP_SO-101 | 97.8772 | 0.0004908 | 0.00768726 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 97.8772 | ø25 | 19.4 | TR10.02.0133 | 0133 | no | WS_Teplá vnitřní 155 | 0
13054513 | 4.NP_SO-101 | 4656.18 | 0.0004908 | 0.365696 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4656.18 | ø25 | 19.4 | TR10.02.0134 | 0134 | no | WS_Studená vnitřní 151 | 0
13054521 | 4.NP_SO-101 | 3456.18 | 0.0004908 | 0.271448 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3456.18 | ø25 | 19.4 | TR10.02.0135 | 0135 | no | WS_Studená vnitřní 151 | 0
13054802 | 3.NP_SO-101 | 852.908 | 0.000804127 | 0.0857437 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11654.3 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 852.908 | ø32 | 24.8 | TR10.02.0136 | 0136 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13054818 | 3.NP_SO-101 | 936.4 | 0.000804127 | 0.0941372 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11654.3 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 936.4 | ø32 | 24.8 | TR10.02.0137 | 0137 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13054929 | 3.NP_SO-101 | 1383.85 | 0.000804127 | 0.13912 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11437.6 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1383.85 | ø32 | 24.8 | TR10.02.0138 | 0138 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13054940 | 4.NP_SO-101 | 3276.06 | 0.000804127 | 0.329346 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2949.88 | 2949.88 | -326.188 | -326.188 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11673.8 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3276.06 | ø32 | 24.8 | TR10.02.0139 | 0139 | yes | WS_"Jiný typ" studená vnitřní 1
13055302 | 3.NP_SO-101 | 736.025 | 0.00125645 | 0.0924916 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11651.2 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 736.025 | ø40 | 31 | TR10.02.0140 | 0140 | yes | WS_Studená vnitřní 151 | 0
13055314 | 3.NP_SO-101 | 726.025 | 0.00125645 | 0.091235 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11651.2 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 726.025 | ø40 | 31 | TR10.02.0141 | 0141 | yes | WS_Studená vnitřní 151 | 0
13055373 | 3.NP_SO-101 | 1477.76 | 0.000804127 | 0.14856 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1477.76 | ø32 | 24.8 | TR10.02.0142 | 0142 | yes | WS_Studená vnitřní 151 | 0
13055400 | 3.NP_SO-101 | 642.375 | 0.000804127 | 0.0645786 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11654.3 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 642.375 | ø32 | 24.8 | TR10.02.0143 | 0143 | yes | WS_Cirkulace vnitřní 2 | 0
13055412 | 3.NP_SO-101 | 512.375 | 0.000804127 | 0.0515096 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11654.3 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 512.375 | ø32 | 24.8 | TR10.02.0144 | 0144 | yes | WS_Cirkulace vnitřní 2 | 0
13055420 | 3.NP_SO-101 | 890.748 | 0.0004908 | 0.0699592 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 890.748 | ø25 | 19.4 | TR10.02.0145 | 0145 | yes | WS_Cirkulace vnitřní 2 | 0
13055488 | 3.NP_SO-101 | 1603.85 | 0.0004908 | 0.125966 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1603.85 | ø25 | 19.4 | TR10.02.0146 | 0146 | yes | WS_Cirkulace vnitřní 2 | 0
13055535 | 3.NP_SO-101 | 536.025 | 0.00125645 | 0.0673589 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11651.2 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 536.025 | ø40 | 31 | TR10.02.0147 | 0147 | yes | WS_Teplá vnitřní 155 | 0
13055549 | 3.NP_SO-101 | 306.025 | 0.00125645 | 0.0384562 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11651.2 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 306.025 | ø40 | 31 | TR10.02.0148 | 0148 | yes | WS_Teplá vnitřní 155 | 0
13055648 | 3.NP_SO-101 | 1677.94 | 0.000804127 | 0.168685 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1677.94 | ø32 | 24.8 | TR10.02.0149 | 0149 | yes | WS_Teplá vnitřní 155 | 0
13055946 | 3.NP_SO-101 | 5798.3 | 0.000804127 | 0.582909 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5798.3 | ø32 | 24.8 | TR10.02.0150 | 0150 | yes | WS_Teplá vnitřní 155 | 0
13055996 | 3.NP_SO-101 | 891.377 | 0.000804127 | 0.089611 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 891.377 | ø32 | 24.8 | TR10.02.0151 | 0151 | yes | WS_Teplá vnitřní 155 | 0
