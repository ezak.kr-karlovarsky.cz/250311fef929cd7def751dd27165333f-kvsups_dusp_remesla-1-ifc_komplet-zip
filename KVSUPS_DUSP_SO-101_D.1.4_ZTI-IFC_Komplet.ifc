Properties of the parts of a building model (IFC4), part 18 of 26

# IfcPipeFitting: M_Přechod, obecný:Standardní (50)
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 1 | Viditelnost 2 | Viditelnost 3 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13060316 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0185 | 0185 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13060318 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0186 | 0186 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13060832 | 2.NP_SO-101 | ø20 mm-ø16 mm | WPA | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT00.04.0203 | 0203 | no | no | yes | no | 3048 | 22.225 | 9.5875 | 11.1125 | WS_Teplá vnitřní 155
13060834 | 2.NP_SO-101 | ø20 mm-ø16 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT00.04.0204 | 0204 | yes | no | yes | no | 3048 | 22.225 | 9.5875 | 11.1125 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061019 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3350 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0207 | 0207 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061021 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0208 | 0208 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061046 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0210 | 0210 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13063015 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 12.5 | 25 | 25 | 50 | 50 | 25 | 0.0000185945 | 12.5 | 0.00290744 | ø50-ø25 | 11.43 | 21.59 | 28.575 | 53.975 | TT00.04.0258 | 0258 | yes | no | no | yes | 3048 | 53.975 | 26.9875 | 14.2875 | WS_Teplá vnitřní 155
13063063 | 1.NP_SO-101 | ø50 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0261 | 0261 | no | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13063072 | 1.NP_SO-101 | ø50 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0262 | 0262 | no | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13063388 | 1.NP_SO-101 | ø50 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0265 | 0265 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13063400 | 1.NP_SO-101 | ø50 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0266 | 0266 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13063929 | -1.PP_SO-101 | ø50 mm-ø32 mm | WPA | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0269 | 0269 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13064982 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0287 | 0287 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13067401 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0289 | 0289 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13067410 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0290 | 0290 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13067481 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3350 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0291 | 0291 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13067581 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0292 | 0292 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13067583 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0293 | 0293 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13157241 | -1.PP_SO-101 | ø50 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0408 | 0408 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13164662 | -1.PP_SO-101 | ø50 mm-ø32 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0460 | 0460 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13164733 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0463 | 0463 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13164744 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0464 | 0464 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13199617 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0504 | 0504 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13229531 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0558 | 0558 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242385 | -1.PP_SO-101 | ø50 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0626 | 0626 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13262044 | 4.NP_SO-101 | ø25 mm-ø20 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0631 | 0631 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13262883 | -1.PP_SO-101 | ø32 mm-ø28 mm | WPA | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 8.73125 | 14 | 16 | 28 | 32 | 32 | 28 | 0.00000747519 | 14 | 0.0015553 | ø32-ø28 | 12.47 | 13.97 | 31.175 | 34.925 | TT00.04.0650 | 0650 | no | no | no | yes | 3048 | 34.925 | 17.4625 | 15.5875 | WS_Teplá vnitřní 155
13262885 | -1.PP_SO-101 | ø28 mm-ø20 mm | WPA | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.79375 | 14 | 10 | 28 | 20 | 28 | 20 | 0.00000438378 | 14 | 0.00107697 | ø28-ø20 | 12.47 | 8.89 | 31.175 | 22.225 | TT00.04.0651 | 0651 | no | no | yes | no | 3048 | 31.175 | 11.1125 | 15.5875 | WS_Teplá vnitřní 155
13264673 | 3.NP_SO-101 | ø25 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450.54 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 12.5 | 25 | 25 | 25 | 25 | 0.00000456527 | 9.60672 | 0.00111918 | ø25-ø25 | 11.43 | 11.43 | 28.575 | 28.575 | TT00.04.0659 | 0659 | yes | yes | no | no | 3045.11 | 28.575 | 14.2875 | 14.2875 | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13264874 | -1.PP_SO-101 | ø50 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0661 | 0661 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13374602 | 2.NP_SO-101 | ø50 mm-ø40 mm | QMA | 2.NP_SO-101 | 3246.99 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 20 | 25 | 40 | 50 | 50 | 40 | 0.0000241169 | 20 | 0.00346833 | ø50-ø40 | 16.51 | 21.59 | 41.275 | 53.975 | TT00.04.0771 | 0771 | yes | no | no | yes | 3048 | 53.975 | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13384923 | 1.NP_SO-101 | ø32 mm-ø25 mm | QMA | 1.NP_SO-101 | 3275 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.04.0852 | 0852 | yes | no | yes | no | 3048 | 34.925 | 14.2875 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcPipeFitting: M_Přechod, obecný:Standardní (19)
Type - Material: 255-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 8.73125 mm; Jmenovitý poloměr 1: 16 mm; Jmenovitý průměr 1: 32 mm; Maximální velikost: 32 mm; Odskok – šířka: 16; Odskok – výška: 16; Velikost značky 1: 13.97 mm; Vnější průměr tvarovky 1: 34.925 mm
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Viditelnost 2: yes; Viditelnost 3: no; Výškové odsazení: 3048 mm; DN tvarovky 1 (sdílený): 32 mm; Max. vnější průměr tvarovky 12: 34.925 mm; Vnější proloměr tvarovky 1: 17.4625 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 2 (mm) = Minimální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 2 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky 2 (mm)
13063250 | 1.NP_SO-101 | ø32 mm-ø25 mm | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0263 | 0263 | yes | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13063252 | 1.NP_SO-101 | ø32 mm-ø20 mm | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0264 | 0264 | yes | 11.1125 | Mechanické – tok - Tlaková ztráta: 0 Pa
13067689 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0297 | 0297 | no | 14.2875
13067695 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0298 | 0298 | no | 11.1125
13067773 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0301 | 0301 | yes | 11.1125
13158632 | 3.NP_SO-101 | ø32 mm-ø25 mm | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0415 | 0415 | yes | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13158634 | 3.NP_SO-101 | ø32 mm-ø25 mm | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0416 | 0416 | yes | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13158669 | 3.NP_SO-101 | ø32 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0418 | 0418 | yes | 11.1125
13158729 | 3.NP_SO-101 | ø32 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0420 | 0420 | yes | 11.1125
13164706 | 3.NP_SO-101 | ø32 mm-ø25 mm | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0462 | 0462 | yes | 14.2875
13231390 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0561 | 0561 | yes | 14.2875
13231465 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0562 | 0562 | no | 14.2875
13231483 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0563 | 0563 | yes | 14.2875
13262208 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0638 | 0638 | no | 11.1125
13262210 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0639 | 0639 | no | 14.2875
13262225 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 8.89 | 22.225 | TT00.04.0640 | 0640 | no | 11.1125
13262227 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0641 | 0641 | no | 14.2875
13262449 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0644 | 0644 | yes | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13264963 | -1.PP_SO-101 | ø32 mm-ø25 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.00000690657 | 0.00146184 | ø32-ø25 | 11.43 | 28.575 | TT00.04.0663 | 0663 | yes | 14.2875

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:13262370
In: -1.PP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat); Group: WS_Studená vnitřní 151
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm-ø50 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2300 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_Studená vnitřní 151
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 25 mm; Jmenovitý průměr: 50 mm; Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000220005 m3; Od středu ke konci: 39.6875 mm; Úhel: 90 deg; Velikost: ø50-ø50-ø50; Velikost značky: 21.59 mm; Vnější průměr tvarovky: 53.975 mm
Identifikační data - Kód prvku: TT00.03.0642; Označení: 0642
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Štítek, od středu ke konci: 39.6875 mm; Úhel 1: 90 deg; Úhel tvarovky 1 (sdílený): 90 deg; Vnější poloměr tvarovky: 26.9875 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní (4)
Type - Material: 032-175-175
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat); Group: WS_Požární zavodněný 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø35 mm-ø35 mm-ø35 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární zavodněný; Klasifikace systému: Požární ochrana – vodní prostředky; Název systému: WS_Požární zavodněný 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg; Jmenovitý poloměr: 17.5 mm; Jmenovitý průměr: 35 mm; Maximální velikost: 35 mm; Minimální velikost: 35 mm; Objem: 0.0000906028 m3; Od středu ke konci: 31.7875 mm; Velikost: ø35-ø35-ø35; Velikost značky: 15.27 mm; Vnější průměr tvarovky: 38.175 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg; Štítek, od středu ke konci: 31.7875 mm; Vnější poloměr tvarovky: 19.0875 mm
Name (M_Spoj T, obecný:Standardní:...) | In | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13158788 | -1.PP_SO-101 | WPA | -1.PP_SO-101 | 2500 | TT00.03.0422 | 0422
13163729 | 3.NP_SO-101 | WPA | 3.NP_SO-101 | 3450 | TT00.03.0444 | 0444
13373959 | 2.NP_SO-101 | QMA | 2.NP_SO-101 | 3400 | TT00.03.0766 | 0766
13383141 | 1.NP_SO-101 | WPA | 1.NP_SO-101 | 3425 | TT00.03.0835 | 0835

# IfcPipeFitting: M_Spoj T, obecný:Standardní (46)
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel 1 (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Štítek, od středu ke konci (mm) | Vnější poloměr tvarovky (mm)
13101688 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1701.66 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0307 | 0307 | yes | 136.646 | 56.5875
13101742 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1782.21 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0309 | 0309 | yes | 136.646 | 56.5875
13120229 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1823.09 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0316 | 0316 | yes | 136.646 | 56.5875
13125818 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1611.86 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0329 | 0329 | yes | 136.646 | 56.5875
13125960 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1656.09 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0331 | 0331 | yes | 136.646 | 56.5875
13125991 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1585.49 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0332 | 0332 | yes | 136.646 | 56.5875
13126189 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1741.88 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0335 | 0335 | yes | 136.646 | 56.5875
13126323 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1652.64 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0338 | 0338 | yes | 136.646 | 56.5875
13129795 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2329.62 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626241 | 81.7875 | 44.9922 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0359 | 0359 | yes | 166.824 | 69.0875
13133961 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2315.58 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626269 | 81.7875 | 44.9905 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0371 | 0371 | yes | 166.831 | 69.0875
13134103 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2368.03 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626269 | 81.7875 | 44.9905 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0374 | 0374 | yes | 166.831 | 69.0875
13134680 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2492.28 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626269 | 81.7875 | 44.9905 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0378 | 0378 | yes | 166.831 | 69.0875
13134852 | -1.PP_SO-101 | ø78 mm-ø78 mm-ø78 mm | -1.PP_SO-101 | 2516.79 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00126982 | 53.2875 | 44.9905 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0381 | 0381 | yes | 98.0099 | 40.5875
13135062 | -1.PP_SO-101 | ø78 mm-ø78 mm-ø78 mm | -1.PP_SO-101 | 2532.67 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00130845 | 53.2875 | 43.8542 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0384 | 0384 | yes | 100.827 | 40.5875
13135691 | -1.PP_SO-101 | ø78 mm-ø78 mm-ø78 mm | -1.PP_SO-101 | 2550.08 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00130845 | 53.2875 | 43.8542 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0390 | 0390 | yes | 100.827 | 40.5875
13136325 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1671.57 | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0397 | 0397 | yes | 136.646 | 56.5875
13190176 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1571.08 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.0035452 | 69.2875 | 43.8542 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0470 | 0470 | yes | 140.574 | 56.5875
13203681 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -875.808 | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0520 | 0520 | yes | 136.614 | 56.5875
13205377 | 2.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-101 | 3245.71 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00130843 | 53.2875 | 43.8547 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0523 | 0523 | no | 100.826 | 40.5875
13216225 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2407.16 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626175 | 81.7875 | 44.9962 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0530 | 0530 | yes | 166.807 | 69.0875
13216862 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2646.35 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0532 | 0532 | yes | 171.626 | 69.0875
13221859 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1791.72 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344113 | 69.2875 | 44.9848 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0545 | 0545 | yes | 136.666 | 56.5875
13228158 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1594.92 | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00344109 | 69.2875 | 44.9852 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0549 | 0549 | yes | 136.664 | 56.5875
13234765 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1608.35 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0578 | 0578 | yes | 136.646 | 56.5875
13235178 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1587.57 | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0583 | 0583 | yes | 136.646 | 56.5875
13235468 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1732.19 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0587 | 0587 | yes | 136.646 | 56.5875
13235833 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1664.21 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0592 | 0592 | yes | 136.646 | 56.5875
13236029 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1749.54 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00344059 | 69.2875 | 44.9908 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0597 | 0597 | yes | 136.645 | 56.5875
13239388 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 3363.76 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00130845 | 53.2875 | 43.8542 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0604 | 0604 | no | 100.827 | 40.5875
13239414 | 1.NP_SO-101 | ø58 mm-ø58 mm-ø58 mm | 1.NP_SO-101 | 3395.02 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.000560001 | 43.2875 | 43.8542 | ø58-ø58-ø58 | 24.47 | 61.175 | TT00.03.0606 | 0606 | no | 75.9849 | 30.5875
13239669 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 3357.73 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00126982 | 53.2875 | 44.9905 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0611 | 0611 | no | 98.0099 | 40.5875
13240022 | 1.NP_SO-101 | ø58 mm-ø58 mm-ø58 mm | 1.NP_SO-101 | 3435.63 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.000560001 | 43.2875 | 43.8542 | ø58-ø58-ø58 | 24.47 | 61.175 | TT00.03.0617 | 0617 | no | 75.9849 | 30.5875
13240321 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 3404.65 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00130845 | 53.2875 | 43.8542 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0619 | 0619 | no | 100.827 | 40.5875
13240725 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 3117.81 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00133851 | 53.2875 | 43 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0624 | 0624 | yes | 103.037 | 40.5875
13272538 | -1.PP_SO-101 | ø78 mm-ø78 mm-ø78 mm | -1.PP_SO-101 | 2368.11 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00111901 | 53.2875 | 49.9893 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0669 | 0669 | yes | 87.0614 | 40.5875
13273394 | 2.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-101 | 446.872 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0670 | 0670 | no | 97.9869 | 40.5875
13274003 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 2791.88 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0677 | 0677 | no | 97.9869 | 40.5875
13275723 | 2.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-101 | 2991.9 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0687 | 0687 | yes | 97.9869 | 40.5875
13275977 | 1.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-101 | 3319.38 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00126982 | 53.2875 | 44.9905 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0694 | 0694 | no | 98.0099 | 40.5875
13278505 | -1.PP_SO-101 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-101 | 2235.51 | SW_Splašky vnitřní gravitační 10 | 100 | 200 | 0.0208605 | 115.888 | 44.9905 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.0705 | 0705 | yes | 249.175 | 103.188
13279252 | -1.PP_SO-101 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-101 | 2393.79 | SW_Splašky vnitřní gravitační 10 | 80 | 160 | 0.00446649 | 94.2875 | 88.8542 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0714 | 0714 | yes | 94.2875 | 81.5875
13279329 | -1.PP_SO-101 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-101 | 2256.47 | SW_Splašky vnitřní gravitační 10 | 80 | 160 | 0.0101498 | 94.2875 | 45.6076 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0719 | 0719 | yes | 194.053 | 81.5875
13287598 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1724.04 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.00344009 | 69.2875 | 44.9963 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0736 | 0736 | yes | 136.627 | 56.5875
13289231 | 3.NP_SO-101 | ø78 mm-ø78 mm-ø78 mm | 3.NP_SO-101 | 3761.78 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.0752 | 0752 | no | 97.9869 | 40.5875
13291382 | -1.PP_SO-101 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-101 | -1715.82 | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.0035424 | 69.2875 | 43.884 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0759 | 0759 | yes | 140.468 | 56.5875
13430578 | -1.PP_SO-101 | ø135 mm-ø135 mm-ø135 mm | -1.PP_SO-101 | 2449.31 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00626357 | 81.7875 | 44.9852 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0907 | 0907 | yes | 166.853 | 69.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (60)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm) | Group
13051233 | -1.PP_SO-101 | ø20 mm-ø20 mm-ø20 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0014 | 0014 | no | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13051755 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0024 | 0024 | yes | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13051829 | -1.PP_SO-101 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0025 | 0025 | yes | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13051923 | -1.PP_SO-101 | ø20 mm-ø20 mm-ø20 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0028 | 0028 | no | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13052056 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0029 | 0029 | yes | 26.9875 | WS_Studená vnitřní 151
13053578 | 4.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0051 | 0051 | no | 26.9875 | WS_Studená vnitřní 151
13054221 | 4.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0061 | 0061 | no | 26.9875 | WS_Teplá vnitřní 155
13054344 | 4.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0064 | 0064 | no | 11.1125 | WS_Studená vnitřní 151
13054520 | 4.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0069 | 0069 | no | 26.9875 | WS_Studená vnitřní 151
13056481 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0093 | 0093 | yes | 11.1125 | WS_Teplá vnitřní 155
13056603 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0099 | 0099 | yes | 11.1125 | WS_Studená vnitřní 151
13056654 | 3.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0100 | 0100 | yes | 26.9875 | WS_Studená vnitřní 151
13056725 | 3.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0101 | 0101 | yes | 26.9875 | WS_Teplá vnitřní 155
13056861 | 3.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0102 | 0102 | yes | 26.9875 | WS_Teplá vnitřní 155
13056945 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0105 | 0105 | no | 11.1125 | WS_Teplá vnitřní 155
13057123 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0107 | 0107 | no | 11.1125 | WS_Teplá vnitřní 155
13057173 | 3.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0108 | 0108 | yes | 26.9875 | WS_Studená vnitřní 151
13057309 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0111 | 0111 | no | 11.1125 | WS_Studená vnitřní 151
13057866 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0119 | 0119 | no | 11.1125 | WS_Studená vnitřní 151
13057933 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0120 | 0120 | no | 11.1125 | WS_Teplá vnitřní 155
13058048 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0126 | 0126 | no | 11.1125 | WS_Studená vnitřní 151
13058129 | 3.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0134 | 0134 | no | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13059055 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3348.92 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0143 | 0143 | no | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13059250 | 2.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0146 | 0146 | yes | 26.9875 | WS_Studená vnitřní 151
13059421 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0150 | 0150 | yes | 11.1125 | WS_Studená vnitřní 151
13059627 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0155 | 0155 | yes | 11.1125 | WS_Studená vnitřní 151
13059702 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0158 | 0158 | yes | 11.1125 | WS_Teplá vnitřní 155
13059980 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0168 | 0168 | yes | 11.1125 | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2
13060070 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0172 | 0172 | yes | 11.1125 | WS_Studená vnitřní 151
13060140 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0176 | 0176 | yes | 11.1125 | WS_Teplá vnitřní 155
13060189 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0177 | 0177 | yes | 11.1125 | WS_Teplá vnitřní 155
13060254 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0178 | 0178 | yes | 11.1125 | WS_Studená vnitřní 151
13060339 | 2.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0187 | 0187 | yes | 26.9875 | WS_Teplá vnitřní 155
13060377 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0189 | 0189 | yes | 11.1125 | WS_Teplá vnitřní 155
13060499 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0194 | 0194 | yes | 11.1125 | WS_Studená vnitřní 151
13060691 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0199 | 0199 | no | 11.1125 | WS_Teplá vnitřní 155
13060765 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0200 | 0200 | yes | 11.1125 | WS_Cirkulace vnitřní 2
13060824 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0202 | 0202 | yes | 11.1125 | WS_Teplá vnitřní 155
13061543 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0216 | 0216 | no | 26.9875 | WS_Teplá vnitřní 155
13061930 | 1.NP_SO-101 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0226 | 0226 | yes | 20.6375 | WS_Studená vnitřní 151
13062022 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0229 | 0229 | no | 26.9875 | WS_Studená vnitřní 151
13062210 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0236 | 0236 | no | 26.9875 | WS_Studená vnitřní 151
13062679 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0246 | 0246 | yes | 26.9875 | WS_Studená vnitřní 151
13062798 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0249 | 0249 | yes | 26.9875 | WS_Studená vnitřní 151
13062895 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0252 | 0252 | yes | 26.9875 | WS_Teplá vnitřní 155
13063599 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0267 | 0267 | yes | 26.9875 | WS_Teplá vnitřní 155
13063873 | -1.PP_SO-101 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0268 | 0268 | yes | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13064138 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0274 | 0274 | no | 26.9875 | WS_Studená vnitřní 151
13064247 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0278 | 0278 | no | 26.9875 | WS_Teplá vnitřní 155
13148638 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0400 | 0400 | yes | 26.9875 | WS_Studená vnitřní 151
13148675 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0403 | 0403 | yes | 26.9875 | WS_Teplá vnitřní 155
13191728 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0484 | 0484 | no | 11.1125 | WS_Studená vnitřní 151
13191753 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0485 | 0485 | no | 11.1125 | WS_Teplá vnitřní 155
13192171 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0490 | 0490 | no | 11.1125 | WS_Teplá vnitřní 155
13192210 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0491 | 0491 | no | 11.1125 | WS_Studená vnitřní 151
13192628 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0492 | 0492 | no | 11.1125 | WS_Teplá vnitřní 155
13192649 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 50 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0493 | 0493 | no | 11.1125 | WS_Studená vnitřní 151
13264345 | 2.NP_SO-101 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0655 | 0655 | yes | 11.1125 | WS_Studená vnitřní 151
13383351 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0837 | 0837 | yes | 26.9875 | WS_Teplá vnitřní 155
13384288 | 1.NP_SO-101 | ø50 mm-ø50 mm-ø50 mm | 1.NP_SO-101 | 3200 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0845 | 0845 | yes | 26.9875 | WS_Studená vnitřní 151

# IfcPipeFitting: M_Spoj T, obecný:Standardní (49)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13050077 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0006 | 0006 | no | 14.2875
13050216 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0007 | 0007 | no | 14.2875
13050307 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0009 | 0009 | no | 14.2875
13050620 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0012 | 0012 | yes | 17.4625
13051366 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0015 | 0015 | no | 14.2875
13051389 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0016 | 0016 | no | 17.4625
13051393 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0017 | 0017 | no | 17.4625
13051454 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0018 | 0018 | yes | 17.4625
13051458 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0019 | 0019 | no | 17.4625
13051593 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0020 | 0020 | no | 14.2875
13051634 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0021 | 0021 | no | 14.2875
13051674 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0022 | 0022 | yes | 17.4625
13052385 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0036 | 0036 | no | 14.2875
13052446 | -1.PP_SO-101 | ø28 mm-ø28 mm-ø28 mm | WPA | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.0040 | 0040 | no | 15.5875
13053345 | 4.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0046 | 0046 | no | 14.2875
13054038 | 4.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 4.NP_SO-101 | 2728.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0056 | 0056 | yes | 17.4625
13054461 | 4.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0066 | 0066 | no | 14.2875
13056001 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0084 | 0084 | yes | 17.4625
13056100 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0086 | 0086 | yes | 17.4625
13056226 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0087 | 0087 | yes | 17.4625
