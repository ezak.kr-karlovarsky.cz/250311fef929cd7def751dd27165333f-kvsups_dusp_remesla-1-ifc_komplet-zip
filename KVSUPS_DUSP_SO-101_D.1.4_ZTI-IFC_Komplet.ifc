Properties of the parts of a building model (IFC4), part 26 of 26

# IfcValve: Nezámrzný ventil:G 1/2" (2)
Name (Nezámrzný ventil:G 1/2":...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Název systému | Kód prvku | Označení
13173353 | 1.NP_SO-101 | 1.NP_SO-101 | 1000 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | VE24.18.0145 | 0145
13198765 | -1.PP_SO-101 | -1.PP_SO-101 | 800 | WS_Studená vnitřní | WS_Studená vnitřní 28 | VE24.18.0176 | 0176 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcValve: Otvor čištění, 90 stupňů:Standardní (2)
In: -1.PP_SO-101
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm
Type - Identifikační data - Kód sestavy: CT00; Komentáře k typům: ČISTÍCÍ TVAROVKA V REVIZNÍ ŠACHTĚ; Název typu: Standardní; Označení typu: 26; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Otvor čištění, 90 stupňů
Classification: CT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø110 mm-ø110 mm
Text - CCI Funkční systém: G; CCI Komponenta: XTA; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární; Tlaková ztráta: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 130 mm; Jmenovitý poloměr: 55 mm; Jmenovitý průměr: 110 mm; Maximální velikost: 110 mm; Minimální velikost: 110 mm; Objem: 0.00465257 m3; Poloměr trubky 1: 59 mm; Poloměr trubky 2: 65 mm; Poloměr uzavření: 26 mm; Šířka: 330 mm; Šroub, poloměr: 7.8 mm; Velikost: ø110-ø110; Výška: 0 mm; Výška šroubu: 8 mm; Výška uzavření: 15 mm; Výška X: 153 mm; W1: 66 mm; W1R: 10 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 13261774; Rodina: Otvor čištění, 90 stupňů; Rodina a typ: Otvor čištění, 90 stupňů: Standardní
Name (Otvor čištění, 90 stupňů:Standardní:...) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13261781 | -1503.06 | SW_Splašky vnitřní gravitační 81 | CT00.26.0196 | 0196
13261788 | -1625.57 | SW_Splašky vnitřní gravitační 4 | CT00.26.0197 | 0197 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcValve: Prodloužení nástavce_03910.2E:03910.2E_Main Component (4)
Type - Material: Plactic - Gray, Stainless Steel
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: d 146 mm; EAN: 9003076025626; HMOTNOST: 0,25 [kg]; Indexovaná poznámka: HL03910.2E; Kód sestavy: VP02; Komentáře k typům: HL03910.2E Nástavec d 146mm, nerezový rámeček 145x145mm včetně O-kroužku. Systém Klick-Klack.; MATERIÁL: PP-V4A; Model: HL03910.2E; Nadpis OmniClass: Deck Waste Water Drains; NÁSTAVEC: 145 x 145 mm; Název typu: 03910.2E_Main Component; Označení typu: 19; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; STAVEBNÍ VÝŠKA: 8 - 80 mm; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL03910.2E.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Prodloužení nástavce_03910.2E; NL_Max: 80 mm; NL_Min: 8 mm; RD: 6.5 mm
Classification: VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8000 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000266268 m3; Stavební výška: 80 mm
Jiné - Id typu: 13173898; NL: 100 mm; NL_Test: yes; R: yes; RL: 84.5 mm; RN: 13; Rodina: Prodloužení nástavce_03910.2E; Rodina a typ: Prodloužení nástavce_03910.2E: 03910.2E_Main Component; Typ: 03910.2E_Main Component
Name (Prodloužení nástavce_03910.2E:03910.2E_Main Component:...) | In | Podlaží | Kód prvku | Označení
13173764 | 1.NP_SO-101 | 1.NP_SO-101 | VP02.19.0146 | 0146
13189699 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.19.0150 | 0150
13189734 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.19.0154 | 0154
13203794 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.19.0177 | 0177

# IfcValve: Přečerpávačka_světlé rozměry:Přečerpávačka_světlé rozměry, Přečerpávačka_světlé rozměry:Přečerpávačka_světlé rozměry:13243373
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Identifikační data - Kód sestavy: CO00; Komentáře k typům: ŠACHTA ČERPACÍ STANICE; Název typu: Přečerpávačka_světlé rozměry; Označení typu: 24; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Přečerpávačka_světlé rozměry
Classification: CO00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 4.68225 m3; Plocha: 2.25 m2
Identifikační data - Kód prvku: CO00.24.0194; Označení: 0194
Jiné - Id typu: 13243371; Rodina: Přečerpávačka_světlé rozměry; Rodina a typ: Přečerpávačka_světlé rozměry: Přečerpávačka_světlé rozměry; Typ: Přečerpávačka_světlé rozměry

# IfcValve: Regulační ventil_závitový:DN 25, Regulační ventil_závitový:DN 25:13066294
In: -1.PP_SO-101
Type - Material: 255-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 75 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE06; Komentáře k typům: Regulační ventil, závitový, DN 25; Model: Model; Nadpis OmniClass: Pipework Fittings; Název typu: DN 25; Označení typu: 10; Popis: Ventil; Popis sestavy: Regulační; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Délka ventilu: 50 mm; H1: 100 mm; H2: 130.357 mm; L1: 55 mm; Lookup Table Name: Závitový_Regulační ventil; Název rodiny: Regulační ventil_závitový; OK: 2.925 mm; R: 12.5 mm; R víčka 1: 18.75 mm; R víčka 2: 15.5 mm; t: 10 mm; -t: -10 mm; Ventil: 93.9214 mm; Výška víčka: 30 mm
Classification: VE06 Uniformat (Uniformat); Group: WS_Cirkulace vnitřní 2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Text - CCI Funkční systém: F; CCI Komponenta: RNA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Cirkulace vnitřní; Klasifikace systému: Teplá voda v domácnosti; Název systému: WS_Cirkulace vnitřní 2; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.000107306 m3; Průměr připojení: 32 mm; Velikost: ø32-ø32
Identifikační data - Kód prvku: VE06.10.0111; Označení: 0111
Jiné - Páteřní trasa: yes; Id typu: 13045613; Rodina: Regulační ventil_závitový; Rodina a typ: Regulační ventil_závitový: DN 25; Typ: DN 25

# IfcValve: Revizní šachta_světlé rozměry2:Revizní šachta_světlé rozměry2, Revizní šachta_světlé rozměry2:Revizní šachta_světlé rozměry2:13243934
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry2; Označení typu: 25; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry2
Classification: AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.0806 m3; Plocha: 0.6 m2
Identifikační data - Kód prvku: AT01.25.0195; Označení: 0195
Jiné - Id typu: 13243932; Rodina: Revizní šachta_světlé rozměry2; Rodina a typ: Revizní šachta_světlé rozměry2: Revizní šachta_světlé rozměry2; Typ: Revizní šachta_světlé rozměry2

# IfcValve: Revizní šachta_světlé rozměry:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry:Revizní šachta_světlé rozměry:13240836
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 23; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry
Classification: AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.70704 m3; Plocha: 0.72 m2
Identifikační data - Kód prvku: AT01.23.0193; Označení: 0193
Jiné - Id typu: 13240834; Rodina: Revizní šachta_světlé rozměry; Rodina a typ: Revizní šachta_světlé rozměry: Revizní šachta_světlé rozměry; Typ: Revizní šachta_světlé rozměry

# IfcValve: Rohový ventil:G 1/2" × 3/4" (3)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE13; Název typu: G 1/2" × 3/4"; Označení typu: 17; Popis: Rohový ventil; Popis sestavy: Rohový; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Rohový ventil
Classification: VE13 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JD
Vazby - Výška od podlaží: 500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000388424 m3; Velikost: ø15-ø15
Jiné - Rodina: Rohový ventil; Id typu: 12857476; Rodina a typ: Rohový ventil: G 1/2" × 3/4"; Typ: G 1/2" × 3/4"
Name (Rohový ventil:G 1/2" × 3/4":...) | In | Podlaží | Kód prvku | Název sestavy | Označení
13147143 | 2.NP_SO-101 | 3.NP_SO-101 | VE13.17.0144 | Myčka 1 | 0144
13286944 | -1.PP_SO-101 | -1.PP_SO-101 | VE13.17.0213 | Výlevka nástěnnð | 0213
13286957 | -1.PP_SO-101 | -1.PP_SO-101 | VE13.17.0214 | Výlevka nástěnnð | 0214

# IfcValve: Rohový ventil:G 1/2" × 3/8" (114)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE13; Název typu: G 1/2" × 3/8"; Označení typu: 01; Popis: Rohový ventil; Popis sestavy: Rohový; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Rohový ventil
Classification: VE13 Uniformat (Uniformat)
Izolace - Celková velikost: ø15 mm-ø15 mm; Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000388424 m3; Velikost: ø15-ø15
Jiné - Id typu: 12812713; Rodina: Rohový ventil; Rodina a typ: Rohový ventil: G 1/2" × 3/8"; Typ: G 1/2" × 3/8"
Name (Rohový ventil:G 1/2" × 3/8":...) | In | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | Typ systému | Kód prvku | Název sestavy | Označení
12872616 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 14 | WS_Teplá vnitřní | VE13.01.0001 | Umyvadlo | 0001
12872617 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 10 | WS_Studená vnitřní | VE13.01.0002 | Umyvadlo | 0002
12872642 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 15 | WS_Teplá vnitřní | VE13.01.0004 | Umyvadlo | 0004
12872643 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 11 | WS_Studená vnitřní | VE13.01.0005 | Umyvadlo | 0005
12872819 | -1.PP_SO-101 | -1.PP_SO-101 | -170 | Teplá voda v domácnosti | WS_Teplá vnitřní 22 | WS_Teplá vnitřní | VE13.01.0007 | Umyvadlo | 0007
12872820 | -1.PP_SO-101 | -1.PP_SO-101 | -170 | Studená voda v domácnosti | WS_Studená vnitřní 18 | WS_Studená vnitřní | VE13.01.0008 | Umyvadlo | 0008
12872852 | -1.PP_SO-101 | -1.PP_SO-101 | -170 | Teplá voda v domácnosti | WS_Teplá vnitřní 11 | WS_Teplá vnitřní | VE13.01.0010 | Umyvadlo | 0010
12872853 | -1.PP_SO-101 | -1.PP_SO-101 | -170 | Studená voda v domácnosti | WS_Studená vnitřní 4 | WS_Studená vnitřní | VE13.01.0011 | Umyvadlo | 0011
12873232 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 24 | WS_Teplá vnitřní | VE13.01.0013 | Umyvadlo | 0013
12873233 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 20 | WS_Studená vnitřní | VE13.01.0014 | Umyvadlo | 0014
12873266 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 13 | WS_Teplá vnitřní | VE13.01.0016 | Umyvadlo | 0016
12873267 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 9 | WS_Studená vnitřní | VE13.01.0017 | Umyvadlo | 0017
12905764 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 141 | WS_Teplá vnitřní | VE13.01.0022 | Umyvadlo | 0022
12905765 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 137 | WS_Studená vnitřní | VE13.01.0023 | Umyvadlo | 0023
12906436 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 146 | WS_Teplá vnitřní | VE13.01.0025 | Umyvadlo + modul | 0025
12906437 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 142 | WS_Studená vnitřní | VE13.01.0026 | Umyvadlo + modul | 0026
12906982 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | WS_Teplá vnitřní | VE13.01.0028 | Umyvadlo | 0028
12906983 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 151 | WS_Studená vnitřní | VE13.01.0029 | Umyvadlo | 0029
12907041 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 156 | WS_Teplá vnitřní | VE13.01.0031 | Umyvadlo + modul | 0031
12907042 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 152 | WS_Studená vnitřní | VE13.01.0032 | Umyvadlo + modul | 0032
12907108 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 157 | WS_Teplá vnitřní | VE13.01.0034 | Umyvadlo + modul | 0034
12907109 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 153 | WS_Studená vnitřní | VE13.01.0035 | Umyvadlo + modul | 0035
12907132 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 158 | WS_Teplá vnitřní | VE13.01.0037 | Umyvadlo + modul | 0037
12907133 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 154 | WS_Studená vnitřní | VE13.01.0038 | Umyvadlo + modul | 0038
12907372 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 160 | WS_Teplá vnitřní | VE13.01.0040 | Umyvadlo | 0040
12907373 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 156 | WS_Studená vnitřní | VE13.01.0041 | Umyvadlo | 0041
12907444 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 161 | WS_Teplá vnitřní | VE13.01.0043 | Umyvadlo | 0043
12907445 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 157 | WS_Studená vnitřní | VE13.01.0044 | Umyvadlo | 0044
12907467 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 162 | WS_Teplá vnitřní | VE13.01.0046 | Umyvadlo | 0046
12907468 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 158 | WS_Studená vnitřní | VE13.01.0047 | Umyvadlo | 0047
12907552 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 163 | WS_Teplá vnitřní | VE13.01.0049 | Umyvadlo + modul | 0049
12907553 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 159 | WS_Studená vnitřní | VE13.01.0050 | Umyvadlo + modul | 0050
12907576 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 164 | WS_Teplá vnitřní | VE13.01.0052 | Umyvadlo + modul | 0052
12907577 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 160 | WS_Studená vnitřní | VE13.01.0053 | Umyvadlo + modul | 0053
12907714 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 165 | WS_Teplá vnitřní | VE13.01.0055 | Umyvadlo | 0055
12907715 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 161 | WS_Studená vnitřní | VE13.01.0056 | Umyvadlo | 0056
12907976 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 167 | WS_Teplá vnitřní | VE13.01.0059 | Umyvadlo | 0059
12907977 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 163 | WS_Studená vnitřní | VE13.01.0060 | Umyvadlo | 0060
12908035 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 168 | WS_Teplá vnitřní | VE13.01.0062 | Umyvadlo + modul | 0062
12908036 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 164 | WS_Studená vnitřní | VE13.01.0063 | Umyvadlo + modul | 0063
12908059 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 169 | WS_Teplá vnitřní | VE13.01.0065 | Umyvadlo + modul | 0065
12908060 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 165 | WS_Studená vnitřní | VE13.01.0066 | Umyvadlo + modul | 0066
12908142 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 170 | WS_Teplá vnitřní | VE13.01.0068 | Umyvadlo + modul | 0068
12908143 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 166 | WS_Studená vnitřní | VE13.01.0069 | Umyvadlo + modul | 0069
12908166 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 171 | WS_Teplá vnitřní | VE13.01.0071 | Umyvadlo + modul | 0071
12908167 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 167 | WS_Studená vnitřní | VE13.01.0072 | Umyvadlo + modul | 0072
12908261 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 172 | WS_Teplá vnitřní | VE13.01.0074 | Umyvadlo + modul | 0074
12908262 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 168 | WS_Studená vnitřní | VE13.01.0075 | Umyvadlo + modul | 0075
12908331 | -1.PP_SO-101 | 4.NP_SO-101 | 1280 | Teplá voda v domácnosti | WS_Teplá vnitřní 173 | WS_Teplá vnitřní | VE13.01.0077 | Umyvadlo + modul | 0077
12908332 | -1.PP_SO-101 | 4.NP_SO-101 | 1280 | Studená voda v domácnosti | WS_Studená vnitřní 169 | WS_Studená vnitřní | VE13.01.0078 | Umyvadlo + modul | 0078
12908453 | -1.PP_SO-101 | 4.NP_SO-101 | 1280 | Teplá voda v domácnosti | WS_Teplá vnitřní 174 | WS_Teplá vnitřní | VE13.01.0080 | Umyvadlo + modul | 0080
12908454 | -1.PP_SO-101 | 4.NP_SO-101 | 1280 | Studená voda v domácnosti | WS_Studená vnitřní 170 | WS_Studená vnitřní | VE13.01.0081 | Umyvadlo + modul | 0081
12908587 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 176 | WS_Teplá vnitřní | VE13.01.0083 | Umyvadlo + modul | 0083
12908588 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 172 | WS_Studená vnitřní | VE13.01.0084 | Umyvadlo + modul | 0084
12908778 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 175 | WS_Teplá vnitřní | VE13.01.0087 | Umyvadlo | 0087
12908779 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 171 | WS_Studená vnitřní | VE13.01.0088 | Umyvadlo | 0088
12944897 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 90 | WS_Teplá vnitřní | VE13.01.0091 | Umyvadlo + modul | 0091
12944898 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 89 | WS_Studená vnitřní | VE13.01.0092 | Umyvadlo + modul | 0092
12944921 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 92 | WS_Teplá vnitřní | VE13.01.0094 | Umyvadlo + modul | 0094
12944922 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 91 | WS_Studená vnitřní | VE13.01.0095 | Umyvadlo + modul | 0095
13136472 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | WS_Teplá vnitřní | VE13.01.0135 | Umyvadlo | 0135
13136473 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 151 | WS_Studená vnitřní | VE13.01.0136 | Umyvadlo | 0136
13142662 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 4 | WS_Teplá vnitřní | VE13.01.0138 | Umyvadlo + modul_invalida | 0138
13142663 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 6 | WS_Studená vnitřní | VE13.01.0139 | Umyvadlo + modul_invalida | 0139
13144904 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 5 | WS_Teplá vnitřní | VE13.01.0141 | Dřez | 0141
13144905 | 3.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 7 | WS_Studená vnitřní | VE13.01.0142 | Dřez | 0142
13192350 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 7 | WS_Teplá vnitřní | VE13.01.0158 | Výlevka nástěnní | 0158
13192351 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 29 | WS_Studená vnitřní | VE13.01.0159 | Výlevka nástěnní | 0159
13192373 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | WS_Teplá vnitřní | VE13.01.0161 | Výlevka nástěnní | 0161
13192374 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 30 | WS_Studená vnitřní | VE13.01.0162 | Výlevka nástěnní | 0162
13192399 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 9 | WS_Teplá vnitřní | VE13.01.0164 | Výlevka nástěnní | 0164
13192400 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 31 | WS_Studená vnitřní | VE13.01.0165 | Výlevka nástěnní | 0165
13192425 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 10 | WS_Teplá vnitřní | VE13.01.0167 | Výlevka nástěnní | 0167
13192426 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 32 | WS_Studená vnitřní | VE13.01.0168 | Výlevka nástěnní | 0168
13192451 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 19 | WS_Teplá vnitřní | VE13.01.0170 | Výlevka nástěnní | 0170
13192452 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 33 | WS_Studená vnitřní | VE13.01.0171 | Výlevka nástěnní | 0171
13192535 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 25 | WS_Teplá vnitřní | VE13.01.0173 | Výlevka nástěnnî | 0173
13192536 | 2.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 35 | WS_Studená vnitřní | VE13.01.0174 | Výlevka nástěnnî | 0174
13218070 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 20 | WS_Teplá vnitřní | VE13.01.0181 | Umyvadlo | 0181
13218071 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 25 | WS_Studená vnitřní | VE13.01.0182 | Umyvadlo | 0182
13218418 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 18 | WS_Teplá vnitřní | VE13.01.0184 | Umyvadlo + modul | 0184
13218419 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 14 | WS_Studená vnitřní | VE13.01.0185 | Umyvadlo + modul | 0185
13218514 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 23 | WS_Teplá vnitřní | VE13.01.0187 | Umyvadlo + modul | 0187
13218515 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 19 | WS_Studená vnitřní | VE13.01.0188 | Umyvadlo + modul | 0188
13218681 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 17 | WS_Teplá vnitřní | VE13.01.0190 | Umyvadlo + modul | 0190
13218682 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 13 | WS_Studená vnitřní | VE13.01.0191 | Umyvadlo + modul | 0191
13279626 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 2 | WS_Teplá vnitřní | VE13.01.0201 | Umyvadlo + modul | 0201
13279627 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 5 | WS_Studená vnitřní | VE13.01.0202 | Umyvadlo + modul | 0202
13279970 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 26 | WS_Teplá vnitřní | VE13.01.0204 | Umyvadlo + modul | 0204
13279971 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 21 | WS_Studená vnitřní | VE13.01.0205 | Umyvadlo + modul | 0205
13281684 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 27 | WS_Teplá vnitřní | VE13.01.0207 | Umyvadlo + modul | 0207
13281685 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 23 | WS_Studená vnitřní | VE13.01.0208 | Umyvadlo + modul | 0208
13281830 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 28 | WS_Teplá vnitřní | VE13.01.0210 | Umyvadlo + modul | 0210
13281831 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 24 | WS_Studená vnitřní | VE13.01.0211 | Umyvadlo + modul | 0211
13315238 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 16 | WS_Teplá vnitřní | VE13.01.0217 | Umyvadlo invalida s předstěnou | 0217
13315239 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 22 | WS_Studená vnitřní | VE13.01.0218 | Umyvadlo invalida s předstěnou | 0218
13315642 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 30 | WS_Teplá vnitřní | VE13.01.0220 | Myčka 5 | 0220
13315643 | 3.NP_SO-101 | 4.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 27 | WS_Studená vnitřní | VE13.01.0221 | Myčka 5 | 0221
13413832 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 29 | WS_Teplá vnitřní | VE13.01.0223 | Myčka 6 | 0223
13413833 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 26 | WS_Studená vnitřní | VE13.01.0224 | Myčka 6 | 0224
13413871 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 12 | WS_Teplá vnitřní | VE13.01.0226 | Myčka 6 | 0226
13413872 | -1.PP_SO-101 | -1.PP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 16 | WS_Studená vnitřní | VE13.01.0227 | Myčka 6 | 0227
13414473 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 21 | WS_Teplá vnitřní | VE13.01.0229 | Myčka 7 | 0229
13414474 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 17 | WS_Studená vnitřní | VE13.01.0230 | Myčka 7 | 0230
13414529 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 31 | WS_Teplá vnitřní | VE13.01.0232 | Myčka 7 | 0232
13414530 | -1.PP_SO-101 | 1.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 36 | WS_Studená vnitřní | VE13.01.0233 | Myčka 7 | 0233
13428031 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 6 | WS_Teplá vnitřní | VE13.01.0237 | Umyvadlo + modul | 0237
13428032 | 2.NP_SO-101 | 3.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 15 | WS_Studená vnitřní | VE13.01.0238 | Umyvadlo + modul | 0238
13437378 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 32 | WS_Teplá vnitřní | VE13.01.0240 | Umyvadlo | 0240
13437379 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 34 | WS_Studená vnitřní | VE13.01.0241 | Umyvadlo | 0241
13437484 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 33 | WS_Teplá vnitřní | VE13.01.0243 | Umyvadlo | 0243
13437485 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 37 | WS_Studená vnitřní | VE13.01.0244 | Umyvadlo | 0244
13437531 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Teplá voda v domácnosti | WS_Teplá vnitřní 3 | WS_Teplá vnitřní | VE13.01.0246 | Umyvadlo + modul | 0246
13437532 | 1.NP_SO-101 | 2.NP_SO-101 | 580 | Studená voda v domácnosti | WS_Studená vnitřní 12 | WS_Studená vnitřní | VE13.01.0247 | Umyvadlo + modul | 0247

# IfcValve: Sifon pisoárový:DN50 (7)
Type - Material: Plactic - White, Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: Plactic - White; Materiál 2: Plactic - Black
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.70.50.00; DIMENZE: DN50; EAN: 9003076314300; HMOTNOST: 0,185 kg; HYDRAULICKÁ KAPACITA: 0,7l/s, Spülwasservolumen 1,0l; Indexovaná poznámka: HL430/50; Kód sestavy: ZU00; Komentáře k typům: Odsávací zápachová uzávěrka DN50 pro pisoáry, s kloubem na odtoku; MATERIÁL: PP; Model: HL430/50; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: DN50; NORMY: DIN1380, DIN19541; Označení typu: 03; Popis: Odsávací zápachová uzávěrka DN50 pro pisoáry; Popis sestavy: Obecný prvek; PRÁVNÍ OZNÁMENÍ: "Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem."; URL: http://www.hutterer-lechner.com/cs/products/catalog/roof-drains/HL430/50.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; b: 110.2 mm; n: 25 mm; Název rodiny: Sifon pisoárový
Classification: ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Výška od podlaží: 450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární,Nedefinovaný
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.0008489 m3; Úhel instalace výstup: 0 deg; Velikost: ø50-ø50
Identifikační data - Název sestavy: Pisoár + modul
Jiné - a: 118.7 mm; c: 118.4 mm; d: 118.7 mm; Id typu: 12878471; Rodina: Sifon pisoárový; Rodina a typ: Sifon pisoárový: DN50; Typ: DN50; Úhel instalace výstup max: 0 deg; Úhel instalace výstup min: 0 deg; x: 25.5 mm
Name (Sifon pisoárový:DN50:...) | In | Podlaží | Kód prvku | Označení
12878824 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.03.0019 | 0019
12879008 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.03.0020 | 0020
12879059 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.03.0021 | 0021
12907822 | 2.NP_SO-101 | 3.NP_SO-101 | ZU00.03.0058 | 0058
12908659 | 3.NP_SO-101 | 4.NP_SO-101 | ZU00.03.0086 | 0086
13427661 | -1.PP_SO-101 | 1.NP_SO-101 | ZU00.03.0235 | 0235
13427752 | -1.PP_SO-101 | 1.NP_SO-101 | ZU00.03.0236 | 0236

# IfcValve: Sifon umyvadlový:Sifon dřezový (7)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZU00; Komentáře k typům: Zápachová uzávěrka pro umyvadlo; Název typu: Sifon dřezový; Označení typu: 16; Popis: ZU; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; A: 25 mm; B: 30 mm; C: 25 mm; ID: 50 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon umyvadlový; OD: 51 mm
Classification: ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000816082 m3; Prodloužení 1: 110 mm; Prodloužení 2: 150 mm; Velikost: ø50-ø50; Výška odpadu: 530 mm
Jiné - Rodina: Sifon umyvadlový; Id typu: 13143001; Rodina a typ: Sifon umyvadlový: Sifon dřezový; Typ: Sifon dřezový
Name (Sifon umyvadlový:Sifon dřezový:...) | In | Podlaží | Kód prvku | Název sestavy | Označení
13144906 | 3.NP_SO-101 | 3.NP_SO-101 | ZU00.16.0143 | Dřez | 0143
13192352 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0160 | Výlevka nástěnní | 0160
13192375 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0163 | Výlevka nástěnní | 0163
13192401 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0166 | Výlevka nástěnní | 0166
13192427 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0169 | Výlevka nástěnní | 0169
13192453 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0172 | Výlevka nástěnní | 0172
13192537 | 2.NP_SO-101 | 2.NP_SO-101 | ZU00.16.0175 | Výlevka nástěnnî | 0175

# IfcValve: Sifon umyvadlový:Sifon umyvadlový (50)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZU00; Komentáře k typům: Zápachová uzávěrka pro umyvadlo; Název typu: Sifon umyvadlový; Označení typu: 02; Popis: ZU; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; A: 20 mm; B: 25 mm; C: 20 mm; ID: 40 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon umyvadlový; OD: 40.8 mm
Classification: ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Velikost: ø40-ø40; Výška odpadu: 530 mm
Jiné - Id typu: 12812715; Rodina: Sifon umyvadlový; Rodina a typ: Sifon umyvadlový: Sifon umyvadlový; Typ: Sifon umyvadlový
Name (Sifon umyvadlový:Sifon umyvadlový:...) | In | Podlaží | Výška od podlaží (mm) | Objem (m3) | Prodloužení 1 (mm) | Prodloužení 2 (mm) | Kód prvku | Název sestavy | Označení
12872624 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0003 | Umyvadlo | 0003
12872650 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0006 | Umyvadlo | 0006
12872827 | -1.PP_SO-101 | -1.PP_SO-101 | -750 | 0.000597412 | 110 | 205.675 | ZU00.02.0009 | Umyvadlo | 0009
12872860 | -1.PP_SO-101 | -1.PP_SO-101 | -750 | 0.000597412 | 110 | 205.675 | ZU00.02.0012 | Umyvadlo | 0012
12873240 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0015 | Umyvadlo | 0015
12873274 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0018 | Umyvadlo | 0018
12905772 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0024 | Umyvadlo | 0024
12906444 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0027 | Umyvadlo + modul | 0027
12906990 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0030 | Umyvadlo | 0030
12907049 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0033 | Umyvadlo + modul | 0033
12907116 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0036 | Umyvadlo + modul | 0036
12907140 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0039 | Umyvadlo + modul | 0039
12907380 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0042 | Umyvadlo | 0042
12907452 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0045 | Umyvadlo | 0045
12907475 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0048 | Umyvadlo | 0048
12907560 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0051 | Umyvadlo + modul | 0051
12907584 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0054 | Umyvadlo + modul | 0054
12907722 | 3.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0057 | Umyvadlo | 0057
12907984 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0061 | Umyvadlo | 0061
12908043 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0064 | Umyvadlo + modul | 0064
12908067 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0067 | Umyvadlo + modul | 0067
12908150 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0070 | Umyvadlo + modul | 0070
12908174 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0073 | Umyvadlo + modul | 0073
12908269 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0076 | Umyvadlo + modul | 0076
12908339 | -1.PP_SO-101 | 4.NP_SO-101 | 700 | 0.000597412 | 110 | 205.675 | ZU00.02.0079 | Umyvadlo + modul | 0079
12908461 | -1.PP_SO-101 | 4.NP_SO-101 | 700 | 0.000597412 | 110 | 205.675 | ZU00.02.0082 | Umyvadlo + modul | 0082
12908595 | 3.NP_SO-101 | 4.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0085 | Umyvadlo + modul | 0085
12908786 | 3.NP_SO-101 | 4.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0089 | Umyvadlo | 0089
12944905 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0093 | Umyvadlo + modul | 0093
12944929 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0096 | Umyvadlo + modul | 0096
13136480 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0137 | Umyvadlo | 0137
13142671 | -1.PP_SO-101 | 1.NP_SO-101 | -0.0315427 | 0.000587529 | 122.9 | 185.7 | ZU00.02.0140 | Umyvadlo + modul_invalida | 0140
13218078 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0183 | Umyvadlo | 0183
13218426 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0186 | Umyvadlo + modul | 0186
13218522 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0189 | Umyvadlo + modul | 0189
13218689 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0192 | Umyvadlo + modul | 0192
13279634 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0203 | Umyvadlo + modul | 0203
13279978 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0206 | Umyvadlo + modul | 0206
13281692 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0209 | Umyvadlo + modul | 0209
13281838 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0212 | Umyvadlo + modul | 0212
13315246 | 2.NP_SO-101 | 3.NP_SO-101 | -0.0315427 | 0.000587529 | 122.9 | 185.7 | ZU00.02.0219 | Umyvadlo invalida s předstěnou | 0219
13315650 | 3.NP_SO-101 | 4.NP_SO-101 | -0.0315427 | 0.000587529 | 122.9 | 185.7 | ZU00.02.0222 | Myčka 5 | 0222
13413840 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0225 | Myčka 6 | 0225
13413879 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0228 | Myčka 6 | 0228
13414481 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0231 | Myčka 7 | 0231
13414537 | -1.PP_SO-101 | 1.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0234 | Myčka 7 | 0234
13428039 | 2.NP_SO-101 | 3.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0239 | Umyvadlo + modul | 0239
13437386 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0242 | Umyvadlo | 0242
13437492 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0245 | Umyvadlo | 0245
13437539 | 1.NP_SO-101 | 2.NP_SO-101 | 0 | 0.000597412 | 110 | 205.675 | ZU00.02.0248 | Umyvadlo + modul | 0248

# IfcValve: Těleso vpusti_3100K:3100K_Main Component (4)
Type - Material: Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: DN50/75/110; EAN: 9003076025510; HMOTNOST: 0,45 [kg]; Indexovaná poznámka: HL3100K; Kód sestavy: VP02; Komentáře k typům: HL3100K Těleso podlahové vpusti DN50/75/110, svislý odtok; MATERIÁL: PE; Model: HL3100K; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 3100K_Main Component; Označení typu: 20; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; STAVEBNÍ VÝŠKA: 162 mm; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL3100K.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Těleso vpusti_3100K
Classification: VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: XKE; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8016.34 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000460713 m3
Jiné - Id typu: 13173904; Rodina: Těleso vpusti_3100K; Rodina a typ: Těleso vpusti_3100K: 3100K_Main Component; Typ: 3100K_Main Component
Name (Těleso vpusti_3100K:3100K_Main Component:...) | In | Podlaží | Kód prvku | Označení
13173765 | 1.NP_SO-101 | 1.NP_SO-101 | VP02.20.0147 | 0147
13189700 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.20.0151 | 0151
13189735 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.20.0155 | 0155
13203795 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.20.0178 | 0178

# IfcValve: Vtoková mřížka_03910.1E:03910.1E_Main Component (4)
Type - Material: Stainless Steel
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: 138x138mm; EAN: 9003076025633; HMOTNOST: 0,22 [kg]; Indexovaná poznámka: HL03910.1E; Kód sestavy: VP02; Komentáře k typům: HL03910.1E Nerezová vtoková mřížka 138x138mm; MATERIÁL: V2A; Model: HL03910.1E; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 03910.1E_Main Component; Označení typu: 22; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; TŘÍDA ZATÍŽENÍ: K3 - 300 kg; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL03910.1E.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Vtoková mřížka_03910.1E
Classification: VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: NAC; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8000 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00009522 m3
Jiné - Id typu: 13173899; Rodina: Vtoková mřížka_03910.1E; Rodina a typ: Vtoková mřížka_03910.1E: 03910.1E_Main Component; Typ: 03910.1E_Main Component
Name (Vtoková mřížka_03910.1E:03910.1E_Main Component:...) | In | Podlaží | Kód prvku | Označení
13173767 | 1.NP_SO-101 | 1.NP_SO-101 | VP02.22.0149 | 0149
13189702 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.22.0153 | 0153
13189737 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.22.0157 | 0157
13203797 | -1.PP_SO-101 | -1.PP_SO-101 | VP02.22.0180 | 0180

# IfcValve: Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnitřní závit (3)
In: -1.PP_SO-101
Type - Material: MANIPULAČNÍ PROSTOR, <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Kóty - DÉLKA: 63 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Cena: 0; Kód sestavy: VE12; Komentáře k typům: VKK DN15; Model: DN 15 vnitřní závit; Název typu: DN15 přímý vnitřní závit; Označení typu: 09; Popis: Kulový kohout; Popis sestavy: Vypouštěcí; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; A: -12 mm; B: 19 mm; C: 16 mm; D: 44 mm; E: -12 mm; H: 37.6 mm; H1: 24.6 mm; H2: 13 mm; KL: no; L1: 28 mm; L2: 63 mm; Lookup Table Name: Vypoštěcí kulový kohout s páčkou.CC; M: 48 mm; M1: 20 mm; Název rodiny: Vypouštěcí kulový kohout závitový.LH; P: 25 mm; P1: 30 mm; P2: 14 mm; PR: yes; Typ: 1 mm; U: 0 deg; UP: 30 deg
Classification: VE12 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000642485 m3; Velikost: ø15
Jiné - Páteřní trasa: yes; Id typu: 13022243; Rodina: Vypouštěcí kulový kohout závitový.LH; Rodina a typ: Vypouštěcí kulový kohout závitový.LH: DN15 přímý vnitřní závit; Typ: DN15 přímý vnitřní závit
Name (Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnitřní závit:...) | Výška od podlaží (mm) | Kód prvku | Označení
13066218 | 2450 | VE12.09.0109 | 0109
13066248 | 2450 | VE12.09.0110 | 0110
13262542 | 2400 | VE12.09.0198 | 0198

# IfcValve: Větrací hlavice:Uzavření_kanalizace_HT (3)
In: 4.NP_SO-101
Type - Material: 255-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 300 mm; Jmenovitá velikost vstupu: 110 mm; Šířka: 300 mm; Výška: 200 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: HV01; Komentáře k typům: VĚTRACÍ HLAVICE; Nadpis OmniClass: Pipework Fittings; Název typu: Uzavření_kanalizace_HT; Označení typu: 04; Popis sestavy: Větrací
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Větrací hlavice; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: HV01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: STŘECHA_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Odvětrání kanalizace; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 12917422; Rodina: Větrací hlavice; Rodina a typ: Větrací hlavice: Uzavření_kanalizace_HT; Typ: Uzavření_kanalizace_HT
Name (Větrací hlavice:Uzavření_kanalizace_HT:...) | Celková velikost | Výška od podlaží (mm) | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Vnější průměr tvarovky (mm) | Výš. (mm) = Vnější poloměr tvarovky (mm) | Vzdálenost šipky (mm) | Kód prvku | Komentáře | Označení
12924368 | ø110 mm | -215 | SW_Odvětrání kanalizace 10 | 55 | 110 | 0.000717025 | 0.0403753 | ø110 | 113.175 | 56.5875 | 285 | HV01.04.0090 | 500 mm NAD PRŮNIKEM STŘECHOU | 0090
13134242 | ø135 mm | -255 | SW_Odvětrání kanalizace 2 | 67.5 | 135 | 0.00131855 | 0.0607814 | ø135 | 138.175 | 69.0875 | 310 | HV01.04.0134 | 500 mm NAD PRŮNIKEM STŘECHOU | 0134
13291192 | ø110 mm | 65 | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000717025 | 0.0403753 | ø110 | 113.175 | 56.5875 | 285 | HV01.04.0215 |  | 0215

# IfcValve: Zpětná klapka závitová.LH:DN 20, Zpětná klapka závitová.LH:DN 20:13072112
In: 3.NP_SO-101
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 50 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; PRŮMĚR: 39 mm
Type - Identifikační data - Kód sestavy: VE15; Komentáře k typům: ZV DN20; Model: Model; Název typu: DN 20; Označení typu: 14; Popis: Ventil; Popis sestavy: Zpětný; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zpětná klapka závitová.LH; ODSAZENí: 16.6667 mm; OSAZENÍ BOČNÉ: 12.5 mm; VS: 100 mm
Classification: VE15 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: RMB; CCI Technický systém: JB
Vazby - Podlaží: 3.NP_SO-101; Výška od podlaží: 3450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000597267 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Identifikační data - Kód prvku: VE15.14.0126; Označení: 0126
Jiné - Typ: DN 20; Id typu: 13046471; Rodina: Zpětná klapka závitová.LH; Rodina a typ: Zpětná klapka závitová.LH: DN 20

# IfcValve: Zpětná klapka závitová.LH:DN 25 (2)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 58 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm; PRŮMĚR: 47 mm
Type - Identifikační data - Kód sestavy: VE15; Komentáře k typům: ZV DN25; Model: Model; Název typu: DN 25; Označení typu: 15; Popis: Ventil; Popis sestavy: Zpětný; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zpětná klapka závitová.LH; ODSAZENí: 19.3333 mm; OSAZENÍ BOČNÉ: 14.5 mm; VS: 116 mm
Classification: VE15 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: RMB; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.000100622 m3; Průměr připojení: 32 mm; Velikost: ø32-ø32
Jiné - Typ: DN 25; Rodina: Zpětná klapka závitová.LH; Id typu: 13046469; Rodina a typ: Zpětná klapka závitová.LH: DN 25
Name (Zpětná klapka závitová.LH:DN 25:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13072560 | 4.NP_SO-101 | 4.NP_SO-101 | 2973.69 | VE15.15.0128 | 0128
13072742 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | VE15.15.0132 | 0132

# IfcValve: Zápachový uzávěr vložka_2100:2100_Main Component (4)
Type - Material: Plactic - White, Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; EAN: 9003076025619; HMOTNOST: 0,18 [kg]; Indexovaná poznámka: HL2100; Kód sestavy: ZU00; Komentáře k typům: HL2100 Zápachový uzávěr "Primus" k HL3100Pr a HL5100Pr; MATERIÁL: PP/ABS; Model: HL2100; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 2100_Main Component; Označení typu: 21; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Obecný prvek; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL2100.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zápachový uzávěr vložka_2100
Classification: ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: RMD; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8005 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000483318 m3
Jiné - Id typu: 13173910; Rodina: Zápachový uzávěr vložka_2100; Rodina a typ: Zápachový uzávěr vložka_2100: 2100_Main Component; Typ: 2100_Main Component
Name (Zápachový uzávěr vložka_2100:2100_Main Component:...) | In | Podlaží | Kód prvku | Označení
13173766 | 1.NP_SO-101 | 1.NP_SO-101 | ZU00.21.0148 | 0148
13189701 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.21.0152 | 0152
13189736 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.21.0156 | 0156
13203796 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.21.0179 | 0179

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 1235.47 m2; Hrubý objem: 2924.68 m3; Obsazená plocha: 1235.47 m2; Obsazený objem: 2924.68 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
