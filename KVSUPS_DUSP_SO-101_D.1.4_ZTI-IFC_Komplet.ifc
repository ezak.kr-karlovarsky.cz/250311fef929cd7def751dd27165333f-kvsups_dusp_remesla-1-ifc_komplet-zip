Properties of the parts of a building model (IFC4), part 13 of 26

# IfcFlowTerminal: Komponent 4000.0:Komponent 4000.0 (3)
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.37; DIMENSION: DN40/50; EAN: 9003076041619; Indexovaná poznámka: HL4000.0; INSTALLATION DEPTH: 70-115 mm; Kód sestavy: ZU00; Komentáře k typům: Framing set for recessed washing device siphons for the installation in the wall, incl. fixing brackets. Stench plug, screw for the siphon cartridge and protection cover included. Prepared for single and double connections of washing machines or clothes dryers. After the installation it may be equipped with eather single (HL4000.1)or double (HL4000.2) connector. Further advantage: After removing the cartridge - free access to the downpipe.; LEGAL NOTICE: Copyright (©), design rights or any other intellectual property rights, shall be the exclusive property of HL Hutterer & Lechner GmbH. Modification is not allowed. Family has been watermarked.; MATERIAL: PP PP PP PP; Model: HL4000.0; Nadpis OmniClass: Valves for Removal Systems; Název typu: Komponent 4000.0; Označení typu: 25; Popis: Washing devices; Popis sestavy: Obecný prvek; URL: http://www.hutterer-lechner.com/en/Products/catalog/washing-devices/attachments/HL4000.0.aspx; Výrobce: HL Hutterer & Lechner GmbH; WEIGHT: 0,24 [kg]
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Komponent 4000.0
Classification: ZU00 Uniformat (Uniformat)
Mechanické – tok - FLOW: 0 m3/s
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Hostitel: <nepřiřazeno>
Fázování - Fáze vytvoření: Fáze 1
Kóty - Installation depth: 115 mm; NOMINAL DIAMETER: 50 mm; Objem: 0.00170009 m3
Jiné - E: yes; A: 204 mm; C: 55 mm; D: 55 mm; Id typu: 12856108; Rodina: Komponent 4000.0; Rodina a typ: Komponent 4000.0: Komponent 4000.0; Typ: Komponent 4000.0
Name (Komponent 4000.0:Komponent 4000.0:...) | In | Kód prvku | Označení
13147149 | 3.NP_SO-101 | ZU00.25.0196 | 0196
13286943 | -1.PP_SO-101 | ZU00.25.0262 | 0262
13286956 | -1.PP_SO-101 | ZU00.25.0264 | 0264

# IfcFlowTerminal: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC:Modul pro WC 112cm, s nádrží Sigma 12cm (19)
Type - Material: PLAST_BÍLÝ, <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro WC 112cm, s nádrží Sigma 12cm; Model: 111.300.00.5; Název typu: Modul pro WC 112cm, s nádrží Sigma 12cm; Označení typu: 02; Popis: Závěsný rám pro WC; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABB; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0356336 m3; Vysunutí nožiček: 100 mm; Vysunutí tlačítka: 60 mm
Identifikační data - Název sestavy: Toaleta + modul
Jiné - Id typu: 12818279; Rodina: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC; Rodina a typ: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC: Modul pro WC 112cm, s nádrží Sigma 12cm; Typ: Modul pro WC 112cm, s nádrží Sigma 12cm; VN: 100 mm
Name (Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC:Modul pro WC 112cm, s nádrží Sigma 12cm:...) | In | Podlaží | Hostitel | Kód prvku | Označení
12834167 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0002 | 0002
12834219 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0005 | 0005
12834256 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0008 | 0008
12834340 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0011 | 0011
12834393 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0014 | 0014
12837347 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0017 | 0017
12906121 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.02.0050 | 0050
12906129 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.02.0053 | 0053
12906388 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.02.0056 | 0056
12907665 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.02.0095 | 0095
12907789 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.02.0101 | 0101
12908715 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.02.0145 | 0145
12908723 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.02.0148 | 0148
12944784 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0172 | 0172
13218241 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0231 | 0231
13413558 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0276 | 0276
13413655 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.02.0279 | 0279
13427845 | 1.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.02.0306 | 0306
13427891 | 1.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.02.0309 | 0309

# IfcFlowTerminal: Modul pro WC a madla, pro lehké kce_invalida:Modul pro WC a madla, pro lehké kce_invalida (3)
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Předstěnové systémy modul pro WC Geberit Duofix Special pro závěs. WC s nádrž. UP320 bezbariérový; Model: 111.375.00.5 218058128000000065; Název typu: Modul pro WC a madla, pro lehké kce_invalida; Označení typu: 16; Popis: Závěsný rám pro WC; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro WC a madla, pro lehké kce_invalida
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABB; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0496315 m3; Vysunuté tlačítka: 60 mm; Vysunutí nožiček: 50 mm
Jiné - Id typu: 13136679; Rodina: Modul pro WC a madla, pro lehké kce_invalida; Rodina a typ: Modul pro WC a madla, pro lehké kce_invalida: Modul pro WC a madla, pro lehké kce_invalida; Typ: Modul pro WC a madla, pro lehké kce_invalida
Name (Modul pro WC a madla, pro lehké kce_invalida:Modul pro WC a madla, pro lehké kce_invalida:...) | In | Podlaží | Hostitel | Kód prvku | Název sestavy | Označení
13136634 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.16.0185 | Toaleta + modul (madla)_invalida | 0185
13315361 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.16.0267 | Myčka 3 | 0267
13315539 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.16.0270 | Myčka 3 | 0270

# IfcFlowTerminal: Modul pro pisoár 112-130 cm Universal - lehká kce.CC:Modul pro pisoár 112-130 cm Universal - lehká kce.CC (7)
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro pisoár 112-130 cm Universal; Model: 111.616.00.1; Název typu: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Označení typu: 07; Popis: Závěcný rám pro pisoár; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro pisoár 112-130 cm Universal - lehká kce.CC
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0163786 m3; Výška čidla: 1170 mm; Vysunutí nožiček: 100 mm; Vysunutí tlačítka: 90 mm
Identifikační data - Název sestavy: Pisoár + modul
Jiné - Id typu: 12834492; Rodina: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Rodina a typ: Modul pro pisoár 112-130 cm Universal - lehká kce.CC: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Typ: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; VC: 1170 mm; VN: 100 mm
Name (Modul pro pisoár 112-130 cm Universal - lehká kce.CC:Modul pro pisoár 112-130 cm Universal - lehká kce.CC:...) | In | Podlaží | Hostitel | Kód prvku | Označení
12878820 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.07.0037 | 0037
12879004 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.07.0040 | 0040
12879055 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.07.0043 | 0043
12907818 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.07.0103 | 0103
12908655 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.07.0141 | 0141
13427657 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.07.0299 | 0299
13427748 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.07.0302 | 0302

# IfcFlowTerminal: Modul pro umyvadlo 82_98 cm.CC:Modul pro umyvadlo 82_98 cm.CC (27)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro umyvadlo 82/98 cm; Model: 111.485.00.1; Název typu: Modul pro umyvadlo 82_98 cm.CC; Označení typu: 09; Popis: Závěsný rám pro umyvadlo; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro umyvadlo 82_98 cm.CC
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0040844 m3; Tloušťka podlahy: 90 mm
Jiné - Id typu: 12812721; Rodina: Modul pro umyvadlo 82_98 cm.CC; Rodina a typ: Modul pro umyvadlo 82_98 cm.CC: Modul pro umyvadlo 82_98 cm.CC; Typ: Modul pro umyvadlo 82_98 cm.CC
Name (Modul pro umyvadlo 82_98 cm.CC:Modul pro umyvadlo 82_98 cm.CC:...) | In | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Kód prvku | Název sestavy | Označení
12906434 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.09.0058 | Umyvadlo + modul | 0058
12907039 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0065 | Umyvadlo + modul | 0065
12907106 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0069 | Umyvadlo + modul | 0069
12907130 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0073 | Umyvadlo + modul | 0073
12907550 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0086 | Umyvadlo + modul | 0086
12907574 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0090 | Umyvadlo + modul | 0090
12908033 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0109 | Umyvadlo + modul | 0109
12908057 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0113 | Umyvadlo + modul | 0113
12908140 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0117 | Umyvadlo + modul | 0117
12908164 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0121 | Umyvadlo + modul | 0121
12908259 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0125 | Umyvadlo + modul | 0125
12908329 | -1.PP_SO-101 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.09.0129 | Umyvadlo + modul | 0129
12908451 | -1.PP_SO-101 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.09.0133 | Umyvadlo + modul | 0133
12908585 | 3.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | MT04.09.0137 | Umyvadlo + modul | 0137
12944895 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.09.0174 | Umyvadlo + modul | 0174
12944919 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.09.0178 | Umyvadlo + modul | 0178
13218416 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.09.0233 | Umyvadlo + modul | 0233
13218512 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.09.0237 | Umyvadlo + modul | 0237
13218679 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | MT04.09.0241 | Umyvadlo + modul | 0241
13279624 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.09.0245 | Umyvadlo + modul | 0245
13279968 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.09.0249 | Umyvadlo + modul | 0249
13281682 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0253 | Umyvadlo + modul | 0253
13281828 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0257 | Umyvadlo + modul | 0257
13414471 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.09.0287 | Myčka 7 | 0287
13414527 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | MT04.09.0291 | Myčka 7 | 0291
13428029 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | MT04.09.0311 | Umyvadlo + modul | 0311
13437529 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | MT04.09.0321 | Umyvadlo + modul | 0321

# IfcFlowTerminal: Modul pro umyvadlo, pro lehké kce_invalida:Modul pro umyvadlo, pro lehké kce_invalida, Modul pro umyvadlo, pro lehké kce_invalida:Modul pro umyvadlo, pro lehké kce_invalida:13142672
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro umyvadlo 112cm též pro TP; Model: 111.430.00.1; Název typu: Modul pro umyvadlo, pro lehké kce_invalida; Označení typu: 18; Popis: Závěsný rám pro umyvadlo; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro umyvadlo, pro lehké kce_invalida
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-101; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00448845 m3; Tloušťka podlahy: 90 mm
Identifikační data - Kód prvku: MT04.18.0188; Název sestavy: Umyvadlo + modul_invalida; Označení: 0188
Jiné - Id typu: 13139492; Rodina: Modul pro umyvadlo, pro lehké kce_invalida; Rodina a typ: Modul pro umyvadlo, pro lehké kce_invalida: Modul pro umyvadlo, pro lehké kce_invalida; Typ: Modul pro umyvadlo, pro lehké kce_invalida

# IfcFlowTerminal: Modul výlevka.CC:Modul výlevka.CC, Modul výlevka.CC:Modul výlevka.CC:12908848
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: pro výlevku 130 cm; Model: Duofix 111.450.00.1; Název typu: Modul výlevka.CC; Označení typu: 10; Popis: Závěsný rám pro výlevku; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul výlevka.CC
Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Přesunout s blízkými prvky: no; Podlaží: 4.NP_SO-101; Hostitel: Podlaží : 4.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00932 m3; Tloušťka podlahy: 0 mm
Identifikační data - Kód prvku: MT04.10.0153; Název sestavy: Výlevka + modul; Označení: 0153
Jiné - Id typu: 12825710; Rodina: Modul výlevka.CC; Rodina a typ: Modul výlevka.CC: Modul výlevka.CC; Typ: Modul výlevka.CC

# IfcFlowTerminal: Nerezový dvoudřez:Nerezový dvoudřez (4)
In: 1.NP_SO-101
Type - Material: Ocel, leštěná
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál dřezu: Ocel, leštěná; Materiál příslušenství: Ocel, leštěná
Type - Stavba - Baterie vestavěná: no
Type - Kóty - Hloubka: 600 mm; Hloubka rovné plochy: 100 mm; Odsazení od stěny: 0 mm; Šířka: 1100 mm; Šířka lemu: 35 mm
Type - Identifikační data - Číslo OmniClass: 23.45.05.14.14; Kód sestavy: ZT06; Komentáře k typům: NEREZOVÝ DVOJDŘEZ; Nadpis OmniClass: Sinks/Lavatories; Název typu: Nerezový dvoudřez; Označení typu: 28; Popis sestavy: Dřez
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Nerezový dvoudřez
Classification: ZT06 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JB
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 850 mm; Výška od podlaží: 850 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0179339 m3; Plocha: 1.46949 m2; Poloha připojení odpadního potrubí: 320 mm; Průměr odpadního potrubí: 40 mm
Jiné - Id typu: 13426564; Rodina: Nerezový dvoudřez; Rodina a typ: Nerezový dvoudřez: Nerezový dvoudřez; Typ: Nerezový dvoudřez; Výška linky: 0 mm
Name (Nerezový dvoudřez:Nerezový dvoudřez:...) | Kód prvku | Označení
13427364 | ZT06.28.0295 | 0295 | Identifikační data - Komentáře: NEREZOVÝ DVOJDŘEZ
13427368 | ZT06.28.0296 | 0296
13427370 | ZT06.28.0297 | 0297
13427410 | ZT06.28.0298 | 0298

# IfcFlowTerminal: Pisoár:Pisoár (7)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA
Type - Kóty - JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT02; Komentáře k typům: Pisoár se zadním přívodem vody se sifonem; Název typu: Pisoár; Označení typu: 08; Popis: P; Popis sestavy: Pisoár; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Pisoár
Classification: ZT02 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0203603 m3; Tloušťka stěny: 20 mm
Identifikační data - Název sestavy: Pisoár + modul
Jiné - Id typu: 12834491; Rodina: Pisoár; Rodina a typ: Pisoár: Pisoár; Typ: Pisoár
Name (Pisoár:Pisoár:...) | In | Podlaží | Hostitel | Kód prvku | Označení | Material
12878822 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT02.08.0038 | 0038
12879006 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT02.08.0041 | 0041 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12879057 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT02.08.0044 | 0044 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12907820 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT02.08.0104 | 0104 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12908657 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT02.08.0142 | 0142 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
13427659 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT02.08.0300 | 0300 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
13427750 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT02.08.0303 | 0303 | <Unnamed>, ZDRAVOTNÍ KERAMIKA

# IfcFlowTerminal: Port ZTI_TRM_voda studená.CC:Port ZTI_TRM_voda studená.CC (29)
Type - Material: ZDRAVOTNÍ KERAMIKA
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: –; Kód sestavy: TR10; Komentáře k typům: ZTI voda teplá; Název typu: Port ZTI_TRM_voda studená.CC; Označení typu: 03; Popis: Port; Popis sestavy: Polypropylene Random Cristallinity Temperature (PP RCT); URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Port ZTI_TRM_voda studená.CC
Classification: TR10 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 8.83531e-07 m3
Jiné - Id typu: 12818271; Rodina: Port ZTI_TRM_voda studená.CC; Rodina a typ: Port ZTI_TRM_voda studená.CC: Port ZTI_TRM_voda studená.CC; Typ: Port ZTI_TRM_voda studená.CC
Name (Port ZTI_TRM_voda studená.CC:Port ZTI_TRM_voda studená.CC:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Název sestavy | Označení
12834169 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0003 | Toaleta + modul | 0003
12834221 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0006 | Toaleta + modul | 0006
12834258 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0009 | Toaleta + modul | 0009
12834342 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0012 | Toaleta + modul | 0012
12834395 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0015 | Toaleta + modul | 0015
12837349 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0018 | Toaleta + modul | 0018
12878823 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1170 | TR10.03.0039 | Pisoár + modul | 0039
12879007 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1170 | TR10.03.0042 | Pisoár + modul | 0042
12879058 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1170 | TR10.03.0045 | Pisoár + modul | 0045
12906123 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1045 | TR10.03.0051 | Toaleta + modul | 0051
12906131 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1045 | TR10.03.0054 | Toaleta + modul | 0054
12906390 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1045 | TR10.03.0057 | Toaleta + modul | 0057
12907667 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1045 | TR10.03.0096 | Toaleta + modul | 0096
12907791 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1045 | TR10.03.0102 | Toaleta + modul | 0102
12907821 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1170 | TR10.03.0105 | Pisoár + modul | 0105
12908658 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 1170 | TR10.03.0143 | Pisoár + modul | 0143
12908717 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 1045 | TR10.03.0146 | Toaleta + modul | 0146
12908725 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 1045 | TR10.03.0149 | Toaleta + modul | 0149
12944786 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0173 | Toaleta + modul | 0173
13136637 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1045 | TR10.03.0187 | Toaleta + modul (madla)_invalida | 0187
13218243 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0232 | Toaleta + modul | 0232
13315363 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1045 | TR10.03.0268 | Myčka 3 | 0268
13315540 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 1045 | TR10.03.0271 | Myčka 3 | 0271
13413559 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0277 | Toaleta + modul | 0277
13413657 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1045 | TR10.03.0280 | Toaleta + modul | 0280
13427660 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1170 | TR10.03.0301 | Pisoár + modul | 0301
13427751 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1170 | TR10.03.0304 | Pisoár + modul | 0304
13427847 | 1.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1045 | TR10.03.0307 | Toaleta + modul | 0307
13427893 | 1.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1045 | TR10.03.0310 | Toaleta + modul | 0310

# IfcFlowTerminal: Pračkový sifon:Pračkový sifon 4000.1 (3)
Type - Material: Plactic - White, V2A
Type - Vazby - Výchozí výška: 600 mm
Type - Grafika - HL4000.1: yes; HL4000.2: no; HL4000.3: no
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm
Type - Identifikační data - CAPACITY: 0,5 l/s; Číslo OmniClass: 23.70.50.21.37; DIMENSION: DN40/50; EAN: 9003076041633; Indexovaná poznámka: HL4000.1; INSTALLATION DEPTH: 70-115 mm; Kód sestavy: ZU00; Komentáře k typům: Single upgrate kit for washing device siphon HL4000.0 corpus. The siphon cartridge is inserted in HL4000.0 corpus and may be removed for maintenance reasons. Suitable for the connection of one washing device like washing machine or dish washer. Siphon cartridge with single connector and backflow ball, stainless steel cover, hose connector and threaded ring.; LEGAL NOTICE: Copyright (©), design rights or any other intellectual property rights, shall be the exclusive property of HL Hutterer & Lechner GmbH. Modification is not allowed. Family has been watermarked.; MATERIAL: PP/ V2A; Model: HL4000.1; Nadpis OmniClass: Valves for Removal Systems; Název typu: Pračkový sifon 4000.1; Označení typu: 24; Popis: Washing devices; Popis sestavy: Obecný prvek; URL: http://www.hutterer-lechner.com/en/Products/catalog/washing-devices/attachments/HL4000.1.aspx; Výrobce: HL Hutterer & Lechner GmbH; WEIGHT: 0,26 [kg]
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Pračkový sifon
Classification: ZU00 Uniformat (Uniformat)
Geometrie dělení - HL134.1C: no; HL134.1K: no
Mechanické – tok - FLOW: 0 m3/s
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Hostitel: <nepřiřazeno>; Výška od podlaží: 500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Instalation depth HL134.1x: 80 mm; Instalation hight HL134.1x: 150 mm; Installation depth: 115 mm; NOMINAL DIAMETER: 50 mm; Objem: 0.000381878 m3
Jiné - A: 204 mm; C: 55 mm; D: 55 mm; E: yes; IDC: 100 mm; IDK: 100 mm; Id typu: 12856286; IHC: 100 mm; IHK: 100 mm; Rodina: Pračkový sifon; Rodina a typ: Pračkový sifon: Pračkový sifon 4000.1; Typ: Pračkový sifon 4000.1; VC: no; VC1: no; VD: yes; VK: no; VK1: no
Name (Pračkový sifon:Pračkový sifon 4000.1:...) | In | Podlaží = Vztažné podlaží | Kód prvku | Název sestavy | Označení
13147148 | 2.NP_SO-101 | 3.NP_SO-101 | ZU00.24.0195 | Myčka 1 | 0195
13286942 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.24.0261 | Výlevka nástěnnð | 0261
13286955 | -1.PP_SO-101 | -1.PP_SO-101 | ZU00.24.0263 | Výlevka nástěnnð | 0263

# IfcFlowTerminal: Sprchová hlavice:Sprchová hlavice (6)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka hlavice: 250 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT00; Komentáře k typům: Komentáře k typům; Model: Model; Název typu: Sprchová hlavice; Označení typu: 14; Popis: Popis; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sprchová hlavice
Classification: ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 2000 mm; Výška od podlaží: 2000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti
Kóty - Objem: 0.000326978 m3; Plocha: 0.0418796 m2
Jiné - Id typu: 12832414; Rodina: Sprchová hlavice; Rodina a typ: Sprchová hlavice: Sprchová hlavice; Typ: Sprchová hlavice
Name (Sprchová hlavice:Sprchová hlavice:...) | Kód prvku | Název sestavy | Označení
12933660 | ZT00.14.0157 | Sprchový kout - žlab (podomítková baterie) | 0157
12933723 | ZT00.14.0160 | Sprchový kout - žlab (podomítková baterie) | 0160
12933782 | ZT00.14.0163 | Sprchový kout - žlab (podomítková baterie) | 0163
12933811 | ZT00.14.0166 | Myčka 8 | 0166
12933840 | ZT00.14.0169 | Myčka 8 | 0169
13218191 | ZT00.14.0228 | Sprchový kout - žlab (podomítková baterie) | 0228

# IfcFlowTerminal: Umyvadlo:Umyvadlo (47)
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT05; Komentáře k typům: Umyvadlo; Název typu: Umyvadlo; Označení typu: 04; Popis: U; Popis sestavy: Umyvadlo; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Umyvadlo
Classification: ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0234229 m3
Jiné - Typ: Umyvadlo; Id typu: 12812717; Rodina: Umyvadlo; Rodina a typ: Umyvadlo: Umyvadlo
Name (Umyvadlo:Umyvadlo:...) | In | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Kód prvku | Název sestavy | Označení
12872615 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0019 | Umyvadlo | 0019
12872641 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0022 | Umyvadlo | 0022
12872818 | -1.PP_SO-101 | -750 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0025 | Umyvadlo | 0025
12872851 | -1.PP_SO-101 | -750 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0028 | Umyvadlo | 0028
12873231 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0031 | Umyvadlo | 0031
12873265 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0034 | Umyvadlo | 0034
12905763 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0046 | Umyvadlo | 0046
12906435 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0059 | Umyvadlo + modul | 0059
12906981 | 2.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0062 | Umyvadlo | 0062
12907040 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0066 | Umyvadlo + modul | 0066
12907107 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0070 | Umyvadlo + modul | 0070
12907131 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0074 | Umyvadlo + modul | 0074
12907371 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0077 | Umyvadlo | 0077
12907443 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0080 | Umyvadlo | 0080
12907466 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0083 | Umyvadlo | 0083
12907551 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0087 | Umyvadlo + modul | 0087
12907575 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0091 | Umyvadlo + modul | 0091
12907713 | 3.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0097 | Umyvadlo | 0097
12907975 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0106 | Umyvadlo | 0106
12908034 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0110 | Umyvadlo + modul | 0110
12908058 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0114 | Umyvadlo + modul | 0114
12908141 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0118 | Umyvadlo + modul | 0118
12908165 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0122 | Umyvadlo + modul | 0122
12908260 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0126 | Umyvadlo + modul | 0126
12908330 | -1.PP_SO-101 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT05.04.0130 | Umyvadlo + modul | 0130
12908452 | -1.PP_SO-101 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT05.04.0134 | Umyvadlo + modul | 0134
12908586 | 3.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT05.04.0138 | Umyvadlo + modul | 0138
12908777 | 3.NP_SO-101 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT05.04.0150 | Umyvadlo | 0150
12944896 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0175 | Umyvadlo + modul | 0175
12944920 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0179 | Umyvadlo + modul | 0179
13136471 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0182 | Umyvadlo | 0182
13218069 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0224 | Umyvadlo | 0224
13218417 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0234 | Umyvadlo + modul | 0234
13218513 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0238 | Umyvadlo + modul | 0238
13218680 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0242 | Umyvadlo + modul | 0242
13279625 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0246 | Umyvadlo + modul | 0246
13279969 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0250 | Umyvadlo + modul | 0250
13281683 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0254 | Umyvadlo + modul | 0254
13281829 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0258 | Umyvadlo + modul | 0258
13413831 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0281 | Myčka 6 | 0281
13413870 | -1.PP_SO-101 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | ZT05.04.0284 | Myčka 6 | 0284
13414472 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0288 | Myčka 7 | 0288
13414528 | -1.PP_SO-101 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.04.0292 | Myčka 7 | 0292
13428030 | 2.NP_SO-101 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.04.0312 | Umyvadlo + modul | 0312
13437377 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0315 | Umyvadlo | 0315
13437483 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0318 | Umyvadlo | 0318
13437530 | 1.NP_SO-101 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT05.04.0322 | Umyvadlo + modul | 0322

# IfcFlowTerminal: Umyvadlo_invalida:Umyvadlo_invalida (3)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: UMi; Kód sestavy: ZT05; Komentáře k typům: Invalida umyvadlo; Název typu: Umyvadlo_invalida; Označení typu: 19; Popis: Umyvadlo invalida; Popis sestavy: Umyvadlo; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Umyvadlo_invalida
Classification: ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0364769 m3
Jiné - Id typu: 13139487; Rodina: Umyvadlo_invalida; Rodina a typ: Umyvadlo_invalida: Umyvadlo_invalida; Typ: Umyvadlo_invalida
Name (Umyvadlo_invalida:Umyvadlo_invalida:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Kód prvku | Název sestavy | Označení | Material
13142691 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT05.19.0190 | Umyvadlo + modul_invalida | 0190
13315244 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT05.19.0265 | Umyvadlo invalida s předstěnou | 0265 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
13315670 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT05.19.0274 | Myčka 5 | 0274 | <Unnamed>, ZDRAVOTNÍ KERAMIKA

# IfcFlowTerminal: Výlevka nástěnná_velká:Výlevka nástěnná_velká, Výlevka nástěnná_velká:Výlevka nástěnná_velká:12908849
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 100 mm; JMENOVITÝ PRŮMĚR 2: 55 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT04; Komentáře k typům: Výlevka keramická Jika Mira závěsná s plast. mřížkou bílá; Model: H8510490000001 234015540500000003; Název typu: Výlevka nástěnná_velká; Označení typu: 11; Popis: Výlevka; Popis sestavy: Výlevka; URL: www.cadconsulting.cz; Výrobce: JIKA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výlevka nástěnná_velká
Classification: ZT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 4.NP_SO-101; Hostitel: Podlaží : 4.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.050226 m3
Identifikační data - Kód prvku: ZT04.11.0154; Název sestavy: Výlevka + modul; Označení: 0154
Jiné - Id typu: 12825702; Rodina: Výlevka nástěnná_velká; Rodina a typ: Výlevka nástěnná_velká: Výlevka nástěnná_velká; Typ: Výlevka nástěnná_velká

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť dřezová (7)
Type - Material: CHROM
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: click clack; Název typu: Výpusť dřezová; Označení typu: 23; Popis: Dřezová výpusť; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výpusť umyvadlová
Classification: ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Dřez_centrovaný.CC : Dřez_centrovaný.CC; Výška od podlaží: 664.572 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00000865422 m3
Jiné - Rodina: Výpusť umyvadlová; Id typu: 13142995; Rodina a typ: Výpusť umyvadlová: Výpusť dřezová; Typ: Výpusť dřezová
Name (Výpusť umyvadlová:Výpusť dřezová:...) | In | Podlaží = Vztažné podlaží | Kód prvku | Název sestavy | Označení
13144916 | 3.NP_SO-101 | 3.NP_SO-101 | ZT00.23.0194 | Dřez | 0194
13192361 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0207 | Výlevka nástěnní | 0207
13192384 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0210 | Výlevka nástěnní | 0210
13192410 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0213 | Výlevka nástěnní | 0213
13192436 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0216 | Výlevka nástěnní | 0216
13192462 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0219 | Výlevka nástěnní | 0219
13192546 | 2.NP_SO-101 | 2.NP_SO-101 | ZT00.23.0222 | Výlevka nástěnnî | 0222

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť umyvadlová (48)
Type - Material: CHROM
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: click clack; Název typu: Výpusť umyvadlová; Označení typu: 06; Popis: Dřezová výpusť; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výpusť umyvadlová
Classification: ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00000865422 m3
Jiné - Id typu: 12866106; Rodina: Výpusť umyvadlová; Rodina a typ: Výpusť umyvadlová: Výpusť umyvadlová; Typ: Výpusť umyvadlová
Name (Výpusť umyvadlová:Výpusť umyvadlová:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Výška od podlaží (mm) | Kód prvku | Název sestavy | Označení
12872626 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0021 | Umyvadlo | 0021
12872652 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0024 | Umyvadlo | 0024
12872829 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | -27 | ZT00.06.0027 | Umyvadlo | 0027
12872862 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | -27 | ZT00.06.0030 | Umyvadlo | 0030
12873242 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0033 | Umyvadlo | 0033
12873276 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0036 | Umyvadlo | 0036
12905774 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0048 | Umyvadlo | 0048
12906446 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0061 | Umyvadlo + modul | 0061
12906992 | 2.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0064 | Umyvadlo | 0064
12907051 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0068 | Umyvadlo + modul | 0068
12907118 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0072 | Umyvadlo + modul | 0072
12907142 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0076 | Umyvadlo + modul | 0076
12907382 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0079 | Umyvadlo | 0079
12907454 | 3.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0082 | Umyvadlo | 0082
12907477 | 3.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0085 | Umyvadlo | 0085
12907562 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0089 | Umyvadlo + modul | 0089
12907586 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0093 | Umyvadlo + modul | 0093
12907724 | 3.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0099 | Umyvadlo | 0099
12907986 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0108 | Umyvadlo | 0108
12908045 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0112 | Umyvadlo + modul | 0112
12908069 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0116 | Umyvadlo + modul | 0116
12908152 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0120 | Umyvadlo + modul | 0120
12908176 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0124 | Umyvadlo + modul | 0124
12908271 | 2.NP_SO-101 | 3.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0128 | Umyvadlo + modul | 0128
12908341 | -1.PP_SO-101 | 4.NP_SO-101 | Umyvadlo : Umyvadlo | 1423 | ZT00.06.0132 | Umyvadlo + modul | 0132
12908463 | -1.PP_SO-101 | 4.NP_SO-101 | Umyvadlo : Umyvadlo | 1423 | ZT00.06.0136 | Umyvadlo + modul | 0136
12908597 | 3.NP_SO-101 | 4.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0140 | Umyvadlo + modul | 0140
12908788 | 3.NP_SO-101 | 4.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0152 | Umyvadlo | 0152
12944907 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0177 | Umyvadlo + modul | 0177
12944931 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0181 | Umyvadlo + modul | 0181
13136482 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0184 | Umyvadlo | 0184
13142673 | -1.PP_SO-101 | 1.NP_SO-101 | <nepřiřazeno> | 712.372 | ZT00.06.0189 | Umyvadlo + modul_invalida | 0189
13218080 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0226 | Umyvadlo | 0226
13218428 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0236 | Umyvadlo + modul | 0236
13218524 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0240 | Umyvadlo + modul | 0240
13218691 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0244 | Umyvadlo + modul | 0244
13279636 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0248 | Umyvadlo + modul | 0248
13279980 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0252 | Umyvadlo + modul | 0252
13281694 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0256 | Umyvadlo + modul | 0256
13281840 | 1.NP_SO-101 | 2.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0260 | Umyvadlo + modul | 0260
13413841 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0283 | Myčka 6 | 0283
13413880 | -1.PP_SO-101 | -1.PP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0286 | Myčka 6 | 0286
13414482 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0290 | Myčka 7 | 0290
13414538 | -1.PP_SO-101 | 1.NP_SO-101 | Umyvadlo : Umyvadlo | 723 | ZT00.06.0294 | Myčka 7 | 0294
13428041 | 2.NP_SO-101 |  | Umyvadlo : Umyvadlo | 0 | ZT00.06.0314 | Umyvadlo + modul | 0314
13437388 | 1.NP_SO-101 |  | Umyvadlo : Umyvadlo | 0 | ZT00.06.0317 | Umyvadlo | 0317
13437494 | 1.NP_SO-101 |  | Umyvadlo : Umyvadlo | 0 | ZT00.06.0320 | Umyvadlo | 0320
13437541 | 1.NP_SO-101 |  | Umyvadlo : Umyvadlo | 0 | ZT00.06.0324 | Umyvadlo + modul | 0324

# IfcFlowTerminal: WC závěsné:WC závěsné (19)
Type - Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA; WC prkénko: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 110 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT01; Komentáře k typům: Závěsné WC pro předstěnu; Název typu: WC závěsné; Označení typu: 01; Popis: WC; Popis sestavy: Záchodová mísa; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: WC závěsné
Classification: ZT01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKB; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.032307 m3; Tloušťka stěny: 20 mm
Identifikační data - Název sestavy: Toaleta + modul
Jiné - Id typu: 12818277; Rodina: WC závěsné; Rodina a typ: WC závěsné: WC závěsné; Typ: WC závěsné
Name (WC závěsné:WC závěsné:...) | In | Hostitel | Podlaží | Kód prvku | Označení
12834166 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0001 | 0001
12834218 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0004 | 0004
12834255 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0007 | 0007
12834339 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0010 | 0010
12834392 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0013 | 0013
12837346 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0016 | 0016
12906120 | -1.PP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | ZT01.01.0049 | 0049
12906128 | -1.PP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | ZT01.01.0052 | 0052
12906387 | -1.PP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | ZT01.01.0055 | 0055
12907664 | 2.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | ZT01.01.0094 | 0094
12907788 | 2.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | ZT01.01.0100 | 0100
12908714 | 3.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | ZT01.01.0144 | 0144
12908722 | 3.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | ZT01.01.0147 | 0147
12944783 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0171 | 0171
13218240 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0230 | 0230
13413557 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0275 | 0275
13413654 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | ZT01.01.0278 | 0278
13427844 | 1.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | ZT01.01.0305 | 0305
13427890 | 1.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | ZT01.01.0308 | 0308

# IfcFlowTerminal: WC závěsné_invalida:WC závěsné_invalida (3)
Type - Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Rámeček tlačítka: NEREZOVÁ OCEL; Sanitární keramika: ZDRAVOTNÍ KERAMIKA; Sedátko: PLAST_BÍLÝ; Tlačítko: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 110 mm; Výška odpadu: 230 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: WCi; Kód sestavy: ZT01; Komentáře k typům: Zavěšené WC pro předstěnu, invalida; Název typu: WC závěsné_invalida; Označení typu: 17; Popis: WC závěsné; Popis sestavy: Záchodová mísa; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: WC závěsné_invalida
Classification: ZT01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKB; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0450623 m3; Tloušťka obkladu: 20 mm
Jiné - Id typu: 13136678; Rodina: WC závěsné_invalida; Rodina a typ: WC závěsné_invalida: WC závěsné_invalida; Typ: WC závěsné_invalida
Name (WC závěsné_invalida:WC závěsné_invalida:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Kód prvku | Název sestavy | Označení
13136635 | -1.PP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | ZT01.17.0186 | Toaleta + modul (madla)_invalida | 0186
13315404 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT01.17.0269 | Myčka 3 | 0269
13315556 | 3.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | ZT01.17.0272 | Myčka 3 | 0272

# IfcFlowTerminal: Zlab_podlahovy_bocni odtok_stredni:Zlab_podlahovy_bocni odtok_stredni (6)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.45.00.00; Kód sestavy: BC01; Nadpis OmniClass: Sanitary, Laundry, and Cleaning Equipment; Název typu: Zlab_podlahovy_bocni odtok_stredni; Označení typu: 15; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Zlab_podlahovy_bocni odtok_stredni
Classification: BC01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-101; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Šířka: 150 mm; Výška: 40 mm; Výška sifonu: 70 mm
Jiné - Id typu: 12838570; Rodina: Zlab_podlahovy_bocni odtok_stredni; Rodina a typ: Zlab_podlahovy_bocni odtok_stredni: Zlab_podlahovy_bocni odtok_stredni; Typ: Zlab_podlahovy_bocni odtok_stredni
Name (Zlab_podlahovy_bocni odtok_stredni:Zlab_podlahovy_bocni odtok_stredni:...) | Délka (mm) | Objem (m3) | Plocha (m2) | Kód prvku | Název sestavy | Označení
12933661 | 1000 | 0.00411 | 0.42895 | BC01.15.0158 | Sprchový kout - žlab (podomítková baterie) | 0158
12933724 | 1000 | 0.00411 | 0.42895 | BC01.15.0161 | Sprchový kout - žlab (podomítková baterie) | 0161
12933783 | 1000 | 0.00411 | 0.42895 | BC01.15.0164 | Sprchový kout - žlab (podomítková baterie) | 0164
12933812 | 900 | 0.00386 | 0.39145 | BC01.15.0167 | Myčka 8 | 0167
12933841 | 900 | 0.00386 | 0.39145 | BC01.15.0170 | Myčka 8 | 0170
13218192 | 1000 | 0.00411 | 0.42895 | BC01.15.0229 | Sprchový kout - žlab (podomítková baterie) | 0229

# IfcPipeFitting: Chránička potrubí:Ocel, Chránička potrubí:Ocel:13221848
In: -1.PP_SO-101
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Komentáře k typům: CHRÁNIČKA; Nadpis OmniClass: Pipework Fittings; Název typu: Ocel; Označení typu: 07
Type - Jiné - Kategorie: Tvarovky; Název rodiny: Chránička potrubí; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Qto_PipeFittingBaseQuantities - Length: 1000 mm; GrossCrossSectionArea: 0.074484 m2; NetCrossSectionArea: 0.074484 m2; OuterSurfaceArea: 0.967532 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø250 mm-ø250 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: -1248.12 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární; Název systému: SW_Splašky vnitřní gravitační 10
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 1000 mm; Jmenovitý poloměr: 125 mm; Jmenovitý průměr: 250 mm; Maximální velikost: 250 mm; Minimální velikost: 250 mm; Objem: 0.0744904 m3; Velikost: ø250-ø250; Velikost značky: 123.19 mm; Vnější průměr tvarovky: 307.975 mm
Identifikační data - Kód prvku: .07.0544; Označení: 0544
Jiné - Páteřní trasa: yes; Id typu: 13221841; Rodina: Chránička potrubí; Rodina a typ: Chránička potrubí: Ocel; Typ: Ocel; Vnější poloměr tvarovky: 153.988 mm
Group: SW_Splašky vnitřní gravitační 10

# IfcPipeFitting: M_Koleno, obecné:Standardní (577)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | CCI Funkční systém | CCI Komponenta | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13048475 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0002 | 0002 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13048839 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0003 | 0003 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13049207 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0004 | 0004 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13049335 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0005 | 0005 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13050275 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 1730 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0008 | 0008 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13050328 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0010 | 0010 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13050338 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0011 | 0011 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13051152 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0013 | 0013 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13051753 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0023 | 0023 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13051875 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0026 | 0026 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13051921 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0027 | 0027 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13052094 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0030 | 0030 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13052104 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0031 | 0031 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13052112 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0032 | 0032 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13052180 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0033 | 0033 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13052188 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0034 | 0034 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13052277 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0035 | 0035 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13052398 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0037 | 0037 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13052406 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0038 | 0038 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13052418 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0039 | 0039 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13052465 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0041 | 0041 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13052473 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0042 | 0042 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13052483 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0043 | 0043 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
