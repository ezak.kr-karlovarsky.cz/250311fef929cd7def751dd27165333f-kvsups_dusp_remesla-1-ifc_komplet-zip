Properties of the parts of a building model (IFC4), part 5 of 26

# IfcSpace: WC-2 A0124.3-2:13315835, A0124.3-2
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0329648; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 10.138 W; Specifikované výkonové zatížení: 13.1794 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000364864 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 2.18512 m3; Plocha: 0.94185 m2
Identifikační data - Číslo: A0124.3-2; Číslo místnosti: Neobsazené; Název: WC-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC-2 A0125.2-2:13315838, A0125.2-2
In: -1.PP_SO-101
LongName: WC-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; NetVolume: 2.16677 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0470483; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 0 W; Specifikované výkonové zatížení: 0 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000111022 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Výpočtová výška: 0 mm
Identifikační data - Číslo: A0125.2-2; Číslo místnosti: Neobsazené; Název: WC-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Úklid-1 A0104-1:13315757, A0104-1
In: -1.PP_SO-101
LongName: Úklid-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; NetVolume: 9.85246 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.167098; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 51.3893 W; Specifikované výkonové zatížení: 66.8061 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00184949 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 9.85246 m3; Plocha: 4.77422 m2
Identifikační data - Číslo: A0104-1; Číslo místnosti: Neobsazené; Název: Úklid-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid-2 A0104-2:13315872, A0104-2
In: -1.PP_SO-101
LongName: Úklid-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; NetVolume: 9.85246 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.167098; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 51.3893 W; Specifikované výkonové zatížení: 66.8061 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00184949 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 9.85246 m3; Plocha: 4.77422 m2
Identifikační data - Číslo: A0104-2; Číslo místnosti: Neobsazené; Název: Úklid-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šablonárna-1 A0103-1:13315711, A0103-1
In: -1.PP_SO-101
LongName: Šablonárna-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 44.4444 m3; NetVolume: 44.4444 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 44.4444 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103-1; Číslo místnosti: Neobsazené; Název: Šablonárna-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šablonárna-2 A0103-2:13315826, A0103-2
In: -1.PP_SO-101
LongName: Šablonárna-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 44.4444 m3; NetVolume: 44.4444 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 44.4444 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103-2; Číslo místnosti: Neobsazené; Název: Šablonárna-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna - M A0111:13315728, A0111
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111; Číslo místnosti: Neobsazené; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - M A0115.1:13315762, A0115.1
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1; Číslo místnosti: Neobsazené; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0108:13315730, A0108
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108; Číslo místnosti: Neobsazené; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0114.1:13315761, A0114.1
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1; Číslo místnosti: Neobsazené; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-M A0111:13315843, A0111
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M A0114.1:13315876, A0114.1
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M A0115.1:13315877, A0115.1
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-Ž A0108:13315845, A0108
In: -1.PP_SO-101
LongName: Šatna-Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Výpočtová výška: 0 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108; Číslo místnosti: Neobsazené; Název: Šatna-Ž; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcBuildingElementProxy: Myčka ZTI:Standardní (2)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: SB02; Název typu: Standardní; Označení typu: 02; Popis sestavy: Myčka
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Myčka ZTI
Classification: SB02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.70296 m2; NetVolume: 0.294312 m3
Elektroinstalace – zatížení - Zdánlivé zatížení: 2200 W
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti,Sanitární,Napájení; Minimální hydrodynamický tlak: 0 Pa; Odpadní voda, přípoj, hodnota PU: 0 m3/s; Průběžný průtok studené vody: 0 m3/s; Průběžný průtok teplé vody: 0 m3/s; Výpočet průtoku studené vody: 0 m3/s; Výpočet průtoku teplé vody: 0 m3/s; Zvážit pro nejvyšší průtok: yes
Elektrotechnika - Napětí: 230 V
Kóty - Délka: 600 mm; Horká voda, poloměr: 6 mm; Objem: 0.294312 m3; Poloměr odpadní vody: 25 mm; Poloměr symbolu: 200 mm; Šířka: 600 mm; Studená voda, poloměr: 6 mm; Výška: 830 mm
Jiné - Typ: Standardní; Id typu: 13146337; Rodina: Myčka ZTI; Rodina a typ: Myčka ZTI: Standardní
Name (Myčka ZTI:Standardní:...) | In | Podlaží | Hostitel | Kód prvku | Název sestavy | Označení
13147142 | 2.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | SB02.02.0002 | Myčka 1 | 0002 | Mechanické - Název systému: WS_Studená vnitřní 2; Group: WS_Studená vnitřní 2
13192674 | 1.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | SB02.02.0003 | Myčka | 0003

# IfcBuildingElementProxy: Pračka ZTI:Standardní (2)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: SB01; Název typu: Standardní; Označení typu: 03; Popis sestavy: Pračka
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Pračka ZTI
Classification: SB01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.73156 m2; NetVolume: 0.299292 m3
Elektroinstalace – zatížení - Zdánlivé zatížení: 2200 W
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-101; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Zvážit pro nejvyšší průtok: yes; Klasifikace systému: Studená voda v domácnosti,Sanitární,Napájení; Minimální hydrodynamický tlak: 0 Pa; Odpadní voda, přípoj, hodnota PU: 0 m3/s; Průběžný průtok studené vody: 0 m3/s; Průběžný průtok teplé vody: 0 m3/s; Výpočet průtoku studené vody: 0 m3/s; Výpočet průtoku teplé vody: 0 m3/s
Elektrotechnika - Napětí: 230 V
Kóty - Délka: 610 mm; Horká voda, poloměr: 6 mm; Objem: 0.299292 m3; Poloměr odpadní vody: 25 mm; Poloměr symbolu: 200 mm; Šířka: 600 mm; Studená voda, poloměr: 6 mm; Výška: 830 mm
Identifikační data - Název sestavy: Výlevka nástěnnð
Jiné - Typ: Standardní; Id typu: 12842323; Rodina: Pračka ZTI; Rodina a typ: Pračka ZTI: Standardní
Name (Pračka ZTI:Standardní:...) | Název systému = Group | Kód prvku | Označení
13286940 | WS_Studená vnitřní 3 | SB01.03.0004 | 0004
13286954 | WS_Studená vnitřní 1 | SB01.03.0005 | 0005

# IfcBuildingElementProxy: Přečerpávací stanice SO101_01:Přečerpávací stanice SO101_01, Přečerpávací stanice SO101_01:Přečerpávací stanice SO101_01:13103228
In: -1.PP_SO-101
Type - Material: Plastic - Grundfos - White, Steel - Grundfos - Black
Type - Data - Minimum Operating Temperature: 0 C; Speed at the working points: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA
Type - Elektroinstalace - Enclosure Rating: 68; Frequency: 50 Hz; Full Load Amperes: 9 A; Load Classification: Other; Maximum Starting Current: 39 A; Motor_IP_Rating: 68; Motor Type: Asynchronous motor; Number of Poles: 1; Number of Poles Integer: 2; Phase: 1; PowerFactor: 0.93; Voltage: 230 V; Wattage: 1400 W
Type - Text - Profese: Kanalizace
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Connection Type: DIN flange; Flow: 0.0166667 m3/s; FluidTempMax: 40 C; FluidTempMin: 0 C; Head: 6724000 Pa; Klasifikace: Žádné; Maximum Operating Temperature: 40 C; Pump Type: Wastewater pump (macerator); RPM: 1430; Speed Type: Fixed; Suction Connection diameter: 110 mm
Type - Konstrukce - Gross Weight: 1.37293 kN
Type - Materiály a povrchové úpravy - Coupler Material: Steel - Grundfos - Black; Impeller Material: Luranyl; Material: Cast Iron; Pump Material: Steel - Grundfos - Black; Tank Material: Plastic - Grundfos - White
Type - Kóty - Jmenovitá velikost vstupu: 110 mm; Jmenovitá velikost výstupu: 110 mm
Type - Identifikační data - Approvals: CE, EAC, LGA; Author: Grundfos Holding A/S; Číslo OmniClass: 23.27.17.00; Copyright: Grundfos Holding A/S; Date Last Modified: August 1, 2017; Equipment Abbreviation: PMP; ID kategorie: PS.01; Kód sestavy: CO00; Komentáře k typům: PŘEČERPÁVACÍ ZAŘÍZENÍ; Manufacturer Website: http://www.grundfos.com; Model: MD.12.1.4; Model Disclaimer: For More Information, Contact Grundfos; Název typu: Přečerpávací stanice SO101_01; Označení typu: 01; Popis: Lifting stations for collecting and removing wastewater of inside buildings; Popis sestavy: Obecný prvek; ProductCode: MD.12.1.4; Product Literature: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA; Product Model Number: 97901084; Product Range: MD000; Uniclass2: Pr_65_53_96_50; URL: http://product-selection.grundfos.com/; Výrobce: Grundfos
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Přečerpávací stanice SO101_01
Classification: CO00 Uniformat (Uniformat); Group: SW_Splašky vnitřní gravitační 10; SW_Splašky vnitřní gravitační 81; SW_Splašky vnitřní gravitační 4; SW_Splašky vnitřní gravitační 8; SW_Splašky vnitřní gravitační 3; SW_Splašky čerpání 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.65383 m2; NetVolume: 0.212942 m3
Mechanické – tok - Průtok: 0.01 m3/s
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: -2085.88 mm; Výška od podlaží: -2085.88 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární,Nedefinovaný,Sanitární,Nedefinovaný,Sanitární,Nedefinovaný,Sanitární,Nedefinovaný,Sanitární,Napájení; Název systému: SW_Splašky čerpání 1,SW_Splašky vnitřní gravitační 3,SW_Splašky vnitřní gravitační 81,SW_Splašky vnitřní gravitační 8,SW_Splašky vnitřní gravitační 4
Grafika - Annotative Symbol Native Radius: 3.175 mm; Clearance Depth Back: 500 mm; Clearance Depth Front: 500 mm; Clearance Depth Left: 600 mm; Clearance Depth Right: 600 mm; Clearance Height: 600 mm; Has Clearance Areas: no; Show Annotative Symbol: no; Show Masking Regions: yes
Stavba - Rear Inlet Eccentric Disk Angle: 0 deg
Kóty - Objem: 0.209412 m3; Plocha: 9.10436 m2
Identifikační data - Kód prvku: CO00.01.0001; Označení: 0001; Part Description: Lifting stations for collecting and removing wastewater of inside buildings; Part Number: MD.12.1.4
Jiné - Páteřní trasa: yes; Id typu: 13103525; Rodina: Přečerpávací stanice SO101_01; Rodina a typ: Přečerpávací stanice SO101_01: Přečerpávací stanice SO101_01; Typ: Přečerpávací stanice SO101_01

# IfcDistributionPort (5006)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12834166_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12834169_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12834218_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12834221_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12834255_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12834258_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12834339_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12834342_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12834392_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12834395_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12837346_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12837349_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12872624_1 | SINK | PIPE | SEWAGE
OutPort_12872615_1 | SOURCE | PIPE | SEWAGE
InPort_12872616_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_12872618_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
OutPort_12872616_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_12872617_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
InPort_12872620_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
OutPort_12872617_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
InPort_12872622_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
OutPort_12872618_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_12872622_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
OutPort_12872620_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
Port_12872624_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12872650_1 | SINK | PIPE | SEWAGE
OutPort_12872641_1 | SOURCE | PIPE | SEWAGE
InPort_12872642_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_12872644_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
OutPort_12872642_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_12872643_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
InPort_12872646_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
OutPort_12872643_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
InPort_12872648_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
OutPort_12872644_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_12872648_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
OutPort_12872646_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
Port_12872650_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12872827_1 | SINK | PIPE | SEWAGE
OutPort_12872818_1 | SOURCE | PIPE | SEWAGE
InPort_12872819_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
InPort_12872821_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
OutPort_12872819_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
InPort_12872820_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
InPort_12872823_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
OutPort_12872820_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
InPort_12872825_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
OutPort_12872821_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
InPort_12872825_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
OutPort_12872823_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
Port_12872827_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12872860_1 | SINK | PIPE | SEWAGE
OutPort_12872851_1 | SOURCE | PIPE | SEWAGE
InPort_12872852_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
InPort_12872854_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
OutPort_12872852_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
InPort_12872853_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
InPort_12872856_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
OutPort_12872853_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
InPort_12872858_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
OutPort_12872854_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
InPort_12872858_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
OutPort_12872856_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
Port_12872860_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12873240_1 | SINK | PIPE | SEWAGE
OutPort_12873231_1 | SOURCE | PIPE | SEWAGE
InPort_12873232_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
InPort_12873234_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
OutPort_12873232_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
InPort_12873233_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
InPort_12873236_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
OutPort_12873233_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
InPort_12873238_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
OutPort_12873234_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
InPort_12873238_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
OutPort_12873236_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
Port_12873240_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12873274_1 | SINK | PIPE | SEWAGE
OutPort_12873265_1 | SOURCE | PIPE | SEWAGE
InPort_12873266_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_12873268_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
OutPort_12873266_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_12873267_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
InPort_12873270_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
OutPort_12873267_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
InPort_12873272_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
OutPort_12873268_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_12873272_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
OutPort_12873270_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
Port_12873274_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12878822_1 | SOURCE | PIPE | SEWAGE
InPort_12878823_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12878824_1 | SOURCE | PIPE | SEWAGE
Port_12878824_2 | SOURCEANDSINK | PIPE
OutPort_12879006_1 | SOURCE | PIPE | SEWAGE
InPort_12879007_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12879008_1 | SOURCE | PIPE | SEWAGE
Port_12879008_2 | SOURCEANDSINK | PIPE
OutPort_12879057_1 | SOURCE | PIPE | SEWAGE
InPort_12879058_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12879059_1 | SOURCE | PIPE | SEWAGE
Port_12879059_2 | SOURCEANDSINK | PIPE
InPort_12905772_1 | SINK | PIPE | SEWAGE
OutPort_12905763_1 | SOURCE | PIPE | SEWAGE
InPort_12905764_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_12905766_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
OutPort_12905764_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_12905765_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 137
InPort_12905768_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 137
OutPort_12905765_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 137
InPort_12905770_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
OutPort_12905766_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_12905770_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 137
OutPort_12905768_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 137
Port_12905772_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12906120_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12906123_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12906128_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12906131_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12906387_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12906390_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12906444_1 | SINK | PIPE | SEWAGE
OutPort_12906435_1 | SOURCE | PIPE | SEWAGE
InPort_12906436_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 146
InPort_12906438_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 146
OutPort_12906436_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 146
InPort_12906437_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
InPort_12906440_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
OutPort_12906437_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
InPort_12906442_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 146
OutPort_12906438_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 146
InPort_12906442_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
OutPort_12906440_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
Port_12906444_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12906990_1 | SINK | PIPE | SEWAGE
OutPort_12906981_1 | SOURCE | PIPE | SEWAGE
InPort_12906982_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13060089_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_12906984_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_12906982_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_12906983_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13060006_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_12906986_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_12906983_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_12906988_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_12906984_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_12906988_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_12906986_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_12906990_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907049_1 | SINK | PIPE | SEWAGE
OutPort_12907040_1 | SOURCE | PIPE | SEWAGE
InPort_12907041_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 156
InPort_12907043_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 156
OutPort_12907041_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 156
InPort_12907042_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 152
InPort_12907045_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 152
OutPort_12907042_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 152
InPort_12907047_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 156
OutPort_12907043_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 156
InPort_12907047_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 152
OutPort_12907045_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 152
Port_12907049_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907116_1 | SINK | PIPE | SEWAGE
OutPort_12907107_1 | SOURCE | PIPE | SEWAGE
InPort_12907108_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 157
InPort_12907110_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 157
OutPort_12907108_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 157
InPort_12907109_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 153
InPort_12907112_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 153
OutPort_12907109_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 153
InPort_12907114_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 157
OutPort_12907110_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 157
InPort_12907114_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 153
OutPort_12907112_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 153
Port_12907116_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907140_1 | SINK | PIPE | SEWAGE
OutPort_12907131_1 | SOURCE | PIPE | SEWAGE
InPort_12907132_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 158
InPort_12907134_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 158
OutPort_12907132_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 158
InPort_12907133_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 154
InPort_12907136_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 154
OutPort_12907133_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 154
InPort_12907138_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 158
OutPort_12907134_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 158
InPort_12907138_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 154
OutPort_12907136_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 154
Port_12907140_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907380_1 | SINK | PIPE | SEWAGE
OutPort_12907371_1 | SOURCE | PIPE | SEWAGE
InPort_12907372_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 160
InPort_12907374_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 160
OutPort_12907372_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 160
InPort_12907373_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 156
InPort_12907376_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 156
OutPort_12907373_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 156
InPort_12907378_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 160
OutPort_12907374_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 160
InPort_12907378_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 156
OutPort_12907376_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 156
Port_12907380_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907452_1 | SINK | PIPE | SEWAGE
OutPort_12907443_1 | SOURCE | PIPE | SEWAGE
InPort_12907444_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 161
InPort_12907446_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 161
OutPort_12907444_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 161
InPort_12907445_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 157
InPort_12907448_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 157
OutPort_12907445_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 157
InPort_12907450_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 161
OutPort_12907446_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 161
InPort_12907450_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 157
OutPort_12907448_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 157
Port_12907452_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907475_1 | SINK | PIPE | SEWAGE
OutPort_12907466_1 | SOURCE | PIPE | SEWAGE
InPort_12907467_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 162
InPort_12907469_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 162
OutPort_12907467_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 162
InPort_12907468_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 158
InPort_12907471_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 158
OutPort_12907468_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 158
InPort_12907473_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 162
OutPort_12907469_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 162
InPort_12907473_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 158
OutPort_12907471_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 158
Port_12907475_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907560_1 | SINK | PIPE | SEWAGE
OutPort_12907551_1 | SOURCE | PIPE | SEWAGE
InPort_12907552_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 163
InPort_12907554_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 163
OutPort_12907552_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 163
InPort_12907553_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 159
InPort_12907556_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 159
OutPort_12907553_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 159
InPort_12907558_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 163
OutPort_12907554_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 163
InPort_12907558_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 159
OutPort_12907556_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 159
Port_12907560_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907584_1 | SINK | PIPE | SEWAGE
OutPort_12907575_1 | SOURCE | PIPE | SEWAGE
InPort_12907576_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 164
InPort_12907578_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 164
OutPort_12907576_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 164
InPort_12907577_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 160
InPort_12907580_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 160
OutPort_12907577_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 160
InPort_12907582_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 164
OutPort_12907578_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 164
InPort_12907582_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 160
OutPort_12907580_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 160
Port_12907584_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12907664_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907667_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12907722_1 | SINK | PIPE | SEWAGE
OutPort_12907713_1 | SOURCE | PIPE | SEWAGE
InPort_12907714_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 165
InPort_12907716_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 165
OutPort_12907714_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 165
InPort_12907715_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 161
InPort_12907718_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 161
OutPort_12907715_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 161
InPort_12907720_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 165
OutPort_12907716_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 165
InPort_12907720_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 161
OutPort_12907718_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 161
Port_12907722_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12907788_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12907791_1 | SINK | PIPE | DOMESTICCOLDWATER
