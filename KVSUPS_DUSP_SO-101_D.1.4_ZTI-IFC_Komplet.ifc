Properties of the parts of a building model (IFC4), part 9 of 26

# IfcDistributionPort (5006)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13125747_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125797_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125795_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125797_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125795_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125810_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125818_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125810_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125830_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125818_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125819_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125818_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125992_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125819_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125960_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125824_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125830_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125824_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190176_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125901_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190168_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125901_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125952_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125960_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125952_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219153_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125960_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125961_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125961_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126164_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125966_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219153_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125966_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219192_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125983_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125991_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125983_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126038_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125991_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13125992_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126036_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126038_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126036_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126181_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126189_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126181_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126199_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126189_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126190_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126193_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126199_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126193_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126209_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126203_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126209_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126203_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207401_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126228_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207397_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13126228_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207401_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13126323_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126315_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126315_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126335_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13126323_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13126324_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13126323_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234766_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13126324_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235833_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126335_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126329_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126329_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126427_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126395_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126423_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126427_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126395_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126423_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126467_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13126467_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126515_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13127575_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13128512_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13127575_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13231465_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13128468_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13127591_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13127591_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13262449_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13127617_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231483_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127617_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128460_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127637_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13128452_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13127859_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127863_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127859_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127865_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127859_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127895_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127860_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127860_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127865_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127883_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127894_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127883_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128464_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127894_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127895_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128095_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128460_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128095_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128464_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13128194_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13128400_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13128194_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13128512_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13128270_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13128468_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13128472_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13128270_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13128308_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13128452_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13128308_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13128456_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13129170_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13431635_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431637_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129170_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129556_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13431637_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129795_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129556_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129779_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129694_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129694_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129761_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129761_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13132585_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431435_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129779_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13129795_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13133962_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13129795_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134104_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135836_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13129810_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13129810_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135797_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432981_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13130710_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205204_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13130733_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273394_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13130760_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13130760_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13130819_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13131534_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13131689_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273543_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13131534_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13131667_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13131685_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13131689_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13131667_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13131685_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273395_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13235293_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13132190_0 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 3
InPort_13132408_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13132190_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13132292_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13132408_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13132432_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13132292_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13132419_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13132432_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13430357_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13132419_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13291192_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 1
OutPort_13132484_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13132484_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13291651_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13132585_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13132587_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133739_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133755_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133766_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133739_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133760_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133766_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133780_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133760_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133904_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133780_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133973_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133904_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13133961_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278511_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13133961_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13133962_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133961_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133973_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134060_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281521_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134148_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134060_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134160_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134095_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134095_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134148_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134103_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134104_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134103_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216226_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134103_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134160_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432372_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134166_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134614_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134852_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134614_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134726_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134680_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135952_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134680_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135836_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134680_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134726_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134782_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134827_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134852_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134782_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134852_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135054_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134969_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135058_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13134969_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135062_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135054_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135062_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135062_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135684_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135464_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135472_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135464_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135498_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135490_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135498_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135490_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135509_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135503_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135509_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135503_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135601_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135601_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135692_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135643_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135687_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135691_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135643_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135684_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135691_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135691_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135692_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135740_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135749_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135760_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135740_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135749_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13280393_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135754_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135760_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135777_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135754_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135765_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135777_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135787_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135765_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135781_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135787_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135797_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13135781_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135952_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216225_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13136325_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13261789_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13136351_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13236538_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13236542_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13136351_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13236538_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13136422_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13136480_1 | SINK | PIPE | SEWAGE
OutPort_13136471_1 | SOURCE | PIPE | SEWAGE
InPort_13136472_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13234179_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13136474_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13136472_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13136473_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13234172_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13136476_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13136473_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13136478_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13136474_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13136478_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13136476_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13136480_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13136635_1 | SOURCE | PIPE | SEWAGE
InPort_13136637_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13142662_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_13142664_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
OutPort_13142662_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_13142663_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13142666_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
OutPort_13142663_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13142707_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
OutPort_13142664_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_13142707_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
OutPort_13142666_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13142671_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13142671_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13142691_1 | SOURCE | PIPE | SEWAGE
InPort_13144904_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
InPort_13144914_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
OutPort_13144904_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
InPort_13144905_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
InPort_13144912_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
OutPort_13144905_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
Port_13144906_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13144907_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13144906_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13144909_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
OutPort_13144914_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
InPort_13144909_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
OutPort_13144912_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
InPort_13147142_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
OutPort_13145247_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
InPort_13145247_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
OutPort_13147142_3 | SOURCE | PIPE | SEWAGE
Port_13147142_4 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_13147143_1 | SOURCEANDSINK | PIPE
Port_13147143_2 | SOURCEANDSINK | PIPE
Port_13147144_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 7
Port_13147144_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 7
OutPort_13147148_1 | SOURCE | PIPE | SEWAGE
Port_13148627_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148638_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148627_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148638_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148639_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148638_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148646_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148664_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148675_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148664_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148675_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148676_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148675_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148683_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148676_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242383_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148822_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13148920_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13148822_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13148904_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164640_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13148904_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156694_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13148920_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158789_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156518_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156518_2 | SINK | PIPE | FIREPROTECTION
InPort_13156518_4 | SINK | PIPE | FIREPROTECTION
InPort_13156518_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13161811_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156518_7 | SINK | PIPE | FIREPROTECTION
InPort_13156518_8 | SINK | PIPE | FIREPROTECTION
Port_13156665_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161835_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156665_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156694_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156687_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156689_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156687_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161825_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13156689_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161835_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156994_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156994_2 | SINK | PIPE | FIREPROTECTION
InPort_13156994_4 | SINK | PIPE | FIREPROTECTION
InPort_13156994_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13164569_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13156994_7 | SINK | PIPE | FIREPROTECTION
InPort_13156994_8 | SINK | PIPE | FIREPROTECTION
Port_13157605_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13234021_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13157605_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173592_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13158784_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158788_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158784_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158792_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158785_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158792_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158785_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160550_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158788_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164640_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158788_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158789_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158860_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381902_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158860_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381906_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158918_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383141_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13158918_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383025_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159333_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373955_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159333_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374796_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159456_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13234039_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159456_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373903_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159646_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160550_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159646_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381906_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159824_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381089_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13159824_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381091_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160077_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381089_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160077_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160489_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160152_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160489_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160152_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160491_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160384_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160491_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13160384_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161467_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161392_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161467_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161392_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161586_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161560_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161586_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161560_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164569_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161811_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13161825_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13162180_1 | SINK | PIPE | FIREPROTECTION
InPort_13162180_2 | SINK | PIPE | FIREPROTECTION
InPort_13162180_4 | SINK | PIPE | FIREPROTECTION
InPort_13162180_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13162474_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13162180_7 | SINK | PIPE | FIREPROTECTION
InPort_13162180_8 | SINK | PIPE | FIREPROTECTION
Port_13162357_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377093_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162357_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377097_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162387_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377091_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162387_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162407_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162399_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162407_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162399_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162419_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162409_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162419_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162409_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162427_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162421_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162427_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162421_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162788_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162451_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162474_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162451_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162786_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162763_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162786_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162763_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13162788_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13163107_1 | SINK | PIPE | FIREPROTECTION
InPort_13163107_2 | SINK | PIPE | FIREPROTECTION
InPort_13163107_4 | SINK | PIPE | FIREPROTECTION
InPort_13163107_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13163589_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13163107_7 | SINK | PIPE | FIREPROTECTION
InPort_13163107_8 | SINK | PIPE | FIREPROTECTION
Port_13163312_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373955_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163312_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163338_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163329_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163338_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163329_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428514_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163355_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434974_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163355_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163737_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163363_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435173_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163363_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435175_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163373_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435173_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163373_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163513_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163460_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163589_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163460_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163591_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163511_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163513_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163511_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163591_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163717_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164494_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163717_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163760_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163729_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164494_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163729_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164501_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163729_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163737_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163730_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428506_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163730_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164501_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163750_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428887_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163750_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428891_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13163760_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428823_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13163838_1 | SINK | PIPE | FIREPROTECTION
InPort_13163838_2 | SINK | PIPE | FIREPROTECTION
InPort_13163838_4 | SINK | PIPE | FIREPROTECTION
InPort_13163838_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13164491_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13163838_7 | SINK | PIPE | FIREPROTECTION
InPort_13163838_8 | SINK | PIPE | FIREPROTECTION
Port_13164109_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428887_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164109_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164304_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164294_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164304_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164294_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164318_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164308_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164318_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164308_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164326_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164320_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164326_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164320_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164336_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164328_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164336_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164328_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164437_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164360_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164487_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164360_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164491_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164435_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164437_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164435_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13164487_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13173353_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199751_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13198774_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13173552_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13173552_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13198776_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173592_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13229780_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173592_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13383650_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173593_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382881_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173593_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13229780_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173683_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173695_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173683_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173753_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173695_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385268_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173745_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173753_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13173745_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199714_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13190377_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13189892_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13287623_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13189962_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13216873_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13190002_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13190133_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190176_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190133_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190168_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190176_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190189_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190189_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190253_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190253_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190240_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190240_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190318_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190318_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190257_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190257_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190381_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190356_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190377_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13190381_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13190356_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13190583_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190677_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190583_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190661_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190673_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190673_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190677_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190675_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190675_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190679_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190677_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190681_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190677_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190679_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190702_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190702_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190708_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190704_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190706_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190706_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190710_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190706_4 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190708_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191502_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191504_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191502_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192056_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191607_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191609_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191607_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192148_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191719_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191728_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191719_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191728_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191729_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191728_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192002_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191729_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191746_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191753_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191746_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191753_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191754_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191753_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192081_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191754_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191767_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192628_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191767_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13191906_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192649_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191906_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191993_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192068_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13191993_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192002_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192649_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192056_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192211_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192064_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192210_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192064_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192068_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192066_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192066_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192068_4 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192068_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192650_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192072_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192160_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192072_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192081_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192628_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192148_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192172_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192156_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192171_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192156_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192160_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192158_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192158_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192160_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192160_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192629_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192163_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192171_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192163_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192171_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192172_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192202_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192210_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192202_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192210_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192211_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192261_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264345_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192261_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192273_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13192350_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_13192359_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
OutPort_13192350_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_13192351_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
InPort_13192357_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
OutPort_13192351_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
Port_13192352_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192353_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192352_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192355_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
OutPort_13192359_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_13192355_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
OutPort_13192357_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
InPort_13192373_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13192382_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
OutPort_13192373_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13192374_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
InPort_13192380_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
OutPort_13192374_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
Port_13192375_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192376_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192375_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192378_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
OutPort_13192382_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13192378_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
OutPort_13192380_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
InPort_13192399_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
