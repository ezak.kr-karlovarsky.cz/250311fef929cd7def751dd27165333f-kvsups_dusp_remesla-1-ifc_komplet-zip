Properties of the parts of a building model (IFC4), part 6 of 26

# IfcDistributionPort (5006)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_12907820_1 | SOURCE | PIPE | SEWAGE
InPort_12907821_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12907822_1 | SOURCE | PIPE | SEWAGE
Port_12907822_2 | SOURCEANDSINK | PIPE
InPort_12907984_1 | SINK | PIPE | SEWAGE
OutPort_12907975_1 | SOURCE | PIPE | SEWAGE
InPort_12907976_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 167
InPort_12907978_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 167
OutPort_12907976_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 167
InPort_12907977_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 163
InPort_12907980_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 163
OutPort_12907977_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 163
InPort_12907982_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 167
OutPort_12907978_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 167
InPort_12907982_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 163
OutPort_12907980_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 163
Port_12907984_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908043_1 | SINK | PIPE | SEWAGE
OutPort_12908034_1 | SOURCE | PIPE | SEWAGE
InPort_12908035_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 168
InPort_12908037_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 168
OutPort_12908035_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 168
InPort_12908036_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 164
InPort_12908039_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 164
OutPort_12908036_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 164
InPort_12908041_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 168
OutPort_12908037_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 168
InPort_12908041_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 164
OutPort_12908039_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 164
Port_12908043_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908067_1 | SINK | PIPE | SEWAGE
OutPort_12908058_1 | SOURCE | PIPE | SEWAGE
InPort_12908059_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 169
InPort_12908061_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 169
OutPort_12908059_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 169
InPort_12908060_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 165
InPort_12908063_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 165
OutPort_12908060_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 165
InPort_12908065_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 169
OutPort_12908061_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 169
InPort_12908065_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 165
OutPort_12908063_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 165
Port_12908067_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908150_1 | SINK | PIPE | SEWAGE
OutPort_12908141_1 | SOURCE | PIPE | SEWAGE
InPort_12908142_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 170
InPort_12908144_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 170
OutPort_12908142_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 170
InPort_12908143_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 166
InPort_12908146_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 166
OutPort_12908143_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 166
InPort_12908148_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 170
OutPort_12908144_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 170
InPort_12908148_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 166
OutPort_12908146_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 166
Port_12908150_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908174_1 | SINK | PIPE | SEWAGE
OutPort_12908165_1 | SOURCE | PIPE | SEWAGE
InPort_12908166_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 171
InPort_12908168_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 171
OutPort_12908166_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 171
InPort_12908167_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 167
InPort_12908170_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 167
OutPort_12908167_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 167
InPort_12908172_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 171
OutPort_12908168_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 171
InPort_12908172_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 167
OutPort_12908170_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 167
Port_12908174_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908269_1 | SINK | PIPE | SEWAGE
OutPort_12908260_1 | SOURCE | PIPE | SEWAGE
InPort_12908261_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 172
InPort_12908263_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 172
OutPort_12908261_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 172
InPort_12908262_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 168
InPort_12908265_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 168
OutPort_12908262_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 168
InPort_12908267_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 172
OutPort_12908263_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 172
InPort_12908267_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 168
OutPort_12908265_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 168
Port_12908269_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908339_1 | SINK | PIPE | SEWAGE
OutPort_12908330_1 | SOURCE | PIPE | SEWAGE
InPort_12908331_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 173
InPort_12908333_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 173
OutPort_12908331_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 173
InPort_12908332_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 169
InPort_12908335_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 169
OutPort_12908332_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 169
InPort_12908337_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 173
OutPort_12908333_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 173
InPort_12908337_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 169
OutPort_12908335_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 169
Port_12908339_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908461_1 | SINK | PIPE | SEWAGE
OutPort_12908452_1 | SOURCE | PIPE | SEWAGE
InPort_12908453_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 174
InPort_12908455_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 174
OutPort_12908453_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 174
InPort_12908454_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 170
InPort_12908457_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 170
OutPort_12908454_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 170
InPort_12908459_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 174
OutPort_12908455_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 174
InPort_12908459_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 170
OutPort_12908457_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 170
Port_12908461_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908595_1 | SINK | PIPE | SEWAGE
OutPort_12908586_1 | SOURCE | PIPE | SEWAGE
InPort_12908587_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 176
InPort_12908589_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 176
OutPort_12908587_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 176
InPort_12908588_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 172
InPort_12908591_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 172
OutPort_12908588_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 172
InPort_12908593_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 176
OutPort_12908589_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 176
InPort_12908593_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 172
OutPort_12908591_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 172
Port_12908595_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12908657_1 | SOURCE | PIPE | SEWAGE
InPort_12908658_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12908659_1 | SOURCE | PIPE | SEWAGE
Port_12908659_2 | SOURCEANDSINK | PIPE
Port_12908714_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908717_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12908722_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12908725_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12908786_1 | SINK | PIPE | SEWAGE
OutPort_12908777_1 | SOURCE | PIPE | SEWAGE
InPort_12908778_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 175
InPort_12908780_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 175
OutPort_12908778_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 175
InPort_12908779_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 171
InPort_12908782_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 171
OutPort_12908779_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 171
InPort_12908784_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 175
OutPort_12908780_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 175
InPort_12908784_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 171
OutPort_12908782_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 171
Port_12908786_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12908849_1 | SOURCE | PIPE | SEWAGE
InPort_12908851_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12908851_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13274003_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912020_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912020_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274510_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912046_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 2
OutPort_13132587_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 2
InPort_13134242_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 2
OutPort_12912046_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 2
InPort_12912057_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13134957_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13135687_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912057_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13133755_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912070_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912070_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13133990_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912758_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13276216_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275981_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912758_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205198_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912775_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912775_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275790_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275635_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12912805_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12912805_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275779_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912861_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217823_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912861_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912907_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135058_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912907_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912922_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13135472_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12912922_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13134827_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12913160_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12913160_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13145177_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12913177_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13217579_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13280987_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12913177_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12913723_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429982_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_12913723_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13126515_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_12914629_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_12914629_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
OutPort_13126567_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_12915234_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13163986_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_12915234_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428996_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13163938_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_12915236_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_12915236_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428961_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_12915456_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383029_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13381307_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_12915456_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_12915507_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13375525_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_12915507_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13374570_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_12915511_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374685_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12915511_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374578_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12915513_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13055545_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_12915513_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374554_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_12924362_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13291428_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_12924368_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 10
OutPort_12924362_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_12924364_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12924366_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13438430_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12924364_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13291386_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_12924366_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 10
InPort_13234222_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12924406_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12924406_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279375_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12924431_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279387_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288964_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_12924431_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_12933659_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12933659_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12933659_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12933660_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_12933661_1 | SOURCE | PIPE | SEWAGE
InPort_12933722_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12933722_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12933722_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12933723_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_12933724_1 | SOURCE | PIPE | SEWAGE
InPort_12933781_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12933781_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12933781_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12933782_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_12933783_1 | SOURCE | PIPE | SEWAGE
InPort_12933810_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12933810_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12933810_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12933811_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_12933812_1 | SOURCE | PIPE | SEWAGE
InPort_12933839_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12933839_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12933839_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12933840_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_12933841_1 | SOURCE | PIPE | SEWAGE
Port_12944783_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12944786_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12944905_1 | SINK | PIPE | SEWAGE
OutPort_12944896_1 | SOURCE | PIPE | SEWAGE
InPort_12944897_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_12944899_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
OutPort_12944897_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_12944898_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
InPort_12944901_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
OutPort_12944898_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
InPort_12944903_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
OutPort_12944899_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_12944903_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
OutPort_12944901_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
Port_12944905_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12944929_1 | SINK | PIPE | SEWAGE
OutPort_12944920_1 | SOURCE | PIPE | SEWAGE
InPort_12944921_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_12944923_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
OutPort_12944921_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_12944922_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
InPort_12944925_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
OutPort_12944922_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
InPort_12944927_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
OutPort_12944923_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_12944927_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
OutPort_12944925_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
Port_12944929_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13048475_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148639_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13048475_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052057_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13048821_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13048839_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13048821_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13048839_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051756_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13262447_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13048975_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13048975_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13049179_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148673_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049179_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148683_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049191_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13148673_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049191_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049207_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049201_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049207_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049201_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13049307_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148636_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049307_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148646_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049319_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13148636_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049319_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049335_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049329_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049335_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049329_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049878_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050307_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13049878_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050328_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050046_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050307_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050046_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050216_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050070_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127912_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050070_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050077_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127912_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050077_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050078_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13050077_3 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13065489_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050078_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127894_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050211_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262849_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050211_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050216_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262849_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050216_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262851_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050217_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050217_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262851_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050244_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13127863_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050244_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050267_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050275_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050267_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050275_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051075_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050307_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052028_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050320_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050328_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050320_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050330_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050338_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050330_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050352_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13065853_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050352_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264963_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050361_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190706_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050361_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050426_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13190710_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050426_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050440_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13065837_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050440_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231390_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050564_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13190681_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050564_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050620_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051455_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050620_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052274_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050620_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231390_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050681_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13065201_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050681_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051458_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13050767_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13065123_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050767_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13063986_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13050938_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13065026_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050938_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051393_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050947_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051233_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13050947_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051152_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051075_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13128456_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051144_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051152_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051166_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13064982_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051166_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051233_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067630_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051233_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13064982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051361_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067615_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051361_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051366_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067615_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051366_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067617_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051366_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051367_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051367_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067617_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051386_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067689_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051389_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067695_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051389_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051669_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051389_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13065038_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051393_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067689_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051393_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051394_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067630_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051454_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231483_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051454_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051455_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051454_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13065211_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051458_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262225_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051458_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262227_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051459_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262227_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051459_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13051519_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13065785_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051519_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067773_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051528_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051593_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051528_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199847_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051588_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439105_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051588_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051593_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439097_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051593_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051594_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051594_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051634_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051602_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067751_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051602_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051634_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067749_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051634_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067751_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051635_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051635_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067749_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051669_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051674_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051674_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051748_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051674_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067773_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051683_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051829_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051683_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13164664_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051692_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051753_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051692_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051748_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13164662_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051753_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051924_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051755_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13164662_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051755_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051756_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051755_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13164664_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051795_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13157337_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051795_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051829_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13063868_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051829_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13157337_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051848_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051921_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051848_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051923_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051857_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051921_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051857_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051875_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051869_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051875_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051869_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051923_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13067581_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051923_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051924_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13051941_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052385_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13051941_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052398_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052028_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13128400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052056_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264874_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052056_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052057_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052056_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262371_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052070_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262905_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052070_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052094_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052082_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052094_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052104_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052096_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052104_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052096_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052106_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052112_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052106_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052164_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052277_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052164_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052180_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052172_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052180_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052172_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052188_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052182_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052188_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052182_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052274_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242385_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052277_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052447_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052288_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262887_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052288_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052465_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052385_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262905_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052385_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262907_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052386_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13065974_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262907_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052390_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052398_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052390_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052406_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052400_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052406_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052418_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052408_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052418_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052408_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13052446_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262883_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052446_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262885_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052446_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262887_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052447_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262885_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052457_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052465_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052457_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052473_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052467_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052473_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052467_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052483_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052475_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052483_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13052475_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13231854_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053052_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053052_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13231856_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13231856_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053241_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053241_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053264_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053264_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053255_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053255_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053276_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053276_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053266_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053266_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13094102_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13072581_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053278_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053278_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13067310_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053338_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13072325_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053939_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053345_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053346_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13067310_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13053345_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053346_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053421_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13163986_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053421_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054558_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053443_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053449_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053443_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053472_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053449_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054521_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053451_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053472_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053451_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053480_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053474_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13309379_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053474_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053492_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053480_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13309381_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053482_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053578_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053492_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053579_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053533_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053586_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053533_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053578_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054538_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053578_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053586_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053579_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054538_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13053599_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054217_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053599_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054550_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053621_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053627_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053621_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053637_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053627_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054222_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053629_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053637_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053629_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053645_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053639_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13070040_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053639_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13072292_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053645_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13070042_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13053667_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13072333_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053667_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13053939_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13072325_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13053975_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13163938_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13058246_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13053975_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054025_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054038_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054025_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428922_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054038_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054039_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13058246_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13054038_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054039_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054217_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054082_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054094_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054082_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054104_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054094_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054214_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054096_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13262076_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054096_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054193_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054104_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13072661_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054185_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054193_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054185_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054214_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054532_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054221_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054532_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054221_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054536_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054221_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054550_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054222_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054536_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13054255_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054265_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054255_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054277_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054265_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054513_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054267_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13054344_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
