Properties of the parts of a building model (IFC4), part 22 of 26

# IfcPipeSegment: Typy trubek:PP-RCT (581)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Reynoldsovo číslo = Třecí faktor = Tření = Doplňkový průtok (m3/s) = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13061448 | 1.NP_SO-101 | 9946.03 | 0.000804127 | 0.999883 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3387.6 | PP–RCT S4 | 32 | 116 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9946.03 | ø32 | 24.8 | TR10.02.0296 | 0296 | yes | WS_Teplá vnitřní 155 | 0
13061456 | 1.NP_SO-101 | 6846.03 | 0.000804127 | 0.688237 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3387.6 | PP–RCT S4 | 32 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6846.03 | ø32 | 24.8 | TR10.02.0297 | 0297 | yes | WS_Teplá vnitřní 155 | 0
13061470 | 1.NP_SO-101 | 884.925 | 0.000804127 | 0.0889623 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3387.6 | PP–RCT S4 | 32 | 116 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 884.925 | ø32 | 24.8 | TR10.02.0298 | 0298 | no | WS_Teplá vnitřní 155 | 0
13061480 | 1.NP_SO-101 | 1232.2 | 0.0019632 | 0.193553 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3380.6 | PP–RCT S4 | 50 | 92 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1232.2 | ø50 | 38.8 | TR10.02.0299 | 0299 | no | WS_Teplá vnitřní 155 | 0
13061488 | 1.NP_SO-101 | 960.312 | 0.0019632 | 0.150846 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3380.6 | PP–RCT S4 | 50 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 960.312 | ø50 | 38.8 | TR10.02.0300 | 0300 | no | WS_Teplá vnitřní 155 | 0
13061544 | 1.NP_SO-101 | 1163.01 | 0.000804127 | 0.116918 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3387.6 | PP–RCT S4 | 32 | 116 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1163.01 | ø32 | 24.8 | TR10.02.0301 | 0301 | no | WS_Teplá vnitřní 155 | 0
13061582 | 1.NP_SO-101 | 3287.61 | 0.000804127 | 0.330506 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3244.84 | -42.7701 | 3244.84 | -42.7701 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -42.7701 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3287.61 | ø32 | 24.8 | TR10.02.0302 | 0302 | yes | WS_Cirkulace vnitřní 2
13061590 | 1.NP_SO-101 | 615.99 | 0.0004908 | 0.0483797 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3390.3 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 615.99 | ø25 | 19.4 | TR10.02.0303 | 0303 | yes | WS_Cirkulace vnitřní 2 | 0
13061598 | 1.NP_SO-101 | 2926.58 | 0.0004908 | 0.229853 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3390.3 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2926.58 | ø25 | 19.4 | TR10.02.0304 | 0304 | yes | WS_Cirkulace vnitřní 2 | 0
13061608 | 1.NP_SO-101 | 6846.82 | 0.0004908 | 0.537748 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3390.3 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6846.82 | ø25 | 19.4 | TR10.02.0305 | 0305 | yes | WS_Cirkulace vnitřní 2 | 0
13061618 | 1.NP_SO-101 | 12410 | 0.000314112 | 0.779743 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3392.3 | PP–RCT S4 | 20 | 32 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 12410 | ø20 | 15.4 | TR10.02.0306 | 0306 | yes | WS_Cirkulace vnitřní 2 | 0
13061696 | 1.NP_SO-101 | 28.4062 | 0.000314112 | 0.00178482 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 28.4062 | ø20 | 15.4 | TR10.02.0307 | 0307 | no | WS_Teplá vnitřní 155 | 0
13061729 | 1.NP_SO-101 | 720.64 | 0.00125645 | 0.0905583 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3384.5 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 720.64 | ø40 | 31 | TR10.02.0308 | 0308 | yes | WS_Studená vnitřní 151 | 0
13061737 | 1.NP_SO-101 | 2927.53 | 0.00125645 | 0.367885 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3384.5 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2927.53 | ø40 | 31 | TR10.02.0309 | 0309 | yes | WS_Studená vnitřní 151 | 0
13061831 | 1.NP_SO-101 | 2940.23 | 0.000804127 | 0.295584 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2940.23 | ø32 | 24.8 | TR10.02.0310 | 0310 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13061841 | 1.NP_SO-101 | 6852.38 | 0.000804127 | 0.688876 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6852.38 | ø32 | 24.8 | TR10.02.0311 | 0311 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13061925 | 1.NP_SO-101 | 10232.5 | 0.000804127 | 1.02869 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3387.6 | PP–RCT S4 | 32 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10232.5 | ø32 | 24.8 | TR10.02.0312 | 0312 | yes | WS_Studená vnitřní 151 | 0
13061931 | 1.NP_SO-101 | 6832.53 | 0.000804127 | 0.686881 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3387.6 | PP–RCT S4 | 32 | 113 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6832.53 | ø32 | 24.8 | TR10.02.0313 | 0313 | yes | WS_Studená vnitřní 151 | 0
13061945 | 1.NP_SO-101 | 952.375 | 0.000804127 | 0.0957432 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3387.6 | PP–RCT S4 | 32 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 952.375 | ø32 | 24.8 | TR10.02.0314 | 0314 | no | WS_Studená vnitřní 151 | 0
13061955 | 1.NP_SO-101 | 1137.3 | 0.0019632 | 0.178647 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3380.6 | PP–RCT S4 | 50 | 92 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1137.3 | ø50 | 38.8 | TR10.02.0315 | 0315 | no | WS_Studená vnitřní 151 | 0
13061971 | 1.NP_SO-101 | 1006.82 | 0.0004908 | 0.0790754 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1006.82 | ø25 | 19.4 | TR10.02.0316 | 0316 | no | WS_Studená vnitřní 151 | 0
13062023 | 1.NP_SO-101 | 1117.9 | 0.000804127 | 0.112384 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3387.6 | PP–RCT S4 | 32 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1117.9 | ø32 | 24.8 | TR10.02.0317 | 0317 | no | WS_Studená vnitřní 151 | 0
13062058 | 1.NP_SO-101 | 962.791 | 0.000804127 | 0.0967903 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 962.791 | ø32 | 24.8 | TR10.02.0318 | 0318 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062072 | 1.NP_SO-101 | 72.375 | 0.000804127 | 0.00727593 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.375 | ø32 | 24.8 | TR10.02.0319 | 0319 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062084 | 1.NP_SO-101 | 314.706 | 0.000804127 | 0.0316377 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 314.706 | ø32 | 24.8 | TR10.02.0320 | 0320 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062092 | 1.NP_SO-101 | 3412.38 | 0.000804127 | 0.343049 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3412.38 | ø32 | 24.8 | TR10.02.0321 | 0321 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062102 | 1.NP_SO-101 | 397.375 | 0.000804127 | 0.0399485 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 397.375 | ø32 | 24.8 | TR10.02.0322 | 0322 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062110 | 1.NP_SO-101 | 1472.38 | 0.000804127 | 0.148019 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1472.38 | ø32 | 24.8 | TR10.02.0323 | 0323 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13062136 | 1.NP_SO-101 | 849.356 | 0.000314112 | 0.0533666 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 849.356 | ø20 | 15.4 | TR10.02.0324 | 0324 | no | WS_Studená vnitřní 151 | 0
13062145 | 1.NP_SO-101 | 393.735 | 0.000314112 | 0.0247391 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 393.735 | ø20 | 15.4 | TR10.02.0325 | 0325 | no | WS_Studená vnitřní 151 | 0
13062205 | 1.NP_SO-101 | 1720.21 | 0.0004908 | 0.135105 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1720.21 | ø25 | 19.4 | TR10.02.0326 | 0326 | no | WS_Studená vnitřní 151 | 0
13062211 | 1.NP_SO-101 | 672.792 | 0.0004908 | 0.052841 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 672.792 | ø25 | 19.4 | TR10.02.0327 | 0327 | no | WS_Studená vnitřní 151 | 0
13062219 | 1.NP_SO-101 | 988.406 | 0.000314112 | 0.0621034 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 988.406 | ø20 | 15.4 | TR10.02.0328 | 0328 | no | WS_Teplá vnitřní 155 | 0
13062228 | 1.NP_SO-101 | 497.552 | 0.000314112 | 0.0312621 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 497.552 | ø20 | 15.4 | TR10.02.0329 | 0329 | no | WS_Teplá vnitřní 155 | 0
13062288 | 1.NP_SO-101 | 1662.58 | 0.0004908 | 0.130579 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1662.58 | ø25 | 19.4 | TR10.02.0330 | 0330 | no | WS_Teplá vnitřní 155 | 0
13062294 | 1.NP_SO-101 | 636.453 | 0.0004908 | 0.0499869 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 636.453 | ø25 | 19.4 | TR10.02.0331 | 0331 | no | WS_Teplá vnitřní 155 | 0
13062302 | 1.NP_SO-101 | 1269.03 | 0.0004908 | 0.0996695 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1269.03 | ø25 | 19.4 | TR10.02.0332 | 0332 | no | WS_Studená vnitřní 151 | 0
13062321 | 1.NP_SO-101 | 700.105 | 0.000314112 | 0.0439889 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 700.105 | ø20 | 15.4 | TR10.02.0333 | 0333 | no | WS_Studená vnitřní 151 | 0
13062421 | 1.NP_SO-101 | 1329.55 | 0.0004908 | 0.104423 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 108 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1329.55 | ø25 | 19.4 | TR10.02.0334 | 0334 | no | WS_Teplá vnitřní 155 | 0
13062440 | 1.NP_SO-101 | 642.538 | 0.000314112 | 0.0403718 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 102 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 642.538 | ø20 | 15.4 | TR10.02.0335 | 0335 | no | WS_Teplá vnitřní 155 | 0
13062502 | 1.NP_SO-101 | 1226.88 | 0.0004908 | 0.0963588 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1226.88 | ø25 | 19.4 | TR10.02.0336 | 0336 | yes | WS_Teplá vnitřní 155 | 0
13062553 | 1.NP_SO-101 | 125.075 | 0.000314112 | 0.00785869 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.075 | ø20 | 15.4 | TR10.02.0337 | 0337 | no | WS_Teplá vnitřní 155 | 0
13062563 | 1.NP_SO-101 | 694.544 | 0.000314112 | 0.0436395 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 694.544 | ø20 | 15.4 | TR10.02.0338 | 0338 | no | WS_Teplá vnitřní 155 | 0
13062614 | 1.NP_SO-101 | 145.075 | 0.000314112 | 0.00911533 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 16 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 145.075 | ø20 | 15.4 | TR10.02.0339 | 0339 | no | WS_Studená vnitřní 151 | 0
13062624 | 1.NP_SO-101 | 627.767 | 0.000314112 | 0.0394437 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 16 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 627.767 | ø20 | 15.4 | TR10.02.0340 | 0340 | no | WS_Studená vnitřní 151 | 0
13062659 | 1.NP_SO-101 | 1196.4 | 0.000314112 | 0.075172 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1196.4 | ø20 | 15.4 | TR10.02.0341 | 0341 | no | WS_Teplá vnitřní 155 | 0
13062684 | 1.NP_SO-101 | 1308.34 | 0.000314112 | 0.0822054 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 16 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1308.34 | ø20 | 15.4 | TR10.02.0342 | 0342 | no | WS_Studená vnitřní 151 | 0
13062694 | 1.NP_SO-101 | 289.5 | 0.0004908 | 0.0227373 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 111 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 289.5 | ø25 | 19.4 | TR10.02.0343 | 0343 | no | WS_Studená vnitřní 151 | 0
13062703 | 1.NP_SO-101 | 179.293 | 0.0004908 | 0.0140817 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 111 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 179.293 | ø25 | 19.4 | TR10.02.0344 | 0344 | no | WS_Studená vnitřní 151 | 0
13062715 | 1.NP_SO-101 | 2043.95 | 0.0004908 | 0.160531 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 111 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2043.95 | ø25 | 19.4 | TR10.02.0345 | 0345 | no | WS_Studená vnitřní 151 | 0
13062791 | 1.NP_SO-101 | 2603.89 | 0.0019632 | 0.409018 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3380.6 | PP–RCT S4 | 50 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2603.89 | ø50 | 38.8 | TR10.02.0346 | 0346 | yes | WS_Studená vnitřní 151 | 0
13062799 | 1.NP_SO-101 | 2572.43 | 0.000804127 | 0.258608 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3387.6 | PP–RCT S4 | 32 | 113 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2572.43 | ø32 | 24.8 | TR10.02.0347 | 0347 | yes | WS_Studená vnitřní 151 | 0
13062807 | 1.NP_SO-101 | 378.185 | 0.0004908 | 0.0297026 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 378.185 | ø25 | 19.4 | TR10.02.0348 | 0348 | no | WS_Teplá vnitřní 155 | 0
13062816 | 1.NP_SO-101 | 238.725 | 0.0004908 | 0.0187494 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 238.725 | ø25 | 19.4 | TR10.02.0349 | 0349 | no | WS_Teplá vnitřní 155 | 0
13062828 | 1.NP_SO-101 | 1859.36 | 0.0004908 | 0.146034 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1859.36 | ø25 | 19.4 | TR10.02.0350 | 0350 | no | WS_Teplá vnitřní 155 | 0
13062890 | 1.NP_SO-101 | 2527.09 | 0.0019632 | 0.396954 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3380.6 | PP–RCT S4 | 50 | 98 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2527.09 | ø50 | 38.8 | TR10.02.0351 | 0351 | yes | WS_Teplá vnitřní 155 | 0
13062896 | 1.NP_SO-101 | 2546.15 | 0.000804127 | 0.255967 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3387.6 | PP–RCT S4 | 32 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2546.15 | ø32 | 24.8 | TR10.02.0352 | 0352 | yes | WS_Teplá vnitřní 155 | 0
13063480 | -1.PP_SO-101 | 26.2868 | 0.000804127 | 0.00264263 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -862.4 | PP–RCT S4 | 32 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.2868 | ø32 | 24.8 | TR10.02.0353 | 0353 | yes | WS_Cirkulace vnitřní 2 | 0
13063588 | -1.PP_SO-101 | 1645.98 | 0.0019632 | 0.25855 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2475 | 2450 | 2450 | 2425 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -719.4 | PP–RCT S4 | 50 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1645.98 | ø50 | 38.8 | TR10.02.0354 | 0354 | yes | WS_Teplá vnitřní 155 | 0
13063600 | -1.PP_SO-101 | 311.621 | 0.000804127 | 0.0313275 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2466 | 2450 | 2450 | 2434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -712.4 | PP–RCT S4 | 32 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 311.621 | ø32 | 24.8 | TR10.02.0355 | 0355 | yes | WS_Teplá vnitřní 155 | 0
13063636 | -1.PP_SO-101 | 545.442 | 0.000804127 | 0.0548338 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2416 | 2400 | 2400 | 2384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -762.4 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 545.442 | ø32 | 24.8 | TR10.02.0356 | 0356 | yes | WS_Cirkulace vnitřní 2 | 0
13063690 | -1.PP_SO-101 | 1534.58 | 0.000804127 | 0.154273 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2416 | 2400 | 2400 | 2384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -762.4 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1534.58 | ø32 | 24.8 | TR10.02.0357 | 0357 | yes | WS_Cirkulace vnitřní 2 | 0
13063753 | -1.PP_SO-101 | 46.1655 | 0.0019632 | 0.00725166 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -869.399 | PP–RCT S4 | 50 | 362 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 46.1655 | ø50 | 38.8 | TR10.02.0358 | 0358 | yes | WS_Studená vnitřní 151 | 0
13063800 | -1.PP_SO-101 | 1007.41 | 0.00125645 | 0.126595 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | -1.PP_SO-101 | 2520 | 2500 | 2500 | 2480 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -665.5 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1007.41 | ø40 | 31 | TR10.02.0359 | 0359 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13063868 | -1.PP_SO-101 | 296.154 | 0.00125645 | 0.0372158 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | -1.PP_SO-101 | 2520 | 2500 | 2500 | 2480 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -665.5 | PP–RCT S4 | 40 | 102 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 296.154 | ø40 | 31 | TR10.02.0360 | 0360 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13063874 | -1.PP_SO-101 | 103.702 | 0.000314112 | 0.0065158 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 103.702 | ø20 | 15.4 | TR10.02.0361 | 0361 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13063987 | -1.PP_SO-101 | 2809.29 | 0.000490782 | 0.220641 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.698 | PP–RCT S4 | 25 | 368 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2809.29 | ø25 | 19.4 | TR10.02.0362 | 0362 | no | WS_Studená vnitřní 151 | 0
13064036 | -1.PP_SO-101 | 209.356 | 0.000314112 | 0.0131542 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 295 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 209.356 | ø20 | 15.4 | TR10.02.0363 | 0363 | no | WS_Studená vnitřní 151 | 0
13064045 | -1.PP_SO-101 | 125.075 | 0.000314112 | 0.00785869 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 295 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.075 | ø20 | 15.4 | TR10.02.0364 | 0364 | no | WS_Studená vnitřní 151 | 0
13064053 | -1.PP_SO-101 | 1022.54 | 0.000314112 | 0.0642479 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 295 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1022.54 | ø20 | 15.4 | TR10.02.0365 | 0365 | no | WS_Studená vnitřní 151 | 0
13064127 | -1.PP_SO-101 | 2078.41 | 0.000314112 | 0.130591 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 289 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2078.41 | ø20 | 15.4 | TR10.02.0366 | 0366 | no | WS_Studená vnitřní 151 | 0
13064139 | -1.PP_SO-101 | 2199.01 | 0.0004908 | 0.17271 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.698 | PP–RCT S4 | 25 | 293 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2199.01 | ø25 | 19.4 | TR10.02.0367 | 0367 | no | WS_Studená vnitřní 151 | 0
13064153 | -1.PP_SO-101 | 429.356 | 0.000314112 | 0.0269772 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 174 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 429.356 | ø20 | 15.4 | TR10.02.0368 | 0368 | no | WS_Teplá vnitřní 155 | 0
13064162 | -1.PP_SO-101 | 185.075 | 0.000314112 | 0.0116286 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 174 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 185.075 | ø20 | 15.4 | TR10.02.0369 | 0369 | no | WS_Teplá vnitřní 155 | 0
13064170 | -1.PP_SO-101 | 922.538 | 0.000314112 | 0.0579647 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 174 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 922.538 | ø20 | 15.4 | TR10.02.0370 | 0370 | no | WS_Teplá vnitřní 155 | 0
13064236 | -1.PP_SO-101 | 2258.69 | 0.000314112 | 0.141917 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 172 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2258.69 | ø20 | 15.4 | TR10.02.0371 | 0371 | no | WS_Teplá vnitřní 155 | 0
13064248 | -1.PP_SO-101 | 1972.86 | 0.0004908 | 0.154948 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 170 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1972.86 | ø25 | 19.4 | TR10.02.0372 | 0372 | no | WS_Teplá vnitřní 155 | 0
13064262 | -1.PP_SO-101 | 1619.75 | 0.000314112 | 0.101772 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 175 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1619.75 | ø20 | 15.4 | TR10.02.0373 | 0373 | no | WS_Teplá vnitřní 155 | 0
13064319 | -1.PP_SO-101 | 2103.8 | 0.000314112 | 0.132186 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2103.8 | ø20 | 15.4 | TR10.02.0374 | 0374 | no | WS_Teplá vnitřní 155 | 0
13064335 | -1.PP_SO-101 | 1665.87 | 0.000314112 | 0.10467 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 297 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1665.87 | ø20 | 15.4 | TR10.02.0375 | 0375 | no | WS_Studená vnitřní 151 | 0
13064408 | -1.PP_SO-101 | 1793.45 | 0.000314112 | 0.112686 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.698 | PP–RCT S4 | 20 | 291 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1793.45 | ø20 | 15.4 | TR10.02.0376 | 0376 | no | WS_Studená vnitřní 151 | 0
13064961 | -1.PP_SO-101 | 1033.37 | 0.0004908 | 0.0811607 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1033.37 | ø25 | 19.4 | TR10.02.0377 | 0377 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13065038 | -1.PP_SO-101 | 699.74 | 0.000804127 | 0.0703456 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2516 | 2500 | 2500 | 2484 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -662.4 | PP–RCT S4 | 32 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 699.74 | ø32 | 24.8 | TR10.02.0378 | 0378 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13065129 | -1.PP_SO-101 | 159.395 | 0.000804127 | 0.0160242 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.4 | PP–RCT S4 | 32 | 299 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 159.395 | ø32 | 24.8 | TR10.02.0379 | 0379 | no | WS_Studená vnitřní 151 | 0
13065211 | -1.PP_SO-101 | 546.057 | 0.000804127 | 0.0548957 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -862.4 | PP–RCT S4 | 32 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 546.057 | ø32 | 24.8 | TR10.02.0380 | 0380 | no | WS_Teplá vnitřní 155 | 0
13065489 | -1.PP_SO-101 | 277.62 | 0.0004908 | 0.0218042 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1742.5 | 1730 | 1730 | 1717.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -1429.7 | PP–RCT S4 | 25 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 277.62 | ø25 | 19.4 | TR10.02.0381 | 0381 | no | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2 | 0
13065788 | -1.PP_SO-101 | 14468.1 | 0.000314112 | 0.909059 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 318 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 14468.1 | ø20 | 15.4 | TR10.02.0382 | 0382 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13065839 | -1.PP_SO-101 | 4851.35 | 0.0004908 | 0.381024 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4851.35 | ø25 | 19.4 | TR10.02.0383 | 0383 | yes | WS_Teplá vnitřní 155 | 0
13065855 | -1.PP_SO-101 | 4724.68 | 0.0004908 | 0.371076 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 375 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4724.68 | ø25 | 19.4 | TR10.02.0384 | 0384 | yes | WS_Studená vnitřní 151 | 0
13065976 | -1.PP_SO-101 | 115 | 0.000804127 | 0.0115611 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.399 | PP–RCT S4 | 32 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 115 | ø32 | 24.8 | TR10.02.0385 | 0385 | yes | WS_Studená vnitřní 151 | 0
13065992 | -1.PP_SO-101 | 2574.9 | 0.000804127 | 0.258857 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2466 | 2450 | 2450 | 2434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -712.4 | PP–RCT S4 | 32 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2574.9 | ø32 | 24.8 | TR10.02.0386 | 0386 | no | WS_Teplá vnitřní 155 | 0
13066114 | -1.PP_SO-101 | 198.644 | 0.0019632 | 0.0312029 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2475 | 2450 | 2450 | 2425 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -719.4 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 198.644 | ø50 | 38.8 | TR10.02.0387 | 0387 | yes | WS_Teplá vnitřní 155 | 0
13066132 | -1.PP_SO-101 | 348.626 | 0.0019632 | 0.0547621 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2475 | 2450 | 2450 | 2425 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -719.4 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 348.626 | ø50 | 38.8 | TR10.02.0388 | 0388 | yes | WS_Studená vnitřní 151 | 0
13066178 | -1.PP_SO-101 | 294.152 | 0.000804127 | 0.0295714 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2416 | 2400 | 2400 | 2384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -762.4 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 294.152 | ø32 | 24.8 | TR10.02.0389 | 0389 | yes | WS_Cirkulace vnitřní 2 | 0
13066220 | -1.PP_SO-101 | 976.251 | 0.0019632 | 0.153349 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2475 | 2450 | 2450 | 2425 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -719.4 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 976.251 | ø50 | 38.8 | TR10.02.0390 | 0390 | yes | WS_Teplá vnitřní 155 | 0
13066250 | -1.PP_SO-101 | 611.237 | 0.0019632 | 0.0960129 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2475 | 2450 | 2450 | 2425 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -719.4 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 611.237 | ø50 | 38.8 | TR10.02.0391 | 0391 | yes | WS_Studená vnitřní 151 | 0
13066297 | -1.PP_SO-101 | 213.319 | 0.000804127 | 0.0214452 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2416 | 2400 | 2400 | 2384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -762.4 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 213.319 | ø32 | 24.8 | TR10.02.0392 | 0392 | yes | WS_Cirkulace vnitřní 2 | 0
13066383 | 1.NP_SO-101 | 226.893 | 0.00125645 | 0.0285122 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3384.5 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 226.893 | ø40 | 31 | TR10.02.0393 | 0393 | yes | WS_Teplá vnitřní 155 | 0
13066401 | 1.NP_SO-101 | 226.893 | 0.00125645 | 0.0285122 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3384.5 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 226.893 | ø40 | 31 | TR10.02.0394 | 0394 | yes | WS_Studená vnitřní 151 | 0
13066423 | 1.NP_SO-101 | 286.243 | 0.0004908 | 0.0224815 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3390.3 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 286.243 | ø25 | 19.4 | TR10.02.0395 | 0395 | yes | WS_Cirkulace vnitřní 2 | 0
13066639 | 1.NP_SO-101 | 2666 | 0.0004908 | 0.209387 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2666 | ø25 | 19.4 | TR10.02.0396 | 0396 | no | WS_Teplá vnitřní 155 | 0
13066655 | 1.NP_SO-101 | 2434.68 | 0.0004908 | 0.191219 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 111 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2434.68 | ø25 | 19.4 | TR10.02.0397 | 0397 | no | WS_Studená vnitřní 151 | 0
13066726 | 1.NP_SO-101 | 574.476 | 0.0004908 | 0.0451192 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 108 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 574.476 | ø25 | 19.4 | TR10.02.0398 | 0398 | no | WS_Teplá vnitřní 155 | 0
13066756 | 1.NP_SO-101 | 711.233 | 0.0004908 | 0.0558601 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 711.233 | ø25 | 19.4 | TR10.02.0399 | 0399 | no | WS_Studená vnitřní 151 | 0
13066980 | 2.NP_SO-101 | 1414.52 | 0.000804127 | 0.142203 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7336.77 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1414.52 | ø32 | 24.8 | TR10.02.0400 | 0400 | yes | WS_Teplá vnitřní 155 | 0
13066998 | 2.NP_SO-101 | 1214.52 | 0.000804127 | 0.122097 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7336.77 | PP–RCT S4 | 32 | 85 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1214.52 | ø32 | 24.8 | TR10.02.0401 | 0401 | yes | WS_Studená vnitřní 151 | 0
13067025 | 2.NP_SO-101 | 1322.2 | 0.0004908 | 0.103845 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7339.47 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1322.2 | ø25 | 19.4 | TR10.02.0402 | 0402 | yes | WS_Cirkulace vnitřní 2 | 0
13069980 | 4.NP_SO-101 | 1539.1 | 0.000804127 | 0.154727 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1539.1 | ø32 | 24.8 | TR10.02.0403 | 0403 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13070042 | 4.NP_SO-101 | 744.397 | 0.0004908 | 0.0584648 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 744.397 | ø25 | 19.4 | TR10.02.0404 | 0404 | no | WS_Teplá vnitřní 155 | 0
13071694 | 1.NP_SO-101 | 2395.1 | 0.000804127 | 0.240781 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2395.1 | ø32 | 24.8 | TR10.02.0405 | 0405 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071725 | 1.NP_SO-101 | 92.7405 | 0.000804127 | 0.00932329 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 92.7405 | ø32 | 24.8 | TR10.02.0406 | 0406 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072066 | 3.NP_SO-101 | 59.6238 | 0.0004908 | 0.00468284 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 59.6238 | ø25 | 19.4 | TR10.02.0407 | 0407 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072114 | 3.NP_SO-101 | 943.671 | 0.0004908 | 0.0741157 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 943.671 | ø25 | 19.4 | TR10.02.0408 | 0408 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072212 | 4.NP_SO-101 | 3739.36 | 0.0004908 | 0.293689 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3739.36 | ø25 | 19.4 | TR10.02.0409 | 0409 | no | WS_Teplá vnitřní 155 | 0
13072563 | 4.NP_SO-101 | 130.278 | 0.000804127 | 0.013097 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 130.278 | ø32 | 24.8 | TR10.02.0410 | 0410 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072583 | 4.NP_SO-101 | 81.8124 | 0.000804127 | 0.00822468 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 4.NP_SO-101 | 2989.69 | 2973.69 | 2973.69 | 2957.69 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 14961.3 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 81.8124 | ø32 | 24.8 | TR10.02.0411 | 0411 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072661 | 4.NP_SO-101 | 644.636 | 0.0004908 | 0.0506296 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2860.84 | 2848.34 | 2848.34 | 2835.84 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 14838.6 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 644.636 | ø25 | 19.4 | TR10.02.0412 | 0412 | no | WS_Teplá vnitřní 155 | 0
13072679 | 4.NP_SO-101 | 723.238 | 0.0004908 | 0.056803 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 723.238 | ø25 | 19.4 | TR10.02.0413 | 0413 | no | WS_Studená vnitřní 151 | 0
13072744 | 1.NP_SO-101 | 108.418 | 0.000804127 | 0.0108994 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 108.418 | ø32 | 24.8 | TR10.02.0414 | 0414 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13072947 | 3.NP_SO-101 | 178.065 | 0.0004908 | 0.0139852 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 178.065 | ø25 | 19.4 | TR10.02.0415 | 0415 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13127575 | -1.PP_SO-101 | 848.462 | 0.0004908 | 0.0666381 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 848.462 | ø25 | 19.4 | TR10.02.0465 | 0465 | no | WS_Studená vnitřní 151 | 0
13127591 | -1.PP_SO-101 | 10375.1 | 0.0004908 | 0.814861 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -859.7 | PP–RCT S4 | 25 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10375.1 | ø25 | 19.4 | TR10.02.0466 | 0466 | yes | WS_Cirkulace vnitřní 2 | 0
13127617 | -1.PP_SO-101 | 948.462 | 0.0004908 | 0.074492 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 159 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 948.462 | ø25 | 19.4 | TR10.02.0467 | 0467 | no | WS_Teplá vnitřní 155 | 0
13127637 | -1.PP_SO-101 | 399.212 | 0.000314112 | 0.0250832 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 399.212 | ø20 | 15.4 | TR10.02.0468 | 0468 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13127860 | -1.PP_SO-101 | 945.869 | 0.000314112 | 0.0594307 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 1740 | 1730 | 1730 | 1720 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1427.7 | PP–RCT S4 | 20 | 18 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 945.869 | ø20 | 15.4 | TR10.02.0469 | 0469 | no | WS_Teplá vnitřní 155 | 0
13127883 | -1.PP_SO-101 | 477.62 | 0.0004908 | 0.0375122 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1742.5 | 1730 | 1730 | 1717.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1429.7 | PP–RCT S4 | 25 | 159 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 477.62 | ø25 | 19.4 | TR10.02.0470 | 0470 | no | WS_Teplá vnitřní 155 | 0
13127895 | -1.PP_SO-101 | 930.966 | 0.0004908 | 0.0731179 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 1742.5 | 1730 | 1730 | 1717.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1429.7 | PP–RCT S4 | 25 | 160 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 930.966 | ø25 | 19.4 | TR10.02.0471 | 0471 | no | WS_Teplá vnitřní 155 | 0
13128095 | -1.PP_SO-101 | 1264.82 | 0.0004908 | 0.0993383 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2309 | 1732.18 | 2297.82 | 1721 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -1426.5 | PP–RCT S4 | 25 | 159 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1264.82 | ø25 | 19.4 | TR10.02.0472 | 0472 | no | WS_Teplá vnitřní 155 | 50
13128194 | -1.PP_SO-101 | 1431.99 | 0.0004908 | 0.112468 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2309 | 2297.82 | 1657.42 | 1646.24 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -1501.26 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1431.99 | ø25 | 19.4 | TR10.02.0473 | 0473 | no | WS_Studená vnitřní 151 | 50
13128270 | -1.PP_SO-101 | 1264.82 | 0.0004908 | 0.0993383 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2309 | 1732.18 | 2297.82 | 1721 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -1426.5 | PP–RCT S4 | 25 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1264.82 | ø25 | 19.4 | TR10.02.0474 | 0474 | no | WS_Cirkulace vnitřní 2 | 50
13128308 | -1.PP_SO-101 | 1713.53 | 0.000314112 | 0.107664 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2507.1 | 1731.84 | 2498.16 | 1722.9 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1425.04 | PP–RCT S4 | 20 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1713.53 | ø20 | 15.4 | TR10.02.0475 | 0475 | no | WS_"Jiný typ" studená vnitřní 1 | 50
13148627 | -1.PP_SO-101 | 2103.97 | 0.0019632 | 0.330491 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -869.4 | PP–RCT S4 | 50 | 360 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2103.97 | ø50 | 38.8 | TR10.02.0512 | 0512 | yes | WS_Studená vnitřní 151 | 0
13148639 | -1.PP_SO-101 | 3049.23 | 0.0019632 | 0.478972 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -869.4 | PP–RCT S4 | 50 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3049.23 | ø50 | 38.8 | TR10.02.0513 | 0513 | yes | WS_Studená vnitřní 151 | 0
13148664 | -1.PP_SO-101 | 2491.29 | 0.0019632 | 0.391331 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -869.4 | PP–RCT S4 | 50 | 182 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2491.29 | ø50 | 38.8 | TR10.02.0514 | 0514 | yes | WS_Teplá vnitřní 155 | 0
13148676 | -1.PP_SO-101 | 2791.83 | 0.0019632 | 0.43854 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -869.4 | PP–RCT S4 | 50 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2791.83 | ø50 | 38.8 | TR10.02.0515 | 0515 | yes | WS_Teplá vnitřní 155 | 0
13157605 | 2.NP_SO-101 | 4222.73 | 0.000804127 | 0.424515 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3377.89 | -844.838 | 3377.89 | -844.838 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3155.16 | PP–RCT S4 | 32 | 327 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4222.73 | ø32 | 24.8 | TR10.02.0520 | 0520 | yes | WS_"Jiný typ" studená vnitřní 1
13161811 | -1.PP_SO-101 | 36.6839 | 0.0004908 | 0.00288115 | ø25 mm |  |  |  | 0.000515464 | F | JB | -1.PP_SO-101 | 1872.5 | 1860 | 1860 | 1847.5 | WS_Požární zavodněný | 0.01 | Požární ochrana – vodní prostředky | Trubka Evo, S4 | WS_Požární zavodněný 1 | -1299.7 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 36.6839 | ø25 | 19.4 | TR10.02.0535 | 0535 | yes | WS_Požární zavodněný 1 | 0
13173552 | 1.NP_SO-101 | 8392.38 | 0.000804127 | 0.843694 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8392.38 | ø32 | 24.8 | TR10.02.0560 | 0560 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13173593 | 1.NP_SO-101 | 3113.53 | 0.00125645 | 0.391258 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3084.52 | 3084.52 | -29.0152 | -29.0152 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -29.0152 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3113.53 | ø40 | 31 | TR10.02.0561 | 0561 | yes | WS_"Jiný typ" studená vnitřní 1
13173683 | 1.NP_SO-101 | 258.369 | 0.000314112 | 0.0162338 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3510 | 3500 | 3500 | 3490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3492.3 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 258.369 | ø20 | 15.4 | TR10.02.0562 | 0562 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13173745 | 1.NP_SO-101 | 705.075 | 0.000314112 | 0.0443012 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3510 | 3500 | 3500 | 3490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3492.3 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 705.075 | ø20 | 15.4 | TR10.02.0563 | 0563 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13189892 | -1.PP_SO-101 | 1194.29 | 0.00950189 | 0.412718 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | -162.946 | -1357.24 | -162.946 | -1357.24 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 8 | -4507.24 | PP–RCT S4 | 110 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1194.29 | ø110 | 85.4 | TR10.02.0564 | 0564 | yes | SW_Splašky vnitřní gravitační 8
13189962 | -1.PP_SO-101 | 1298.93 | 0.00950189 | 0.448878 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | -162.946 | -1461.88 | -162.946 | -1461.88 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 8 | -4611.88 | PP–RCT S4 | 110 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1298.93 | ø110 | 85.4 | TR10.02.0565 | 0565 | yes | SW_Splašky vnitřní gravitační 8
