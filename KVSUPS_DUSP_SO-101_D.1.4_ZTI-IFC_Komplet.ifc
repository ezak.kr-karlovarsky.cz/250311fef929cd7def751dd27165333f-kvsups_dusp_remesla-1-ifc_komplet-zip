Properties of the parts of a building model (IFC4), part 19 of 26

# IfcPipeFitting: M_Spoj T, obecný:Standardní (49)
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13057439 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0113 | 0113 | yes | 17.4625
13057622 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0116 | 0116 | yes | 17.4625
13057722 | 3.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0117 | 0117 | yes | 14.2875
13057793 | 3.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0118 | 0118 | yes | 17.4625
13059277 | 2.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 2.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0147 | 0147 | yes | 17.4625
13059304 | 2.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 2.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0148 | 0148 | yes | 17.4625
13061455 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0213 | 0213 | yes | 17.4625
13061695 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0221 | 0221 | no | 14.2875
13062293 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0238 | 0238 | no | 14.2875
13062654 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0245 | 0245 | yes | 14.2875
13063982 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0270 | 0270 | no | 17.4625
13063986 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0271 | 0271 | no | 17.4625
13064318 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0280 | 0280 | no | 14.2875
13064407 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0281 | 0281 | no | 14.2875
13072325 | 4.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0303 | 0303 | no | 14.2875
13127859 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0344 | 0344 | no | 14.2875
13127894 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0347 | 0347 | no | 14.2875
13173592 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 1.NP_SO-101 | 3125 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0466 | 0466 | yes | 17.4625
13198965 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0496 | 0496 | yes | 14.2875
13199079 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0498 | 0498 | yes | 14.2875
13199847 | -1.PP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0510 | 0510 | yes | 14.2875
13229443 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0551 | 0551 | no | 14.2875
13229491 | 1.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0554 | 0554 | no | 14.2875
13242398 | -1.PP_SO-101 | ø50 mm-ø50 mm-ø50 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 89.6386 | 25 | 50 | 0.000220004 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0628 | 0628 | yes | 26.9875
13262762 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0645 | 0645 | yes | 17.4625
13264669 | 3.NP_SO-101 | ø25 mm-ø25 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0658 | 0658 | yes | 14.2875
13264955 | -1.PP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0662 | 0662 | yes | 17.4625
13383426 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | WPA | 1.NP_SO-101 | 3275 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0840 | 0840 | yes | 17.4625
13385369 | 1.NP_SO-101 | ø32 mm-ø32 mm-ø32 mm | QMA | 1.NP_SO-101 | 3125 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0862 | 0862 | yes | 17.4625

# IfcPipeFitting: M_Spojka, obecná:Standardní (3)
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Typ: Standardní
Name (M_Spojka, obecná:Standardní:...) | In | Length (mm) = Délka (mm) = Vnější poloměr tvarovky (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Group
12924366 | 4.NP_SO-101 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | 4.NP_SO-101 | 2000 | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0001 | 0001 | SW_Splašky vnitřní gravitační 10; SW_Odvětrání kanalizace 10
13126515 | -1.PP_SO-101 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-101 | 114.135 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0342 | 0342 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13132587 | 3.NP_SO-101 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 3.NP_SO-101 | 1970.52 | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.0367 | 0367 | SW_Splašky vnitřní gravitační 10; SW_Odvětrání kanalizace 2

# IfcPipeFitting: M_Uzavření, obecné:Standardní (20)
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní
Name (M_Uzavření, obecné:Standardní:...) | In | Length (mm) = Výš. (mm) = Vnější poloměr tvarovky (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa
13126567 | -1.PP_SO-101 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm | -1.PP_SO-101 | 742.429 | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000569234 | ø110 | 113.175 | TT00.05.0343 | 0343 | yes
13130710 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 1306.3 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0360 | 0360 | no
13130733 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 1578.04 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0361 | 0361 | no
13130819 | 2.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 2.NP_SO-101 | 1257.46 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0362 | 0362 | no
13133990 | 1.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 1.NP_SO-101 | 1238.1 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0373 | 0373 | yes
13134166 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 1527.23 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0377 | 0377 | yes
13134957 | 1.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 1.NP_SO-101 | 1518.04 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0382 | 0382 | yes
13145177 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 2778.04 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0398 | 0398 | yes
13275779 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 1578.04 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0688 | 0688 | yes
13275790 | 3.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 3.NP_SO-101 | 1778.11 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0689 | 0689 | no
13275803 | 2.NP_SO-101 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm | 2.NP_SO-101 | 653.87 | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000210042 | ø78 | 81.175 | TT00.05.0690 | 0690 | no
13275814 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 299.116 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0691 | 0691 | no
13275817 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 304.316 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0692 | 0692 | no
13275819 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 247.335 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0693 | 0693 | no
13279375 | 4.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 4.NP_SO-101 | 1119.21 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0721 | 0721 | no
13279387 | 4.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 4.NP_SO-101 | 3080 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0722 | 0722 | no
13279408 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 181.789 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0723 | 0723 | no
13279410 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 168.354 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0724 | 0724 | no
13279412 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 187.193 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0725 | 0725 | no
13279414 | 2.NP_SO-101 | 30.5875 | 0.00293887 | 0.00587852 | ø58 mm | 2.NP_SO-101 | 180.002 | SW_Splašky vnitřní gravitační 10 | 29 | 58 | 0.0000899003 | ø58 | 61.175 | TT00.05.0726 | 0726 | no

# IfcPipeSegment: Ohebné trubky:Odpadní hadice (3)
Type - PredefinedType: FLEXIBLESEGMENT; Material: 128-0-0
Type - Tvarovky - Preferovaný typ spojky: T-spoj
Type - Požární ochrana - Požární odolnost: –
Type - Mechanické - Drsnost: 0.04572 mm
Type - Identifikační data - ID kategorie: OP; Kód sestavy: TR00; Název typu: Odpadní hadice; Označení typu: 02; Popis: Odpadní hadice; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Ohebné trubky; Název rodiny: Ohebné trubky
Classification: TR00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm
Mechanické – tok - Instalační jednotky: 0; Relativní drsnost: 0.002286
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Počáteční střední výška: 444.273 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Řez: 1; Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární; Průměr: 20 mm
Grafika - Vzor ohybu: Jediná linie
Kóty - Délka: 595.766 mm; Vnější průměr: 20 mm; Vnitřní průměr: 20 mm
Jiné - Rodina: Ohebné trubky; Id typu: 10008631; Rodina a typ: Ohebné trubky: Odpadní hadice; Typ: Odpadní hadice
Name (Ohebné trubky:Odpadní hadice:...) | In | Referenční podlaží | Název systému = Group | Kód prvku | Název sestavy | Označení
13147144 | 2.NP_SO-101 | 3.NP_SO-101 | SW_Splašky vnitřní gravitační 7 | TR00.02.0068 | Myčka 1 | 0068
13286947 | -1.PP_SO-101 | -1.PP_SO-101 | SW_Splašky vnitřní gravitační 9 | TR00.02.0098 | Výlevka nástěnnð | 0098
13286960 | -1.PP_SO-101 | -1.PP_SO-101 | SW_Splašky vnitřní gravitační 11 | TR00.02.0100 | Výlevka nástěnnð | 0100

# IfcPipeSegment: Ohebné trubky:Pancéřová hadice (117)
Type - PredefinedType: FLEXIBLESEGMENT; Material: 255-0-0
Type - Tvarovky - Preferovaný typ spojky: T-spoj
Type - Požární ochrana - Požární odolnost: –
Type - Mechanické - Drsnost: 0.04572 mm
Type - Identifikační data - ID kategorie: OP; Kód sestavy: TR00; Název typu: Pancéřová hadice; Označení typu: 01; Popis: Pancéřová hadice; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Ohebné trubky; Název rodiny: Ohebné trubky
Classification: TR00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s; Instalační jednotky: 0; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Tlaková ztráta: 0 Pa; Třecí faktor: 0; Tření: 0
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Vzor ohybu: Jediná linie
Jiné - Id typu: 9893359; Rodina: Ohebné trubky; Rodina a typ: Ohebné trubky: Pancéřová hadice; Typ: Pancéřová hadice
Name (Ohebné trubky:Pancéřová hadice:...) | In | Celková velikost | Relativní drsnost | Počáteční střední výška (mm) | Referenční podlaží | Typ systému | Klasifikace systému | Název systému = Group | Průměr (mm) = Vnější průměr (mm) = Vnitřní průměr (mm) | Řez | Délka (mm) | Kód prvku | Název sestavy | Označení
12872618 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 14 | 15 | 1 | 239.66 | TR00.01.0001 | Umyvadlo | 0001
12872620 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 10 | 15 | 1 | 239.66 | TR00.01.0002 | Umyvadlo | 0002
12872644 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 15 | 15 | 1 | 239.66 | TR00.01.0003 | Umyvadlo | 0003
12872646 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 11 | 15 | 1 | 239.66 | TR00.01.0004 | Umyvadlo | 0004
12872821 | -1.PP_SO-101 | ø15 mm | 0.003048 | -145 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 22 | 15 | 1 | 239.66 | TR00.01.0005 | Umyvadlo | 0005
12872823 | -1.PP_SO-101 | ø15 mm | 0.003048 | -145 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 18 | 15 | 1 | 239.66 | TR00.01.0006 | Umyvadlo | 0006
12872854 | -1.PP_SO-101 | ø15 mm | 0.003048 | -145 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 11 | 15 | 1 | 239.66 | TR00.01.0007 | Umyvadlo | 0007
12872856 | -1.PP_SO-101 | ø15 mm | 0.003048 | -145 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 4 | 15 | 1 | 239.66 | TR00.01.0008 | Umyvadlo | 0008
12873234 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 24 | 15 | 1 | 239.66 | TR00.01.0009 | Umyvadlo | 0009
12873236 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 20 | 15 | 1 | 239.66 | TR00.01.0010 | Umyvadlo | 0010
12873268 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 13 | 15 | 1 | 239.66 | TR00.01.0011 | Umyvadlo | 0011
12873270 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 9 | 15 | 1 | 239.66 | TR00.01.0012 | Umyvadlo | 0012
12905766 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 141 | 15 | 1 | 239.66 | TR00.01.0013 | Umyvadlo | 0013
12905768 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 137 | 15 | 1 | 239.66 | TR00.01.0014 | Umyvadlo | 0014
12906438 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 146 | 15 | 1 | 239.66 | TR00.01.0015 | Umyvadlo + modul | 0015
12906440 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 142 | 15 | 1 | 239.66 | TR00.01.0016 | Umyvadlo + modul | 0016
12906984 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 15 | 1 | 239.66 | TR00.01.0017 | Umyvadlo | 0017
12906986 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 15 | 1 | 239.66 | TR00.01.0018 | Umyvadlo | 0018
12907043 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 156 | 15 | 1 | 239.66 | TR00.01.0019 | Umyvadlo + modul | 0019
12907045 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 152 | 15 | 1 | 239.66 | TR00.01.0020 | Umyvadlo + modul | 0020
12907110 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 157 | 15 | 1 | 239.66 | TR00.01.0021 | Umyvadlo + modul | 0021
12907112 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 153 | 15 | 1 | 239.66 | TR00.01.0022 | Umyvadlo + modul | 0022
12907134 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 158 | 15 | 1 | 239.66 | TR00.01.0023 | Umyvadlo + modul | 0023
12907136 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 154 | 15 | 1 | 239.66 | TR00.01.0024 | Umyvadlo + modul | 0024
12907374 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 160 | 15 | 1 | 239.66 | TR00.01.0025 | Umyvadlo | 0025
12907376 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 156 | 15 | 1 | 239.66 | TR00.01.0026 | Umyvadlo | 0026
12907446 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 161 | 15 | 1 | 239.66 | TR00.01.0027 | Umyvadlo | 0027
12907448 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 157 | 15 | 1 | 239.66 | TR00.01.0028 | Umyvadlo | 0028
12907469 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 162 | 15 | 1 | 239.66 | TR00.01.0029 | Umyvadlo | 0029
12907471 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 158 | 15 | 1 | 239.66 | TR00.01.0030 | Umyvadlo | 0030
12907554 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 163 | 15 | 1 | 239.66 | TR00.01.0031 | Umyvadlo + modul | 0031
12907556 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 159 | 15 | 1 | 239.66 | TR00.01.0032 | Umyvadlo + modul | 0032
12907578 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 164 | 15 | 1 | 239.66 | TR00.01.0033 | Umyvadlo + modul | 0033
12907580 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 160 | 15 | 1 | 239.66 | TR00.01.0034 | Umyvadlo + modul | 0034
12907716 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 165 | 15 | 1 | 239.66 | TR00.01.0035 | Umyvadlo | 0035
12907718 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 161 | 15 | 1 | 239.66 | TR00.01.0036 | Umyvadlo | 0036
12907978 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 167 | 15 | 1 | 239.66 | TR00.01.0037 | Umyvadlo | 0037
12907980 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 163 | 15 | 1 | 239.66 | TR00.01.0038 | Umyvadlo | 0038
12908037 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 168 | 15 | 1 | 239.66 | TR00.01.0039 | Umyvadlo + modul | 0039
12908039 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 164 | 15 | 1 | 239.66 | TR00.01.0040 | Umyvadlo + modul | 0040
12908061 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 169 | 15 | 1 | 239.66 | TR00.01.0041 | Umyvadlo + modul | 0041
12908063 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 165 | 15 | 1 | 239.66 | TR00.01.0042 | Umyvadlo + modul | 0042
12908144 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 170 | 15 | 1 | 239.66 | TR00.01.0043 | Umyvadlo + modul | 0043
12908146 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 166 | 15 | 1 | 239.66 | TR00.01.0044 | Umyvadlo + modul | 0044
12908168 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 171 | 15 | 1 | 239.66 | TR00.01.0045 | Umyvadlo + modul | 0045
12908170 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 167 | 15 | 1 | 239.66 | TR00.01.0046 | Umyvadlo + modul | 0046
12908263 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 172 | 15 | 1 | 239.66 | TR00.01.0047 | Umyvadlo + modul | 0047
12908265 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 168 | 15 | 1 | 239.66 | TR00.01.0048 | Umyvadlo + modul | 0048
12908333 | -1.PP_SO-101 | ø15 mm | 0.003048 | 1305 | 4.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 173 | 15 | 1 | 239.66 | TR00.01.0049 | Umyvadlo + modul | 0049
12908335 | -1.PP_SO-101 | ø15 mm | 0.003048 | 1305 | 4.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 169 | 15 | 1 | 239.66 | TR00.01.0050 | Umyvadlo + modul | 0050
12908455 | -1.PP_SO-101 | ø15 mm | 0.003048 | 1305 | 4.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 174 | 15 | 1 | 239.66 | TR00.01.0051 | Umyvadlo + modul | 0051
12908457 | -1.PP_SO-101 | ø15 mm | 0.003048 | 1305 | 4.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 170 | 15 | 1 | 239.66 | TR00.01.0052 | Umyvadlo + modul | 0052
12908589 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 176 | 15 | 1 | 239.66 | TR00.01.0053 | Umyvadlo + modul | 0053
12908591 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 172 | 15 | 1 | 239.66 | TR00.01.0054 | Umyvadlo + modul | 0054
12908780 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 175 | 15 | 1 | 239.66 | TR00.01.0055 | Umyvadlo | 0055
12908782 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 171 | 15 | 1 | 239.66 | TR00.01.0056 | Umyvadlo | 0056
12944899 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 90 | 15 | 1 | 239.66 | TR00.01.0057 | Umyvadlo + modul | 0057
12944901 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 89 | 15 | 1 | 239.66 | TR00.01.0058 | Umyvadlo + modul | 0058
12944923 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 92 | 15 | 1 | 239.66 | TR00.01.0059 | Umyvadlo + modul | 0059
12944925 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 91 | 15 | 1 | 239.66 | TR00.01.0060 | Umyvadlo + modul | 0060
13136474 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 15 | 149 | 239.66 | TR00.01.0061 | Umyvadlo | 0061
13136476 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 15 | 154 | 239.66 | TR00.01.0062 | Umyvadlo | 0062
13142664 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 4 | 15 | 1 | 191.237 | TR00.01.0063 | Umyvadlo + modul_invalida | 0063
13142666 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 15 | 1 | 191.241 | TR00.01.0064 | Umyvadlo + modul_invalida | 0064
13144912 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 7 | 15 | 1 | 302.376 | TR00.01.0065 | Dřez | 0065
13144914 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 5 | 15 | 1 | 302.376 | TR00.01.0066 | Dřez | 0066
13145247 | 2.NP_SO-101 | ø12 mm | 0.00381 | 615 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 2 | 12 | 1 | 780.74 | TR00.01.0067 | Myčka 1 | 0067
13192357 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 29 | 15 | 1 | 302.376 | TR00.01.0069 | Výlevka nástěnní | 0069
13192359 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 7 | 15 | 1 | 302.376 | TR00.01.0070 | Výlevka nástěnní | 0070
13192380 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 30 | 15 | 1 | 302.376 | TR00.01.0071 | Výlevka nástěnní | 0071
13192382 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 15 | 1 | 302.376 | TR00.01.0072 | Výlevka nástěnní | 0072
13192406 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 31 | 15 | 1 | 302.376 | TR00.01.0073 | Výlevka nástěnní | 0073
13192408 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 9 | 15 | 1 | 302.376 | TR00.01.0074 | Výlevka nástěnní | 0074
13192432 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 32 | 15 | 1 | 302.376 | TR00.01.0075 | Výlevka nástěnní | 0075
13192434 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 10 | 15 | 1 | 302.376 | TR00.01.0076 | Výlevka nástěnní | 0076
13192458 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 33 | 15 | 1 | 302.376 | TR00.01.0077 | Výlevka nástěnní | 0077
13192460 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 19 | 15 | 1 | 302.376 | TR00.01.0078 | Výlevka nástěnní | 0078
13192542 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 35 | 15 | 1 | 238.594 | TR00.01.0079 | Výlevka nástěnnî | 0079
13192544 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 25 | 15 | 1 | 238.594 | TR00.01.0080 | Výlevka nástěnnî | 0080
13218072 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 20 | 15 | 1 | 239.66 | TR00.01.0081 | Umyvadlo | 0081
13218074 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 25 | 15 | 1 | 239.66 | TR00.01.0082 | Umyvadlo | 0082
13218420 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 18 | 15 | 1 | 239.66 | TR00.01.0083 | Umyvadlo + modul | 0083
13218422 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 14 | 15 | 1 | 239.66 | TR00.01.0084 | Umyvadlo + modul | 0084
13218516 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 23 | 15 | 1 | 239.66 | TR00.01.0085 | Umyvadlo + modul | 0085
13218518 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 19 | 15 | 1 | 239.66 | TR00.01.0086 | Umyvadlo + modul | 0086
13218683 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 17 | 15 | 1 | 239.66 | TR00.01.0087 | Umyvadlo + modul | 0087
13218685 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 13 | 15 | 1 | 239.66 | TR00.01.0088 | Umyvadlo + modul | 0088
13279628 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 2 | 15 | 1 | 239.66 | TR00.01.0089 | Umyvadlo + modul | 0089
13279630 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 5 | 15 | 1 | 239.66 | TR00.01.0090 | Umyvadlo + modul | 0090
13279972 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 26 | 15 | 1 | 239.66 | TR00.01.0091 | Umyvadlo + modul | 0091
13279974 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 21 | 15 | 1 | 239.66 | TR00.01.0092 | Umyvadlo + modul | 0092
13281686 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 27 | 15 | 1 | 239.66 | TR00.01.0093 | Umyvadlo + modul | 0093
13281688 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 23 | 15 | 1 | 239.66 | TR00.01.0094 | Umyvadlo + modul | 0094
13281832 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 28 | 15 | 1 | 239.66 | TR00.01.0095 | Umyvadlo + modul | 0095
13281834 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 24 | 15 | 1 | 239.66 | TR00.01.0096 | Umyvadlo + modul | 0096
13286945 | -1.PP_SO-101 | ø12 mm | 0.00381 | 615 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 3 | 12 | 1 | 457.911 | TR00.01.0097 | Výlevka nástěnnð | 0097
13286958 | -1.PP_SO-101 | ø12 mm | 0.00381 | 615 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 1 | 12 | 1 | 457.911 | TR00.01.0099 | Výlevka nástěnnð | 0099
13315240 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 16 | 15 | 1 | 194.474 | TR00.01.0101 | Umyvadlo invalida s předstěnou | 0101
13315242 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 22 | 15 | 1 | 194.474 | TR00.01.0102 | Umyvadlo invalida s předstěnou | 0102
13315644 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 30 | 15 | 1 | 397.231 | TR00.01.0103 | Myčka 5 | 0103
13315646 | 3.NP_SO-101 | ø15 mm | 0.003048 | 605 | 4.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 27 | 15 | 1 | 442.395 | TR00.01.0104 | Myčka 5 | 0104
13413834 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 29 | 15 | 1 | 239.66 | TR00.01.0105 | Myčka 6 | 0105
13413836 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 26 | 15 | 1 | 239.66 | TR00.01.0106 | Myčka 6 | 0106
13413873 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 12 | 15 | 1 | 239.66 | TR00.01.0107 | Myčka 6 | 0107
13413875 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | -1.PP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 16 | 15 | 1 | 239.66 | TR00.01.0108 | Myčka 6 | 0108
13414475 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 21 | 15 | 1 | 239.66 | TR00.01.0109 | Myčka 7 | 0109
13414477 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 17 | 15 | 1 | 239.66 | TR00.01.0110 | Myčka 7 | 0110
13414531 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 31 | 15 | 1 | 239.66 | TR00.01.0111 | Myčka 7 | 0111
13414533 | -1.PP_SO-101 | ø15 mm | 0.003048 | 605 | 1.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 36 | 15 | 1 | 239.66 | TR00.01.0112 | Myčka 7 | 0112
13428033 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 6 | 15 | 1 | 239.66 | TR00.01.0113 | Umyvadlo + modul | 0113
13428035 | 2.NP_SO-101 | ø15 mm | 0.003048 | 605 | 3.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 15 | 15 | 1 | 239.66 | TR00.01.0114 | Umyvadlo + modul | 0114
13437380 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 32 | 15 | 1 | 239.66 | TR00.01.0115 | Umyvadlo | 0115
13437382 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 34 | 15 | 1 | 239.66 | TR00.01.0116 | Umyvadlo | 0116
13437486 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 33 | 15 | 1 | 239.66 | TR00.01.0117 | Umyvadlo | 0117
13437488 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 37 | 15 | 1 | 239.66 | TR00.01.0118 | Umyvadlo | 0118
13437533 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 3 | 15 | 1 | 239.66 | TR00.01.0119 | Umyvadlo + modul | 0119
13437535 | 1.NP_SO-101 | ø15 mm | 0.003048 | 605 | 2.NP_SO-101 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 12 | 15 | 1 | 239.66 | TR00.01.0120 | Umyvadlo + modul | 0120

# IfcPipeSegment: Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná) (64)
Type - Material: 032-175-175
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR03; Model: IVAR.IVCCT; Název typu: Ocel_pozink (uvnitř / vně pozinkovaná); Označení typu: 05; Popis: POZINK; Popis sestavy: Ocel pozinková; Výrobce: IVAR CS
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR03 Uniformat (Uniformat); Group: WS_Požární zavodněný 1
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Požární ochrana – vodní prostředky; Název systému: WS_Požární zavodněný 1; Typ přípoje: Obecné; Typ systému: WS_Požární zavodněný
Jiné - Rodina: Typy trubek; Páteřní trasa: yes; Id typu: 12484472; Rodina a typ: Typy trubek: Ocel_pozink (uvnitř / vně pozinkovaná); Typ: Ocel_pozink (uvnitř / vně pozinkovaná)
Name (Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná):...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Řez | Drsnost (mm) | Materiál | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení
13148822 | -1.PP_SO-101 | 4720.88 | 0.000961968 | 0.519088 | ø35 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2517.5 | 2500 | 2500 | 2482.5 | 2 | 0.1 | Kov, ocel | -666 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0516 | 0516
13148904 | -1.PP_SO-101 | 6845.5 | 0.00061566 | 0.602162 | ø28 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2514 | 2500 | 2500 | 2486 | 132 | 0.1 | Kov, ocel | -662.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0517 | 0517
13156665 | -1.PP_SO-101 | 1283.48 | 0.00061566 | 0.1129 | ø28 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2514 | 2500 | 2500 | 2486 | 132 | 0.1 | Kov, ocel | -662.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0518 | 0518
13156687 | -1.PP_SO-101 | 598.725 | 0.0004908 | 0.0470238 | ø25 mm | 0 | -1.PP_SO-101 |  | 2479.36 | 1880.64 | 2479.36 | 1880.64 | 1 | 0 |  | -1269.36 |  | 25 |  |  | ø25 | 25 | TR03.05.0519 | 0519
13158784 | -1.PP_SO-101 | 42.0671 | 0.000961968 | 0.00462552 | ø35 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2517.5 | 2500 | 2500 | 2482.5 | 180 | 0.1 | Kov, ocel | -666 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0521 | 0521
13158785 | -1.PP_SO-101 | 49.6376 | 0.000961968 | 0.00545794 | ø35 mm | 0.000257732 | -1.PP_SO-101 | 100 | 2504.92 | 2457.45 | 2492.55 | 2445.08 | 180 | 0.1 | Kov, ocel | -703.863 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0522 | 0522
13158789 | -1.PP_SO-101 | 20350.7 | 0.000961968 | 2.23768 | ø35 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2517.5 | 2500 | 2500 | 2482.5 | 2 | 0.1 | Kov, ocel | -666 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0523 | 0523
13158860 | -1.PP_SO-101 | 590.075 | 0.000961968 | 0.0648822 | ø35 mm | 0.000257732 | -1.PP_SO-101 | 0 | 2467.5 | 2450 | 2450 | 2432.5 | 180 | 0.1 | Kov, ocel | -716 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0524 | 0524
13158918 | 1.NP_SO-101 | 3427.18 | 0.000961968 | 0.376838 | ø35 mm | 0.000257732 | 1.NP_SO-101 |  | 3393.21 | -33.9693 | 3393.21 | -33.9693 | 180 | 0.1 | Kov, ocel | -33.9693 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0525 | 0525 | Identifikační data - Komentáře: P1
13159333 | 3.NP_SO-101 | 4602.11 | 0.00061566 | 0.404823 | ø28 mm | 0.000403226 | 3.NP_SO-101 |  | 3614.04 | -988.067 | 3614.04 | -988.067 | 173 | 0.1 | Kov, ocel | 7011.93 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0526 | 0526 | Identifikační data - Komentáře: P1
13159456 | 2.NP_SO-101 | 133.601 | 0.000961968 | 0.0146901 | ø35 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3417.5 | 3400 | 3400 | 3382.5 | 153 | 0.1 | Kov, ocel | 7384 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0527 | 0527
13159646 | -1.PP_SO-101 | 1789.75 | 0.000961968 | 0.196794 | ø35 mm | 0.00196078 | -1.PP_SO-101 | 0 | 2467.5 | 2450 | 2450 | 2432.5 | 180 | 0.1 | Kov, ocel | -716 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0528 | 0528
13159824 | 1.NP_SO-101 | 803.399 | 0.00061566 | 0.0706707 | ø28 mm | 0.000322581 | 1.NP_SO-101 | 0 | 3414 | 3400 | 3400 | 3386 | 183 | 0.1 | Kov, ocel | 3387.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0529 | 0529
13160077 | 1.NP_SO-101 | 2578.62 | 0.00061566 | 0.226827 | ø28 mm | 0.000322581 | 1.NP_SO-101 | 0 | 3414 | 3400 | 3400 | 3386 | 183 | 0.1 | Kov, ocel | 3387.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0530 | 0530
13160152 | 1.NP_SO-101 | 5388.18 | 0.00061566 | 0.473969 | ø28 mm | 0.000322581 | 1.NP_SO-101 | 0.0799011 | 3418.31 | 3404.31 | 3400 | 3386 | 183 | 0.1 | Kov, ocel | 3387.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0531 | 0531
13160384 | 1.NP_SO-101 | 1944.49 | 0.00061566 | 0.171046 | ø28 mm | 0.000322581 | 1.NP_SO-101 | 0 | 3418.31 | 3404.31 | 3404.31 | 3390.31 | 183 | 0.1 | Kov, ocel | 3391.81 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0532 | 0532
13161392 | 1.NP_SO-101 | 1850.43 | 0.00061566 | 0.162772 | ø28 mm | 0 | 1.NP_SO-101 |  | 3382.37 | 1531.94 | 3382.37 | 1531.94 | 183 | 0.1 | Kov, ocel | 1531.94 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0533 | 0533
13161560 | 1.NP_SO-101 | 44.5011 | 0.00061566 | 0.00391452 | ø28 mm | 0.000515464 | 1.NP_SO-101 | 0 | 1524 | 1510 | 1510 | 1496 | 183 | 0.1 | Kov, ocel | 1497.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0534 | 0534
13162357 | 2.NP_SO-101 | 372.698 | 0.00061566 | 0.0327843 | ø28 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3414 | 3400 | 3400 | 3386 | 137 | 0.1 | Kov, ocel | 7387.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0536 | 0536
13162387 | 2.NP_SO-101 | 2827.84 | 0.00061566 | 0.24875 | ø28 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3339 | 3325 | 3325 | 3311 | 137 | 0.1 | Kov, ocel | 7312.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0537 | 0537
13162399 | 2.NP_SO-101 | 6616.13 | 0.00061566 | 0.581985 | ø28 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3339 | 3325 | 3325 | 3311 | 137 | 0.1 | Kov, ocel | 7312.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0538 | 0538
13162409 | 2.NP_SO-101 | 2408.86 | 0.00061566 | 0.211894 | ø28 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3339 | 3325 | 3325 | 3311 | 137 | 0.1 | Kov, ocel | 7312.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0539 | 0539
13162421 | 2.NP_SO-101 | 176.063 | 0.00061566 | 0.0154873 | ø28 mm | 0.00196078 | 2.NP_SO-101 | 0 | 3339 | 3325 | 3325 | 3311 | 137 | 0.1 | Kov, ocel | 7312.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0540 | 0540
13162451 | 2.NP_SO-101 | 65.2687 | 0.00061566 | 0.00574134 | ø28 mm | 0.004 | 2.NP_SO-101 | 0 | 1524 | 1510 | 1510 | 1496 | 137 | 0.1 | Kov, ocel | 5497.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0541 | 0541
13162763 | 2.NP_SO-101 | 1771.13 | 0.00061566 | 0.155796 | ø28 mm | 0 | 2.NP_SO-101 |  | 3303.06 | 3303.06 | 1531.94 | 1531.94 | 137 | 0.1 | Kov, ocel | 5531.94 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0542 | 0542
13163312 | 3.NP_SO-101 | 929.024 | 0.00061566 | 0.0817212 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3649.98 | 3635.98 | 3635.98 | 3621.98 | 173 | 0.1 | Kov, ocel | 11623.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0543 | 0543
13163329 | 3.NP_SO-101 | 1056.13 | 0.00061566 | 0.0929016 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3649.98 | 3635.98 | 3635.98 | 3621.98 | 173 | 0.1 | Kov, ocel | 11623.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0544 | 0544
13163355 | 3.NP_SO-101 | 5359.74 | 0.00061566 | 0.471467 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 187 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0545 | 0545
13163363 | 3.NP_SO-101 | 2028.62 | 0.00061566 | 0.178447 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 187 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0546 | 0546
13163373 | 3.NP_SO-101 | 184.389 | 0.00061566 | 0.0162197 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 187 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0547 | 0547
13163460 | 3.NP_SO-101 | 119.533 | 0.00061566 | 0.0105147 | ø28 mm | 0.004 | 3.NP_SO-101 | 0 | 1524 | 1510 | 1510 | 1496 | 187 | 0.1 | Kov, ocel | 9497.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0548 | 0548
13163511 | 3.NP_SO-101 | 1896.13 | 0.00061566 | 0.166792 | ø28 mm | 0 | 3.NP_SO-101 |  | 3428.06 | 1531.94 | 3428.06 | 1531.94 | 187 | 0.1 | Kov, ocel | 9531.94 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0549 | 0549
13163717 | 3.NP_SO-101 | 2381.62 | 0.00061566 | 0.209498 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 185 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0550 | 0550
13163730 | 3.NP_SO-101 | 1467.17 | 0.00061566 | 0.129059 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3464 | 3450 | 3450 | 3436 | 173 | 0.1 | Kov, ocel | 11437.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0551 | 0551
13163750 | 3.NP_SO-101 | 476.604 | 0.00061566 | 0.0419243 | ø28 mm | 0.003125 | 3.NP_SO-101 | 0 | 3664 | 3650 | 3650 | 3636 | 185 | 0.1 | Kov, ocel | 11637.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0552 | 0552
13164109 | 4.NP_SO-101 | 3322.1 | 0.00061566 | 0.292227 | ø28 mm | 0 | 4.NP_SO-101 |  | 2994.04 | 2994.04 | -328.063 | -328.063 | 185 | 0.1 | Kov, ocel | 11671.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0553 | 0553 | Identifikační data - Komentáře: P1
13164294 | 4.NP_SO-101 | 416.125 | 0.00061566 | 0.0366043 | ø28 mm | 0.003125 | 4.NP_SO-101 | 0 | 3029.98 | 3015.98 | 3015.98 | 3001.98 | 185 | 0.1 | Kov, ocel | 15003.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0554 | 0554 | Identifikační data - Komentáře: P1
13164308 | 4.NP_SO-101 | 1435.58 | 0.00061566 | 0.12628 | ø28 mm | 0.003125 | 4.NP_SO-101 | 0 | 3029.98 | 3015.98 | 3015.98 | 3001.98 | 185 | 0.1 | Kov, ocel | 15003.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0555 | 0555
13164320 | 4.NP_SO-101 | 3460.47 | 0.00061566 | 0.304399 | ø28 mm | 0.003125 | 4.NP_SO-101 | 0 | 3029.98 | 3015.98 | 3015.98 | 3001.98 | 185 | 0.1 | Kov, ocel | 15003.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0556 | 0556
13164328 | 4.NP_SO-101 | 295.576 | 0.00061566 | 0.0260002 | ø28 mm | 0.003125 | 4.NP_SO-101 | 0 | 3029.98 | 3015.98 | 3015.98 | 3001.98 | 185 | 0.1 | Kov, ocel | 15003.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0557 | 0557
13164360 | 4.NP_SO-101 | 81.8123 | 0.00061566 | 0.00719658 | ø28 mm | 0.004 | 4.NP_SO-101 | 0 | 1524 | 1510 | 1510 | 1496 | 185 | 0.1 | Kov, ocel | 13497.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0558 | 0558
13164435 | 4.NP_SO-101 | 1462.1 | 0.00061566 | 0.128613 | ø28 mm | 0 | 4.NP_SO-101 |  | 2994.04 | 1531.94 | 2994.04 | 1531.94 | 185 | 0.1 | Kov, ocel | 13531.9 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0559 | 0559
13373946 | 2.NP_SO-101 | 61.961 | 0.000961968 | 0.00681296 | ø35 mm | 0.003125 | 2.NP_SO-101 | 0 | 3417.5 | 3400 | 3400 | 3382.5 | 172 | 0.1 | Kov, ocel | 7384 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0814 | 0814
13373960 | 2.NP_SO-101 | 844.847 | 0.000961968 | 0.0928957 | ø35 mm | 0.003125 | 2.NP_SO-101 | 0 | 3417.5 | 3400 | 3400 | 3382.5 | 153 | 0.1 | Kov, ocel | 7384 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0815 | 0815
13374729 | 2.NP_SO-101 | 352.779 | 0.000961968 | 0.0387901 | ø35 mm | 0.003125 | 2.NP_SO-101 |  | 3368.21 | 3015.43 | 3368.21 | 3015.43 | 171 | 0.1 | Kov, ocel | 7015.43 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0821 | 0821
13374731 | 2.NP_SO-101 | 102.557 | 0.000961968 | 0.0112767 | ø35 mm | 0.003125 | 2.NP_SO-101 | 0 | 3007.5 | 2990 | 2990 | 2972.5 | 171 | 0.1 | Kov, ocel | 6974 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0822 | 0822
13377087 | 2.NP_SO-101 | 31.125 | 0.00061566 | 0.0027379 | ø28 mm | 0 | 2.NP_SO-101 |  | 3378.06 | 3378.06 | 3346.94 | 3346.94 | 137 | 0.1 | Kov, ocel | 7346.94 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0824 | 0824
13381079 | 1.NP_SO-101 | 13.0255 | 0.00061566 | 0.00114579 | ø28 mm | 0 | 1.NP_SO-101 |  | 3378.06 | 3378.06 | 3365.04 | 3365.04 | 183 | 0.1 | Kov, ocel | 3365.04 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0840 | 0840
13381511 | -1.PP_SO-101 | 348.174 | 0.000961968 | 0.0382837 | ø35 mm | 0.003125 | -1.PP_SO-101 | 0 | 2749.16 | 2731.66 | 2731.66 | 2714.16 | 180 | 0.1 | Kov, ocel | -434.34 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0841 | 0841
13381660 | -1.PP_SO-101 | 58.6365 | 0.000961968 | 0.00644742 | ø35 mm | 0.003125 | -1.PP_SO-101 | 0 | 2749.16 | 2731.66 | 2731.66 | 2714.16 | 180 | 0.1 | Kov, ocel | -434.34 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0842 | 0842
13381898 | -1.PP_SO-101 | 230.785 | 0.000961968 | 0.0253761 | ø35 mm | 0 | -1.PP_SO-101 |  | 2706.22 | 2475.44 | 2706.22 | 2475.44 | 180 | 0.1 | Kov, ocel | -674.562 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0847 | 0847
13382302 | 1.NP_SO-101 | 287.86 | 0.000961968 | 0.0316519 | ø35 mm | 0.003125 | 1.NP_SO-101 |  | -105.042 | -105.042 | -392.903 | -392.903 | 180 | 0.1 | Kov, ocel | -392.903 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0851 | 0851 | Identifikační data - Komentáře: P1
13382990 | 1.NP_SO-101 | 49.6376 | 0.000961968 | 0.00545794 | ø35 mm | 0.003125 | 1.NP_SO-101 | 100 | -39.582 | -51.9563 | -87.0554 | -99.4297 | 180 | 0.1 | Kov, ocel | -98.3691 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0857 | 0857
13383133 | 1.NP_SO-101 | 19.5896 | 0.00061566 | 0.00172319 | ø28 mm | 0.003125 | 1.NP_SO-101 | 0 | 3439 | 3425 | 3425 | 3411 | 183 | 0.1 | Kov, ocel | 3412.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0858 | 0858
13383142 | 2.NP_SO-101 | 3917.78 | 0.000961968 | 0.430782 | ø35 mm | 0.003125 | 2.NP_SO-101 |  | 3374.56 | -543.213 | 3374.56 | -543.213 | 153 | 0.1 | Kov, ocel | 3456.79 | Zn | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 32 | TR03.05.0859 | 0859 | Identifikační data - Komentáře: P1
13383145 | 1.NP_SO-101 | 271.913 | 0.00061566 | 0.0239187 | ø28 mm | 0.003125 | 1.NP_SO-101 | 0 | 3357.1 | 3343.1 | 3343.1 | 3329.1 | 183 | 0.1 | Kov, ocel | 3330.6 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0860 | 0860
13383214 | 1.NP_SO-101 | 38.0255 | 0.00061566 | 0.0033449 | ø28 mm | 0 | 1.NP_SO-101 |  | 3403.06 | 3365.04 | 3403.06 | 3365.04 | 183 | 0.1 | Kov, ocel | 3365.04 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0861 | 0861
13425561 | 3.NP_SO-101 | 1598.09 | 0.00061566 | 0.140576 | ø28 mm | 0.004 | 3.NP_SO-101 | 0 | 3649.98 | 3635.98 | 3635.98 | 3621.98 | 173 | 0.1 | Kov, ocel | 11623.5 | Zn | 28 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 25 | TR03.05.0890 | 0890
