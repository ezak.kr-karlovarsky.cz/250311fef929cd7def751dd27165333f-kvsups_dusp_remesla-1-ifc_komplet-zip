Properties of the parts of a building model (IFC4), part 25 of 26

# IfcPipeSegment: Typy trubek:PP_Skolan SAFE dB (179)
Name (Typy trubek:PP_Skolan SAFE dB:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
13288563 | 3.NP_SO-101 | 272.79 | 0.00477764 | 0.0668457 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 3236 | 3208.43 | 3015.53 | 2987.96 | Sanitární | SW_Splašky vnitřní gravitační 10 | 10991.1 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0796 | 0796 | yes | 100
13288774 | 3.NP_SO-101 | 422.18 | 0.00477764 | 0.103453 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 3663.79 | 3663.79 | 3241.61 | 3241.61 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11241.6 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0797 | 0797 | yes
13288976 | 4.NP_SO-101 | 5745.44 | 0.00477764 | 1.40789 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 268.275 | 114.397 | 229.283 | 75.4046 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12079.9 | 78 | 209 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0798 | 0798 | no | 2 | Identifikační data - Komentáře: VEDENO VE ZVYŠENÉ PODLAZE; Cena instance: 0
13288992 | 4.NP_SO-101 | 1061.84 | 0.00477764 | 0.260197 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 152.612 | 92.3869 | 113.619 | 53.3947 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12057.9 | 78 | 209 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0799 | 0799 | no | 2
13289002 | 4.NP_SO-101 | 205.882 | 0.00477764 | 0.0504503 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 130.602 | 87.4928 | 91.6096 | 48.5006 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12053 | 78 | 209 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0800 | 0800 | no | 2
13289159 | 4.NP_SO-101 | 897.525 | 0.00477764 | 0.219933 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 73.381 | 16.4419 | 34.3888 | -22.5503 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11981.9 | 78 | 208 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0801 | 0801 | no | 2
13289182 | 4.NP_SO-101 | 242.728 | 0.00477764 | 0.0594792 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 30.2808 | 2.70362 | -168.931 | -196.508 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11806.7 | 78 | 208 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0802 | 0802 | no | 100
13289241 | 4.NP_SO-101 | 180.796 | 0.00477764 | 0.0443031 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 40.5647 | 40.5647 | -140.232 | -140.232 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11859.8 | 78 | 209 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0803 | 0803 | no
13289829 | -1.PP_SO-101 | 391.656 | 0.0143117 | 0.166107 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2527.96 | 2460.48 | 2452.64 | 2385.16 | Sanitární | SW_Splašky vnitřní gravitační 10 | -759.543 | 135 | 215 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0804 | 0804 | yes | 2
13289830 | -1.PP_SO-101 | 152.597 | 0.0143117 | 0.0647188 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2638.19 | 2482.56 | 2590.46 | 2434.83 | Sanitární | SW_Splašky vnitřní gravitační 10 | -711.426 | 135 | 215 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0805 | 0805 | yes | 100
13291386 | 4.NP_SO-101 | 477.063 | 0.00950189 | 0.164861 | ø110 mm |  | 0.000100604 | G | JD | 4.NP_SO-101 | 2505.36 | 2505.36 | 2028.29 | 2028.29 | Průduch | SW_Odvětrání kanalizace 10 | 14028.3 | 110 | 3 | SW_Odvětrání kanalizace | ø110 | 99.4 | TR08.01.0808 | 0808 | yes | Identifikační data - Komentáře: S4
13291405 | 4.NP_SO-101 | 474.125 | 0.00950189 | 0.163846 | ø110 mm |  | 0.000100604 | G | JD | 4.NP_SO-101 | 2623.29 | 2568.29 | 2568.29 | 2513.29 | Průduch | SW_Odvětrání kanalizace 10 | 14518.6 | 110 | 3 | SW_Odvětrání kanalizace | ø110 | 99.4 | TR08.01.0809 | 0809 | yes | 0
13429428 | 1.NP_SO-101 | 158.586 | 0.00477764 | 0.0388607 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 56.0394 | -83.6753 | 28.4622 | -111.252 | Sanitární | SW_Splašky vnitřní gravitační 10 | -108.07 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0906 | 0906 | yes | 100
13429454 | 1.NP_SO-101 | 68.2572 | 0.00477764 | 0.016726 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | -377.505 | -453.347 | -405.082 | -480.925 | Sanitární | SW_Splašky vnitřní gravitační 10 | -477.743 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0907 | 0907 | yes | 100
13429510 | 1.NP_SO-101 | 255.027 | 0.00477764 | 0.062493 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | -116.865 | -371.893 | -116.865 | -371.893 | Sanitární | SW_Splašky vnitřní gravitační 10 | -371.893 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0908 | 0908 | yes
13429579 | 1.NP_SO-101 | 214.622 | 0.00477764 | 0.0525919 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | -433.69 | -476.974 | -472.683 | -515.966 | Sanitární | SW_Splašky vnitřní gravitační 10 | -511.467 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0909 | 0909 | yes | 2
13429888 | 1.NP_SO-101 | 362.497 | 0.00477764 | 0.0888277 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | -68.3311 | -430.83 | -68.3327 | -430.831 | Sanitární | SW_Splašky vnitřní gravitační 10 | -430.831 | 78 | 83 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0910 | 0910 | yes
13429970 | 1.NP_SO-101 | 95.4637 | 0.00477764 | 0.0233928 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 59.9378 | -35.1423 | 32.3607 | -62.7195 | Sanitární | SW_Splašky vnitřní gravitační 10 | -59.5375 | 78 | 83 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0911 | 0911 | yes | 100
13430415 | 2.NP_SO-101 | 305.704 | 0.00950189 | 0.105644 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | -4228.41 | -4228.41 | -4534.11 | -4534.11 | Sanitární | SW_Splašky vnitřní gravitační 10 | -534.11 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0913 | 0913 | yes
13430521 | 2.NP_SO-101 | 31.1393 | 0.00950189 | 0.010761 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | -4539.72 | -4600.63 | -4578.61 | -4639.52 | Sanitární | SW_Splašky vnitřní gravitační 10 | -635.776 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0914 | 0914 | yes | 100
13430534 | 2.NP_SO-101 | 66.3168 | 0.00950189 | 0.0229174 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | -4564.06 | -4620.38 | -4619.05 | -4675.37 | Sanitární | SW_Splašky vnitřní gravitační 10 | -670.07 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0915 | 0915 | yes | 2.00002
13430579 | -1.PP_SO-101 | 916.995 | 0.0143117 | 0.388911 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2513.46 | 2445.97 | 2427.64 | 2360.15 | Sanitární | SW_Splašky vnitřní gravitační 10 | -784.552 | 135 | 92 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0916 | 0916 | yes | 2
13430595 | 2.NP_SO-101 | 101.662 | 0.00950189 | 0.0351318 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | -4108.46 | -4165.48 | -4163.45 | -4220.47 | Sanitární | SW_Splašky vnitřní gravitační 10 | -215.171 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0917 | 0917 | yes | 2
13431435 | -1.PP_SO-101 | 2439.27 | 0.0143117 | 1.03453 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2876.18 | 2759.92 | 2808.69 | 2692.43 | Sanitární | SW_Splašky vnitřní gravitační 10 | -452.27 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0918 | 0918 | yes | 1.99999
13431589 | -1.PP_SO-101 | 485.385 | 0.0143117 | 0.205859 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2785.57 | 2394.62 | 2737.84 | 2346.89 | Sanitární | SW_Splašky vnitřní gravitační 10 | -799.363 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0919 | 0919 | yes | 100
13432372 | 3.NP_SO-101 | 5948.21 | 0.00477764 | 1.45757 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 1527.23 | -4420.98 | 1527.23 | -4420.98 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3579.02 | 78 | 226 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0922 | 0922 | yes | Identifikační data - Komentáře: S3
13432617 | 3.NP_SO-101 | 32.7355 | 0.00477764 | 0.00802164 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | -4426.6 | -4477.32 | -4454.17 | -4504.9 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3498.28 | 78 | 226 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0923 | 0923 | yes | 100
13432815 | 1.NP_SO-101 | 162.715 | 0.00477764 | 0.0398725 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3541.27 | 3480.52 | 3502.63 | 3441.88 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3446.34 | 78 | 226 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0924 | 0924 | yes | 13.716
13432981 | 3.NP_SO-101 | 1701.87 | 0.00477764 | 0.417033 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 1306.3 | -395.564 | 1306.3 | -395.564 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7604.44 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0925 | 0925 | no | Identifikační data - Komentáře: S2
13433022 | 3.NP_SO-101 | 243.958 | 0.00477764 | 0.0597806 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | -401.177 | -428.754 | -601.259 | -628.836 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7374.35 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0926 | 0926 |  | 100
13438413 | 3.NP_SO-101 | 380.705 | 0.00950189 | 0.131562 | ø110 mm | 0 | 0.000100604 | F | JB | 3.NP_SO-101 | 3414.48 | 3351.88 | 3359.49 | 3296.89 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11302.2 | 110 | 227 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0956 | 0956 | yes | 2
13438421 | 3.NP_SO-101 | 1147.41 | 0.00950189 | 0.396517 | ø110 mm | 0 | 0.000100604 | G | JD | 3.NP_SO-101 | 3405.9 | 3327.97 | 3350.92 | 3272.98 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11278.3 | 110 | 227 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0957 | 0957 | yes | 2

# IfcPipeSegment: Typy trubek:PVC-U_KG systém (116)
In: -1.PP_SO-101
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR06; Název typu: PVC-U_KG systém; Označení typu: 03; Popis: PVC-U; Popis sestavy: Polyvinyl chlorid (PVC); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Instalační jednotky: 0
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Referenční podlaží: -1.PP_SO-101; Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Drsnost: 0.125 mm; Klasifikace systému: Sanitární; Materiál: PVC–U_KG SYSTEM; Popis úseku: PVC–KGEM SN4; Typ přípoje: Obecné; Úsek potrubí: PVC–U_KG SYSTEM - SN4; Výkaz/typ: SN4
Jiné - Rodina: Typy trubek; Páteřní trasa: yes; Id typu: 9442186; Rodina a typ: Typy trubek: PVC-U_KG systém; Typ: PVC-U_KG systém
Name (Typy trubek:PVC-U_KG systém:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Sklon | Spodní výška (mm) | Střední výška (mm) | Název systému | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Group
13101677 | 610.087 | 0.00950189 | 0.210831 | ø110 mm | 0.00120656 | -1631.74 | -1686.73 | -1698.93 | 2 | -1753.92 | -1698.93 | SW_Splašky vnitřní gravitační 81 | -4900.72 | 110 | 33 | ø110 | 103.6 | TR06.03.0416 | 0416 | SW_Splašky vnitřní gravitační 81
13101732 | 510.068 | 0.00950189 | 0.176267 | ø110 mm | 0.00120656 | -1714.29 | -1769.28 | -1779.48 | 2 | -1834.46 | -1779.48 | SW_Splašky vnitřní gravitační 81 | -4981.27 | 110 | 35 | ø110 | 103.6 | TR06.03.0417 | 0417 | SW_Splašky vnitřní gravitační 81
13101746 | 1275.4 | 0.00950189 | 0.440745 | ø110 mm | 0.00120656 | -1648.97 | -1703.95 | -1729.46 | 2 | -1784.45 | -1729.46 | SW_Splašky vnitřní gravitační 81 | -4931.25 | 110 | 30 | ø110 | 103.6 | TR06.03.0418 | 0418 | SW_Splašky vnitřní gravitační 81
13101784 | 1128.18 | 0.00950189 | 0.38987 | ø110 mm | 0.00120656 | -1329.3 | -1384.29 | -1406.85 | 2 | -1461.84 | -1406.85 | SW_Splašky vnitřní gravitační 81 | -4608.64 | 110 | 39 | ø110 | 103.6 | TR06.03.0419 | 0419 | SW_Splašky vnitřní gravitační 81
13101800 | 866.012 | 0.00950189 | 0.299272 | ø110 mm | 0.00120656 | -1310.94 | -1365.93 | -1383.25 | 2 | -1438.24 | -1383.25 | SW_Splašky vnitřní gravitační 81 | -4585.04 | 110 | 39 | ø110 | 103.6 | TR06.03.0420 | 0420 | SW_Splašky vnitřní gravitační 81
13101840 | 387.15 | 0.00950189 | 0.13379 | ø110 mm | 0.00120656 | -1606.11 | -1661.1 | -1668.84 | 2 | -1723.83 | -1668.84 | SW_Splašky vnitřní gravitační 4 | -4870.63 | 110 | 12 | ø110 | 103.6 | TR06.03.0421 | 0421 | SW_Splašky vnitřní gravitační 4
13101852 | 3888.29 | 0.00950189 | 1.3437 | ø110 mm | 0.00120656 | -1452.1 | -1507.09 | -1584.84 | 2 | -1639.83 | -1584.84 | SW_Splašky vnitřní gravitační 4 | -4786.63 | 110 | 17 | ø110 | 103.6 | TR06.03.0422 | 0422 | SW_Splašky vnitřní gravitační 4
13101986 | 3540.37 | 0.00950189 | 1.22346 | ø110 mm | 0.00120656 | -1689.63 | -1815.41 | -1744.62 | 2 | -1870.4 | -1744.62 | SW_Splašky vnitřní gravitační 8 | -5017.2 | 110 | 18 | ø110 | 103.6 | TR06.03.0423 | 0423 | SW_Splašky vnitřní gravitační 8
13101995 | 1037.08 | 0.00950189 | 0.358391 | ø110 mm | 0.00120656 | -1630.94 | -1685.93 | -1706.66 | 2 | -1761.65 | -1706.66 | SW_Splašky vnitřní gravitační 8 | -4908.45 | 110 | 16 | ø110 | 103.6 | TR06.03.0424 | 0424 | SW_Splašky vnitřní gravitační 8
13102961 | 290.175 | 0.00950189 | 0.100277 | ø110 mm | 0.00120656 | -1770.83 | -1831.62 | -1825.82 | 2 | -1886.61 | -1825.82 | SW_Splašky vnitřní gravitační 8 | -5033.41 | 110 | 6 | ø110 | 103.6 | TR06.03.0425 | 0425 | SW_Splašky vnitřní gravitační 8
13118326 | 8.0477 | 0.00950189 | 0.00278109 | ø110 mm | 0.00120656 | -1714.59 | -1768.99 | -1770.18 | 15 | -1824.57 | -1770.18 | SW_Splašky vnitřní gravitační 4 | -4971.41 | 110 | 1 | ø110 | 103.6 | TR06.03.0427 | 0427 | SW_Splašky vnitřní gravitační 4
13118823 | 4.37247 | 0.00950189 | 0.00151102 | ø110 mm | 0.00120656 | -1715.88 | -1770.88 | -1770.88 | 0 | -1825.88 | -1770.88 | SW_Splašky vnitřní gravitační 4 | -4972.68 | 110 | 1 | ø110 | 103.6 | TR06.03.0428 | 0428 | SW_Splašky vnitřní gravitační 4
13119455 | 4700.75 | 0.00950189 | 1.62446 | ø110 mm | 0.00120656 | -1619.32 | -1674.31 | -1768.3 | 1.99999 | -1823.29 | -1768.3 | SW_Splašky vnitřní gravitační 4 | -4970.09 | 110 | 1 | ø110 | 103.6 | TR06.03.0429 | 0429 | SW_Splašky vnitřní gravitační 4
13119652 | 14.8972 | 0.00950189 | 0.0051481 | ø110 mm | 0.00120656 | -1778.27 | -1832.5 | -1834.99 | 16.9728 | -1889.21 | -1834.99 | SW_Splašky vnitřní gravitační 8 | -5036.06 | 110 | 6 | ø110 | 103.6 | TR06.03.0430 | 0430 | SW_Splašky vnitřní gravitační 8
13119665 | 22.4551 | 0.00950189 | 0.00775992 | ø110 mm | 0.00120656 | -1780.88 | -1835.88 | -1835.88 | 0 | -1890.88 | -1835.88 | SW_Splašky vnitřní gravitační 8 | -5037.68 | 110 | 6 | ø110 | 103.6 | TR06.03.0431 | 0431 | SW_Splašky vnitřní gravitační 8
13120221 | 195.187 | 0.00950189 | 0.0674519 | ø110 mm | 0.00120656 | -1761.46 | -1816.45 | -1820.35 | 2 | -1875.34 | -1820.35 | SW_Splašky vnitřní gravitační 8 | -5022.14 | 110 | 18 | ø110 | 103.6 | TR06.03.0432 | 0432 | SW_Splašky vnitřní gravitační 8
13120294 | 357.885 | 0.00950189 | 0.123676 | ø110 mm | 0.00120656 | -1055.56 | -1094.45 | -1347.51 | 100 | -1386.4 | -1347.51 | SW_Splašky vnitřní gravitační 81 | -4534.14 | 110 | 39 | ø110 | 103.6 | TR06.03.0433 | 0433 | SW_Splašky vnitřní gravitační 81
13120517 | 6.9232 | 0.00950189 | 0.00239249 | ø110 mm | 0.00120656 | -1779.49 | -1833.59 | -1834.84 | 18.3832 | -1888.93 | -1834.84 | SW_Splašky vnitřní gravitační 81 | -5035.79 | 110 | 24 | ø110 | 103.6 | TR06.03.0434 | 0434 | SW_Splašky vnitřní gravitační 81
13120532 | 6.66222 | 0.00950189 | 0.0023023 | ø110 mm | 0.00120656 | -1780.88 | -1835.88 | -1835.88 | 0 | -1890.88 | -1835.88 | SW_Splašky vnitřní gravitační 81 | -5037.68 | 110 | 24 | ø110 | 103.6 | TR06.03.0435 | 0435 | SW_Splašky vnitřní gravitační 81
13125170 | 984.812 | 0.00950189 | 0.340327 | ø110 mm | 0.00120656 | -1075 | -1130 | -1130 | 0 | -1185 | -1130 | SW_Splašky vnitřní gravitační 10 | -4331.8 | 110 | 193 | ø110 | 103.6 | TR06.03.0436 | 0436 | SW_Splašky vnitřní gravitační 10
13125183 | 327.939 | 0.00950189 | 0.113327 | ø110 mm | 0.00120656 | -1192.93 | -1192.94 | -1520.88 |  | -1520.88 | -1520.88 | SW_Splašky vnitřní gravitační 10 | -4670.88 | 110 | 193 | ø110 | 103.6 | TR06.03.0437 | 0437 | SW_Splašky vnitřní gravitační 10; SW_Splašky čerpání 1
13125408 | 3110.22 | 0.00950189 | 1.07481 | ø110 mm | 0.00120656 | 2581.06 | -529.155 | 2581.06 |  | -529.155 | 2581.06 | SW_Splašky vnitřní gravitační 10 | -3679.15 | 110 | 193 | ø110 | 103.6 | TR06.03.0438 | 0438 | SW_Splašky vnitřní gravitační 10
13125530 | 760.716 | 0.00950189 | 0.262885 | ø110 mm | 0.00120656 | -534.768 | -1111.57 | -573.658 | 100 | -1150.46 | -573.658 | SW_Splašky vnitřní gravitační 10 | -4298.19 | 110 | 193 | ø110 | 103.6 | TR06.03.0439 | 0439 | SW_Splašky vnitřní gravitační 10
13125606 | 2387.6 | 0.00950189 | 0.825096 | ø110 mm | 0.00120656 | -1075 | -1130 | -1130 | 0 | -1185 | -1130 | SW_Splašky vnitřní gravitační 10 | -4331.8 | 110 | 193 | ø110 | 103.6 | TR06.03.0440 | 0440 | SW_Splašky vnitřní gravitační 10
13125680 | 211.009 | 0.00950189 | 0.0729193 | ø110 mm | 0.00120656 | -1075 | -1130 | -1130 | 0 | -1185 | -1130 | SW_Splašky vnitřní gravitační 10 | -4331.8 | 110 | 193 | ø110 | 103.6 | TR06.03.0441 | 0441 | SW_Splašky vnitřní gravitační 10
13125690 | 963.627 | 0.00950189 | 0.333005 | ø110 mm | 0.00120656 | -1075 | -1130 | -1130 | 0 | -1185 | -1130 | SW_Splašky vnitřní gravitační 10 | -4331.8 | 110 | 193 | ø110 | 103.6 | TR06.03.0442 | 0442 | SW_Splašky vnitřní gravitační 10
13125747 | 1045.57 | 0.00950189 | 0.361322 | ø110 mm | 0.00120656 | -1506.86 | -1561.85 | -1582.76 | 2 | -1637.75 | -1582.76 | SW_Splašky vnitřní gravitační 8 | -4784.55 | 110 | 14 | ø110 | 103.6 | TR06.03.0443 | 0443 | SW_Splašky vnitřní gravitační 8
13125795 | 1937.24 | 0.00950189 | 0.669461 | ø110 mm | 0.00120656 | 438.31 | 438.309 | -1498.93 | 5468189 | -1498.93 | -1498.93 | SW_Splašky vnitřní gravitační 8 | -4648.93 | 110 | 14 | ø110 | 103.6 | TR06.03.0444 | 0444 | SW_Splašky vnitřní gravitační 8
13125810 | 515.616 | 0.00950189 | 0.178184 | ø110 mm | 0.00120656 | -1543.83 | -1598.82 | -1609.13 | 2 | -1664.12 | -1609.13 | SW_Splašky vnitřní gravitační 8 | -4810.92 | 110 | 23 | ø110 | 103.6 | TR06.03.0445 | 0445 | SW_Splašky vnitřní gravitační 8
13125819 | 1938.71 | 0.00950189 | 0.669972 | ø110 mm | 0.00120656 | -1559.6 | -1614.59 | -1653.36 | 2 | -1708.35 | -1653.36 | SW_Splašky vnitřní gravitační 8 | -4855.15 | 110 | 10 | ø110 | 103.6 | TR06.03.0446 | 0446 | SW_Splašky vnitřní gravitační 8
13125824 | 1194.4 | 0.00950189 | 0.412754 | ø110 mm | 0.00120656 | -1518.9 | -1573.89 | -1597.78 | 2 | -1652.76 | -1597.78 | SW_Splašky vnitřní gravitační 8 | -4799.57 | 110 | 23 | ø110 | 103.6 | TR06.03.0447 | 0447 | SW_Splašky vnitřní gravitační 8
13125901 | 1763.5 | 0.00950189 | 0.609421 | ø110 mm | 0.00120656 | 438.31 | 438.309 | -1325.19 |  | -1325.19 | -1325.19 | SW_Splašky vnitřní gravitační 8 | -4475.19 | 110 | 22 | ø110 | 103.6 | TR06.03.0448 | 0448 | SW_Splašky vnitřní gravitační 8
13125952 | 318.825 | 0.00950189 | 0.110178 | ø110 mm | 0.00120656 | -1592 | -1646.98 | -1653.36 | 2 | -1708.35 | -1653.36 | SW_Splašky vnitřní gravitační 8 | -4855.15 | 110 | 13 | ø110 | 103.6 | TR06.03.0449 | 0449 | SW_Splašky vnitřní gravitační 8
13125961 | 1303.24 | 0.00950189 | 0.450369 | ø110 mm | 0.00120656 | -1603.84 | -1658.82 | -1684.88 | 2 | -1739.87 | -1684.88 | SW_Splašky vnitřní gravitační 8 | -4886.67 | 110 | 16 | ø110 | 103.6 | TR06.03.0450 | 0450 | SW_Splašky vnitřní gravitační 8
13125966 | 206.687 | 0.00950189 | 0.071426 | ø110 mm | 0.00120656 | -1586.82 | -1641.81 | -1645.94 | 2 | -1700.93 | -1645.94 | SW_Splašky vnitřní gravitační 8 | -4847.73 | 110 | 13 | ø110 | 103.6 | TR06.03.0451 | 0451 | SW_Splašky vnitřní gravitační 8
13125983 | 1221.33 | 0.00950189 | 0.422063 | ø110 mm | 0.00120656 | -1503.35 | -1558.34 | -1582.76 | 2 | -1637.75 | -1582.76 | SW_Splašky vnitřní gravitační 8 | -4784.55 | 110 | 15 | ø110 | 103.6 | TR06.03.0452 | 0452 | SW_Splašky vnitřní gravitační 8
13125992 | 1045.38 | 0.00950189 | 0.361256 | ø110 mm | 0.00120656 | -1533.24 | -1588.22 | -1609.13 | 2 | -1664.12 | -1609.13 | SW_Splašky vnitřní gravitační 8 | -4810.92 | 110 | 9 | ø110 | 103.6 | TR06.03.0453 | 0453 | SW_Splašky vnitřní gravitační 8
13126036 | 1933.72 | 0.00950189 | 0.668246 | ø110 mm | 0.00120656 | 438.311 | 438.309 | -1495.41 | 2745613 | -1495.42 | -1495.41 | SW_Splašky vnitřní gravitační 8 | -4645.42 | 110 | 15 | ø110 | 103.6 | TR06.03.0454 | 0454 | SW_Splašky vnitřní gravitační 8
13126181 | 197.076 | 0.00950189 | 0.0681047 | ø110 mm | 0.00120656 | -1680.22 | -1735.21 | -1739.15 | 2 | -1794.14 | -1739.15 | SW_Splašky vnitřní gravitační 8 | -4940.94 | 110 | 26 | ø110 | 103.6 | TR06.03.0455 | 0455 | SW_Splašky vnitřní gravitační 8
13126190 | 1572.55 | 0.00950189 | 0.543436 | ø110 mm | 0.00120656 | -1652.72 | -1739.15 | -1707.71 | 2 | -1794.14 | -1707.71 | SW_Splašky vnitřní gravitační 8 | -4940.94 | 110 | 16 | ø110 | 103.6 | TR06.03.0456 | 0456 | SW_Splašky vnitřní gravitační 8
13126193 | 1568.9 | 0.00950189 | 0.542171 | ø110 mm | 0.00120656 | -1647.81 | -1702.8 | -1734.17 | 2 | -1789.16 | -1734.17 | SW_Splašky vnitřní gravitační 8 | -4935.96 | 110 | 26 | ø110 | 103.6 | TR06.03.0457 | 0457 | SW_Splašky vnitřní gravitační 8
13126203 | 393.933 | 0.00950189 | 0.136133 | ø110 mm | 0.00120656 | -1638.89 | -1693.88 | -1701.75 | 2 | -1756.74 | -1701.75 | SW_Splašky vnitřní gravitační 8 | -4903.54 | 110 | 26 | ø110 | 103.6 | TR06.03.0458 | 0458 | SW_Splašky vnitřní gravitační 8
13126228 | 1957.03 | 0.00950189 | 0.676301 | ø110 mm | 0.00120656 | -1598.71 | -1692.83 | -1653.7 | 2 | -1747.82 | -1653.7 | SW_Splašky vnitřní gravitační 8 | -4894.62 | 110 | 26 | ø110 | 103.6 | TR06.03.0459 | 0459 | SW_Splašky vnitřní gravitační 8
13126315 | 533.089 | 0.00950189 | 0.184222 | ø110 mm | 0.00120656 | -1584.26 | -1639.25 | -1649.91 | 2 | -1704.9 | -1649.91 | SW_Splašky vnitřní gravitační 81 | -4851.7 | 110 | 11 | ø110 | 103.6 | TR06.03.0460 | 0460 | SW_Splašky vnitřní gravitační 81
13126324 | 305.107 | 0.00950189 | 0.105437 | ø110 mm | 0.00120656 | -1600.38 | -1655.37 | -1661.47 | 2 | -1716.46 | -1661.47 | SW_Splašky vnitřní gravitační 81 | -4863.26 | 110 | 3 | ø110 | 103.6 | TR06.03.0461 | 0461 | SW_Splašky vnitřní gravitační 81
13126329 | 1267.84 | 0.00950189 | 0.438133 | ø110 mm | 0.00120656 | -1557.86 | -1612.85 | -1638.21 | 2 | -1693.19 | -1638.21 | SW_Splašky vnitřní gravitační 81 | -4840 | 110 | 11 | ø110 | 103.6 | TR06.03.0462 | 0462 | SW_Splašky vnitřní gravitační 81
13126395 | 252.511 | 0.00950189 | 0.0872616 | ø110 mm | 0.00120656 | -1376.99 | -1594.43 | -1415.88 | 100 | -1633.32 | -1415.88 | SW_Splašky vnitřní gravitační 81 | -4781.06 | 110 | 11 | ø110 | 103.6 | TR06.03.0463 | 0463 | SW_Splašky vnitřní gravitační 81
13126467 | 1457.22 | 0.00950189 | 0.503578 | ø110 mm | 0.00120656 | 85.8412 | 85.8412 | -1371.38 |  | -1371.38 | -1371.38 | SW_Splašky vnitřní gravitační 81 | -4521.38 | 110 | 11 | ø110 | 103.6 | TR06.03.0464 | 0464 | SW_Splašky vnitřní gravitační 81
13136351 | 2893.71 | 0.00950189 | 0.999996 | ø110 mm | 0.00120656 | -1417.48 | -1530.34 | -1472.47 | 2 | -1585.32 | -1472.47 | SW_Splašky vnitřní gravitační 4 | -4732.12 | 110 | 3 | ø110 | 103.6 | TR06.03.0510 | 0510 | SW_Splašky vnitřní gravitační 4
13136422 | 946.602 | 0.00950189 | 0.327122 | ø110 mm | 0.00120656 | -462.946 | -462.946 | -1409.55 |  | -1409.55 | -1409.55 | SW_Splašky vnitřní gravitační 4 | -4559.55 | 110 | 3 | ø110 | 103.6 | TR06.03.0511 | 0511 | SW_Splašky vnitřní gravitační 4
13190133 | 144.234 | 0.00950189 | 0.0498438 | ø110 mm | 0.00120656 | -1330.8 | -1369.69 | -1471.68 | 100 | -1510.57 | -1471.68 | SW_Splašky vnitřní gravitační 8 | -4658.31 | 110 | 22 | ø110 | 103.6 | TR06.03.0567 | 0567 | SW_Splašky vnitřní gravitační 8
13190189 | 425.902 | 0.00950189 | 0.147181 | ø110 mm | 0.00120656 | -1504.77 | -1559.75 | -1568.27 | 2 | -1623.26 | -1568.27 | SW_Splašky vnitřní gravitační 8 | -4770.06 | 110 | 25 | ø110 | 103.6 | TR06.03.0568 | 0568 | SW_Splašky vnitřní gravitační 8
13190240 | 222.462 | 0.00950189 | 0.0768773 | ø110 mm | 0.00120656 | -1499.27 | -1554.26 | -1558.71 | 2 | -1613.7 | -1558.71 | SW_Splašky vnitřní gravitační 8 | -4760.5 | 110 | 25 | ø110 | 103.6 | TR06.03.0569 | 0569 | SW_Splašky vnitřní gravitační 8
13190257 | 89.8428 | 0.00950189 | 0.0310474 | ø110 mm | 0.00120656 | -1496.44 | -1551.42 | -1553.22 | 2 | -1608.21 | -1553.22 | SW_Splašky vnitřní gravitační 8 | -4755.01 | 110 | 25 | ø110 | 103.6 | TR06.03.0570 | 0570 | SW_Splašky vnitřní gravitační 8
13190356 | 185.633 | 0.00950189 | 0.06415 | ø110 mm | 0.00120656 | -1362.85 | -1533 | -1401.74 | 100 | -1571.89 | -1401.74 | SW_Splašky vnitřní gravitační 8 | -4719.63 | 110 | 25 | ø110 | 103.6 | TR06.03.0571 | 0571 | SW_Splašky vnitřní gravitační 8
13202762 | 685.817 | 0.00950189 | 0.237001 | ø110 mm | 0.00120656 | -255.37 | -779.207 | -294.261 | 100 | -818.098 | -294.261 | SW_Splašky vnitřní gravitační 4 | -3965.84 | 110 | 13 | ø110 | 103.6 | TR06.03.0627 | 0627 | SW_Splašky vnitřní gravitační 4
13203033 | 475.763 | 0.00950189 | 0.164412 | ø110 mm | 0.00120656 | -414.838 | -469.827 | -479.341 | 2 | -534.33 | -479.341 | SW_Splašky vnitřní gravitační 4 | -3681.13 | 110 | 11 | ø110 | 103.6 | TR06.03.0628 | 0628 | SW_Splašky vnitřní gravitační 4
13203132 | 171.842 | 0.00950189 | 0.0593844 | ø110 mm | 0.00120656 | -458.871 | -619.273 | -497.762 | 100 | -658.164 | -497.762 | SW_Splašky vnitřní gravitační 4 | -3805.9 | 110 | 11 | ø110 | 103.6 | TR06.03.0629 | 0629 | SW_Splašky vnitřní gravitační 4
13203219 | 254.115 | 0.00950189 | 0.0878157 | ø110 mm | 0.00120656 | -232.829 | -451.406 | -271.72 | 100 | -490.297 | -271.72 | SW_Splašky vnitřní gravitační 4 | -3638.03 | 110 | 11 | ø110 | 103.6 | TR06.03.0630 | 0630 | SW_Splašky vnitřní gravitační 4
13203424 | 234.226 | 0.00950189 | 0.0809426 | ø110 mm | 0.00120656 | -1284.15 | -1488.67 | -1323.05 | 100 | -1527.56 | -1323.05 | SW_Splašky vnitřní gravitační 4 | -4675.3 | 110 | 17 | ø110 | 103.6 | TR06.03.0631 | 0631 | SW_Splašky vnitřní gravitační 4
13203674 | 266.12 | 0.00950189 | 0.0919644 | ø110 mm | 0.00120656 | -1012.42 | -1278.54 | -1012.42 |  | -1278.54 | -1012.42 | SW_Splašky vnitřní gravitační 4 | -4428.54 | 110 | 17 | ø110 | 103.6 | TR06.03.0632 | 0632 | SW_Splašky vnitřní gravitační 4
13203682 | 75.621 | 0.00950189 | 0.0261328 | ø110 mm | 0.00120656 | -663.573 | -739.194 | -663.573 |  | -739.194 | -663.573 | SW_Splašky vnitřní gravitační 4 | -3889.19 | 110 | 11 | ø110 | 103.6 | TR06.03.0633 | 0633 | SW_Splašky vnitřní gravitační 4
13206830 | 1726.63 | 0.04908 | 1.3561 | ø250 mm | 0.000526094 | -1133.14 | -1292.64 | -1258.11 | 1.99998 | -1417.61 | -1258.11 | SW_Splašky vnitřní gravitační 10 | -4561.42 | 250 | 180 | ø250 | 237.6 | TR06.03.0637 | 0637 | SW_Splašky vnitřní gravitační 10
13207155 | 1416.32 | 0.00950189 | 0.489446 | ø110 mm | 0.00120656 | -4.42638 | -4.42638 | -1420.75 |  | -1420.75 | -1420.75 | SW_Splašky vnitřní gravitační 8 | -4570.75 | 110 | 26 | ø110 | 103.6 | TR06.03.0638 | 0638 | SW_Splašky vnitřní gravitační 8
13207372 | 240.454 | 0.00950189 | 0.0830948 | ø110 mm | 0.00120656 | -1426.36 | -1635.28 | -1465.25 | 100 | -1674.17 | -1465.25 | SW_Splašky vnitřní gravitační 8 | -4821.91 | 110 | 26 | ø110 | 103.6 | TR06.03.0639 | 0639 | SW_Splašky vnitřní gravitační 8
13218557 | 1742.26 | 0.00950189 | 0.602082 | ø110 mm | 0.00120656 | 163.376 | 163.375 | -1578.88 | 4147546 | -1578.89 | -1578.88 | SW_Splašky vnitřní gravitační 8 | -4728.89 | 110 | 13 | ø110 | 103.6 | TR06.03.0659 | 0659 | SW_Splašky vnitřní gravitační 8
13219217 | 1707.28 | 0.00950189 | 0.589992 | ø110 mm | 0.00120656 | 75.5358 | 75.5343 | -1631.74 | 3817229 | -1631.74 | -1631.74 | SW_Splašky vnitřní gravitační 81 | -4781.74 | 110 | 31 | ø110 | 103.6 | TR06.03.0660 | 0660 | SW_Splašky vnitřní gravitační 81
13219230 | 1644.22 | 0.00950189 | 0.568202 | ø110 mm | 0.00120656 | 67.3477 | 67.3466 | -1576.87 | 5056517 | -1576.87 | -1576.87 | SW_Splašky vnitřní gravitační 81 | -4726.87 | 110 | 34 | ø110 | 103.6 | TR06.03.0661 | 0661 | SW_Splašky vnitřní gravitační 81
13219263 | 2428.81 | 0.00950189 | 0.839337 | ø110 mm | 0.00120656 | 937.063 | 937.063 | -1491.75 |  | -1491.75 | -1491.75 | SW_Splašky vnitřní gravitační 8 | -4641.75 | 110 | 56 | ø110 | 103.6 | TR06.03.0662 | 0662 | SW_Splašky vnitřní gravitační 8
13219750 | 1079.29 | 0.00950189 | 0.372977 | ø110 mm | 0.00120656 | -1637.01 | -1692 | -1713.08 | 1.95307 | -1768.07 | -1713.08 | SW_Splašky vnitřní gravitační 8 | -4914.87 | 110 | 68 | ø110 | 103.6 | TR06.03.0663 | 0663 | SW_Splašky vnitřní gravitační 8
13219810 | 2256.09 | 0.00950189 | 0.77965 | ø110 mm | 0.00120656 | -1688.88 | -1743.87 | -1788.98 | 2 | -1843.97 | -1788.98 | SW_Splašky vnitřní gravitační 8 | -4990.77 | 110 | 60 | ø110 | 103.6 | TR06.03.0664 | 0664 | SW_Splašky vnitřní gravitační 8
13220059 | 1493.93 | 0.00950189 | 0.516265 | ø110 mm | 0.00120656 | 64.1728 | 64.1728 | -1429.76 |  | -1429.76 | -1429.76 | SW_Splašky vnitřní gravitační 8 | -4579.76 | 110 | 68 | ø110 | 103.6 | TR06.03.0665 | 0665 | SW_Splašky vnitřní gravitační 8
13221846 | 1635.71 | 0.04908 | 1.28468 | ø250 mm | 0.000526094 | -1080.44 | -1238.12 | -1205.41 | 2 | -1363.09 | -1205.41 | SW_Splašky vnitřní gravitační 10 | -4506.89 | 250 | 180 | ø250 | 237.6 | TR06.03.0666 | 0666 | SW_Splašky vnitřní gravitační 10
13221857 | 178.617 | 0.00950189 | 0.0617257 | ø110 mm | 0.00120656 | -1732.58 | -1787.57 | -1791.14 | 2 | -1846.13 | -1791.14 | SW_Splašky vnitřní gravitační 8 | -4992.93 | 110 | 47 | ø110 | 103.6 | TR06.03.0667 | 0667 | SW_Splašky vnitřní gravitační 8
13221860 | 1295.51 | 0.00950189 | 0.447697 | ø110 mm | 0.00120656 | -1739.46 | -1794.45 | -1820.35 | 2 | -1875.34 | -1820.35 | SW_Splašky vnitřní gravitační 8 | -5022.14 | 110 | 40 | ø110 | 103.6 | TR06.03.0668 | 0668 | SW_Splašky vnitřní gravitační 8
13221867 | 1931.62 | 0.00950189 | 0.667518 | ø110 mm | 0.00120656 | -1692.92 | -1747.91 | -1786.53 | 2 | -1841.52 | -1786.53 | SW_Splašky vnitřní gravitační 8 | -4988.32 | 110 | 47 | ø110 | 103.6 | TR06.03.0669 | 0669 | SW_Splašky vnitřní gravitační 8
13222501 | 823.199 | 0.00950189 | 0.284477 | ø110 mm | 0.00120656 | -1584.81 | -1656.26 | -1639.8 | 2 | -1711.25 | -1656.26 | SW_Splašky vnitřní gravitační 81 | -4858.05 | 110 | 34 | ø110 | 103.6 | TR06.03.0670 | 0670 | SW_Splašky vnitřní gravitační 81
13222820 | 3754.88 | 0.00950189 | 1.29759 | ø110 mm | 0.00120656 | -1649.4 | -1779.48 | -1704.39 | 2 | -1834.46 | -1704.39 | SW_Splašky vnitřní gravitační 81 | -4981.27 | 110 | 21 | ø110 | 103.6 | TR06.03.0671 | 0671 | SW_Splašky vnitřní gravitační 81
13222907 | 1594.24 | 0.00950189 | 0.55093 | ø110 mm | 0.00120656 | 75.5354 | 75.5343 | -1518.71 | 4902813 | -1518.71 | -1518.71 | SW_Splašky vnitřní gravitační 81 | -4668.71 | 110 | 27 | ø110 | 103.6 | TR06.03.0672 | 0672 | SW_Splašky vnitřní gravitační 81
13222942 | 1549.31 | 0.00950189 | 0.535404 | ø110 mm | 0.00120656 | 75.5355 | 75.5343 | -1473.78 | 4844134 | -1473.78 | -1473.78 | SW_Splašky vnitřní gravitační 81 | -4623.78 | 110 | 28 | ø110 | 103.6 | TR06.03.0673 | 0673 | SW_Splašky vnitřní gravitační 81
13224857 | 2381.57 | 0.00950189 | 0.823011 | ø110 mm | 0.00120656 | -1729.95 | -1784.94 | -1832.56 | 2 | -1887.55 | -1832.56 | SW_Splašky vnitřní gravitační 81 | -5034.35 | 110 | 24 | ø110 | 103.6 | TR06.03.0674 | 0674 | SW_Splašky vnitřní gravitační 81
13228159 | 3121.14 | 0.00950189 | 1.07859 | ø110 mm | 0.00120656 | -1542.66 | -1597.65 | -1660.06 | 2 | -1715.05 | -1660.06 | SW_Splašky vnitřní gravitační 4 | -4861.85 | 110 | 12 | ø110 | 103.6 | TR06.03.0678 | 0678 | SW_Splašky vnitřní gravitační 4
13234751 | 628.882 | 0.00950189 | 0.217326 | ø110 mm | 0.00120656 | -1538.05 | -1593.04 | -1605.62 | 2 | -1660.61 | -1605.62 | SW_Splašky vnitřní gravitační 81 | -4807.41 | 110 | 27 | ø110 | 103.6 | TR06.03.0682 | 0682 | SW_Splašky vnitřní gravitační 81
13234766 | 1941.66 | 0.00950189 | 0.67099 | ø110 mm | 0.00120656 | -1556.09 | -1611.08 | -1649.91 | 2 | -1704.9 | -1649.91 | SW_Splašky vnitřní gravitační 81 | -4851.7 | 110 | 10 | ø110 | 103.6 | TR06.03.0683 | 0683 | SW_Splašky vnitřní gravitační 81
13234771 | 518.524 | 0.00950189 | 0.179189 | ø110 mm | 0.00120656 | -1526.64 | -1592 | -1581.63 | 2 | -1646.99 | -1581.63 | SW_Splašky vnitřní gravitační 81 | -4793.79 | 110 | 27 | ø110 | 103.6 | TR06.03.0684 | 0684 | SW_Splašky vnitřní gravitační 81
13234799 | 1671.6 | 0.00950189 | 0.577662 | ø110 mm | 0.00120656 | -1517.2 | -1572.19 | -1605.62 | 2 | -1660.61 | -1605.62 | SW_Splašky vnitřní gravitační 81 | -4807.41 | 110 | 28 | ø110 | 103.6 | TR06.03.0685 | 0685 | SW_Splašky vnitřní gravitační 81
13234826 | 1729 | 0.00950189 | 0.597499 | ø110 mm | 0.00120656 | -1481.71 | -1571.28 | -1536.7 | 2 | -1626.26 | -1536.7 | SW_Splašky vnitřní gravitační 81 | -4773.07 | 110 | 28 | ø110 | 103.6 | TR06.03.0686 | 0686 | SW_Splašky vnitřní gravitační 81
13235168 | 354.205 | 0.00950189 | 0.122405 | ø110 mm | 0.00120656 | -1522.77 | -1577.76 | -1584.84 | 2 | -1639.83 | -1584.84 | SW_Splašky vnitřní gravitační 4 | -4786.63 | 110 | 18 | ø110 | 103.6 | TR06.03.0687 | 0687 | SW_Splašky vnitřní gravitační 4
13235179 | 93.9057 | 0.00950189 | 0.0324515 | ø110 mm | 0.00120656 | -1535.32 | -1590.3 | -1592.18 | 2 | -1647.17 | -1592.18 | SW_Splašky vnitřní gravitační 4 | -4793.97 | 110 | 14 | ø110 | 103.6 | TR06.03.0688 | 0688 | SW_Splašky vnitřní gravitační 4
13235184 | 444.915 | 0.00950189 | 0.153752 | ø110 mm | 0.00120656 | -1512.83 | -1576.71 | -1567.82 | 2 | -1631.7 | -1567.82 | SW_Splašky vnitřní gravitační 4 | -4778.5 | 110 | 18 | ø110 | 103.6 | TR06.03.0689 | 0689 | SW_Splašky vnitřní gravitační 4
13235460 | 360.856 | 0.00950189 | 0.124703 | ø110 mm | 0.00120656 | -1667.25 | -1722.24 | -1729.46 | 2 | -1784.45 | -1729.46 | SW_Splašky vnitřní gravitační 81 | -4931.25 | 110 | 31 | ø110 | 103.6 | TR06.03.0690 | 0690 | SW_Splašky vnitřní gravitační 81
13235469 | 594.326 | 0.00950189 | 0.205384 | ø110 mm | 0.00120656 | -1679.93 | -1734.92 | -1746.81 | 2 | -1801.8 | -1746.81 | SW_Splašky vnitřní gravitační 81 | -4948.6 | 110 | 8 | ø110 | 103.6 | TR06.03.0691 | 0691 | SW_Splašky vnitřní gravitační 81
13235474 | 1326.88 | 0.00950189 | 0.458538 | ø110 mm | 0.00120656 | -1639.68 | -1721.2 | -1694.67 | 2 | -1776.19 | -1694.67 | SW_Splašky vnitřní gravitační 81 | -4922.99 | 110 | 31 | ø110 | 103.6 | TR06.03.0692 | 0692 | SW_Splašky vnitřní gravitační 81
13235537 | 1678.72 | 0.00950189 | 0.580125 | ø110 mm | 0.00120656 | 75.5353 | 75.5343 | -1603.19 | 5378941 | -1603.19 | -1603.19 | SW_Splašky vnitřní gravitační 81 | -4753.19 | 110 | 30 | ø110 | 103.6 | TR06.03.0693 | 0693 | SW_Splašky vnitřní gravitační 81
13235572 | 1840.25 | 0.00950189 | 0.635946 | ø110 mm | 0.00120656 | -1611.13 | -1702.91 | -1666.11 | 2 | -1757.9 | -1666.11 | SW_Splašky vnitřní gravitační 81 | -4904.7 | 110 | 30 | ø110 | 103.6 | TR06.03.0694 | 0694 | SW_Splašky vnitřní gravitační 81
13235825 | 208.636 | 0.00950189 | 0.0720993 | ø110 mm | 0.00120656 | -1602.31 | -1657.3 | -1661.47 | 2 | -1716.46 | -1661.47 | SW_Splašky vnitřní gravitační 81 | -4863.26 | 110 | 34 | ø110 | 103.6 | TR06.03.0695 | 0695 | SW_Splašky vnitřní gravitační 81
13235834 | 937.64 | 0.00950189 | 0.324025 | ø110 mm | 0.00120656 | -1611.95 | -1666.94 | -1685.69 | 2 | -1740.68 | -1685.69 | SW_Splašky vnitřní gravitační 81 | -4887.48 | 110 | 33 | ø110 | 103.6 | TR06.03.0696 | 0696 | SW_Splašky vnitřní gravitační 81
13235908 | 1723.61 | 0.00950189 | 0.595636 | ø110 mm | 0.00120656 | 67.3479 | 67.3466 | -1656.26 | 4252862 | -1656.26 | -1656.26 | SW_Splašky vnitřní gravitační 81 | -4806.26 | 110 | 37 | ø110 | 103.6 | TR06.03.0697 | 0697 | SW_Splašky vnitřní gravitační 81
13235910 | 822.487 | 0.00950189 | 0.284231 | ø110 mm | 0.00120656 | -1664.2 | -1735.63 | -1719.19 | 2 | -1790.62 | -1735.63 | SW_Splašky vnitřní gravitační 81 | -4937.42 | 110 | 37 | ø110 | 103.6 | TR06.03.0698 | 0698 | SW_Splašky vnitřní gravitační 81
13235912 | 506.641 | 0.00950189 | 0.175083 | ø110 mm | 0.00120656 | -1681.69 | -1746.81 | -1736.68 | 2 | -1801.8 | -1736.68 | SW_Splašky vnitřní gravitační 81 | -4948.6 | 110 | 37 | ø110 | 103.6 | TR06.03.0699 | 0699 | SW_Splašky vnitřní gravitační 81
13236030 | 798.319 | 0.00950189 | 0.275879 | ø110 mm | 0.00120656 | -1697.28 | -1752.27 | -1768.23 | 2 | -1823.22 | -1768.23 | SW_Splašky vnitřní gravitační 81 | -4970.02 | 110 | 35 | ø110 | 103.6 | TR06.03.0700 | 0700 | SW_Splašky vnitřní gravitační 81
13236467 | 628.575 | 0.00950189 | 0.21722 | ø110 mm | 0.00120656 | -1476.39 | -1531.38 | -1543.95 | 2 | -1598.94 | -1543.95 | SW_Splašky vnitřní gravitační 4 | -4745.74 | 110 | 3 | ø110 | 103.6 | TR06.03.0701 | 0701 | SW_Splašky vnitřní gravitační 4
13247143 | 3864.84 | 0.00950189 | 1.33559 | ø110 mm | 0.00120656 | -1490 | -1544.99 | -1622.27 | 1.99999 | -1677.26 | -1622.27 | SW_Splašky vnitřní gravitační 4 | -4824.06 | 110 | 3 | ø110 | 103.6 | TR06.03.0722 | 0722 | SW_Splašky vnitřní gravitační 4
13259811 | 9630.45 | 0.00950189 | 3.32805 | ø110 mm | 0.00120656 | -1451.37 | -1698.93 | -1506.36 | 2 | -1753.92 | -1506.36 | SW_Splašky vnitřní gravitační 81 | -4900.72 | 110 | 39 | ø110 | 103.6 | TR06.03.0723 | 0723 | SW_Splašky vnitřní gravitační 81
13261783 | 4594.32 | 0.00950189 | 1.58768 | ø110 mm | 0.00120656 | -1352.9 | -1499.76 | -1407.89 | 2 | -1554.75 | -1407.89 | SW_Splašky vnitřní gravitační 81 | -4701.55 | 110 | 39 | ø110 | 103.6 | TR06.03.0724 | 0724 | SW_Splašky vnitřní gravitační 81
13261789 | 1999.09 | 0.00950189 | 0.690837 | ø110 mm | 0.00120656 | -1573.88 | -1628.87 | -1668.84 | 1.99999 | -1723.83 | -1668.84 | SW_Splašky vnitřní gravitační 4 | -4870.63 | 110 | 3 | ø110 | 103.6 | TR06.03.0725 | 0725 | SW_Splašky vnitřní gravitační 4
13277938 | 2520.87 | 0.04908 | 1.97989 | ø250 mm | 0.000526094 | -1027.79 | -1152.77 | -1203.18 | 2 | -1328.15 | -1203.18 | SW_Splašky vnitřní gravitační 10 | -4471.95 | 250 | 180 | ø250 | 237.6 | TR06.03.0768 | 0768 | SW_Splašky vnitřní gravitační 10
13277956 | 954.695 | 0.04908 | 0.749815 | ø250 mm | 0.000526094 | -1006.47 | -1131.44 | -1150.53 | 2 | -1275.51 | -1150.53 | SW_Splašky vnitřní gravitační 10 | -4419.31 | 250 | 180 | ø250 | 237.6 | TR06.03.0769 | 0769 | SW_Splašky vnitřní gravitační 10
13278319 | 505.424 | 0.04908 | 0.396959 | ø250 mm | 0.000526094 | -646.171 | -1091.95 | -734.56 | 100 | -1180.34 | -734.56 | SW_Splašky vnitřní gravitační 10 | -4325.95 | 250 | 180 | ø250 | 237.6 | TR06.03.0771 | 0771 | SW_Splašky vnitřní gravitační 10
13279241 | 1692.93 | 0.00950189 | 0.585034 | ø110 mm | 0.00120656 | 2699 | 2644 | 2644 | 0 | 2589 | 2644 | SW_Splašky vnitřní gravitační 10 | -557.799 | 110 | 193 | ø110 | 103.6 | TR06.03.0778 | 0778 | SW_Splašky vnitřní gravitační 10
13279250 | 52.1954 | 0.00950189 | 0.0180374 | ø110 mm | 0.00120656 | 2581.06 | 2581.06 | 2528.87 |  | 2528.87 | 2528.87 | SW_Splašky vnitřní gravitační 10 | -621.132 | 110 | 193 | ø110 | 103.6 | TR06.03.0779 | 0779 | SW_Splašky vnitřní gravitační 10 | Identifikační data - Komentáře: NAPOJENÍ ČERPANÉ SPLAŠKY NAD HVV
13287182 | 275.823 | 0.00950189 | 0.0953176 | ø110 mm | 0.00120656 | -1435.37 | -1474.26 | -1669.3 | 100 | -1708.19 | -1669.3 | SW_Splašky vnitřní gravitační 8 | -4855.93 | 110 | 68 | ø110 | 103.6 | TR06.03.0790 | 0790 | SW_Splašky vnitřní gravitační 8
13287293 | 162.663 | 0.00950189 | 0.0562123 | ø110 mm | 0.00120656 | -1632.73 | -1687.72 | -1690.97 | 2 | -1745.96 | -1690.97 | SW_Splašky vnitřní gravitační 8 | -4892.76 | 110 | 68 | ø110 | 103.6 | TR06.03.0791 | 0791 | SW_Splašky vnitřní gravitační 8
13287599 | 825.307 | 0.00950189 | 0.285206 | ø110 mm | 0.00120656 | -1671.72 | -1726.71 | -1742.83 | 1.95307 | -1797.82 | -1742.83 | SW_Splašky vnitřní gravitační 8 | -4944.62 | 110 | 60 | ø110 | 103.6 | TR06.03.0793 | 0793 | SW_Splašky vnitřní gravitační 8
13291359 | 113.47 | 0.00950189 | 0.0392123 | ø110 mm | 0.00120656 | -1497.36 | -1616.49 | -1536.25 | 100.01 | -1655.38 | -1536.25 | SW_Splašky vnitřní gravitační 8 | -4803.12 | 110 | 56 | ø110 | 103.6 | TR06.03.0806 | 0806 | SW_Splašky vnitřní gravitační 8
13291383 | 144.095 | 0.00950189 | 0.0497955 | ø110 mm | 0.00120656 | -1663.57 | -1718.56 | -1721.38 | 1.95307 | -1776.37 | -1721.38 | SW_Splašky vnitřní gravitační 8 | -4923.17 | 110 | 69 | ø110 | 103.6 | TR06.03.0807 | 0807 | SW_Splašky vnitřní gravitační 8

# IfcValve: Filtr závitový.LH:DN 20, Filtr závitový.LH:DN 20:13072064
In: 3.NP_SO-101
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 69 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: FI00; Komentáře k typům: F DN20; Model: Model; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN 20; Označení typu: 13; Popis: Filtr; Popis sestavy: Obecný prvek; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; DF: 32 mm; DFl: 32 mm; DN: 20 mm; Lookup Table Name: Závitový_Filtr; Název rodiny: Filtr závitový.LH; ODFl: 59.3 mm; OF: 17.25 mm; RN: 10 mm; Scale Factor: 17; SF: 17; TDFl: 5 mm; TF: 12 mm; V: 10.6667 mm; VS: 19.7667 mm; WDFl: 12 mm; WFl: 26 mm
Classification: FI00 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: 3.NP_SO-101; Výška od podlaží: 3450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000740691 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Identifikační data - Kód prvku: FI00.13.0125; Označení: 0125
Jiné - Rodina: Filtr závitový.LH; Id typu: 13040045; Rodina a typ: Filtr závitový.LH: DN 20; Typ: DN 20

# IfcValve: Filtr závitový.LH:DN 25 (2)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 82 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: FI00; Komentáře k typům: F DN25; Model: Model; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN 25; Označení typu: 12; Popis: Filtr; Popis sestavy: Obecný prvek; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; DF: 38 mm; DFl: 38 mm; DN: 25 mm; Lookup Table Name: Závitový_Filtr; Název rodiny: Filtr závitový.LH; ODFl: 70.5 mm; OF: 20.5 mm; RN: 12.5 mm; Scale Factor: 21; SF: 21; TDFl: 8 mm; TF: 14 mm; V: 12.6667 mm; VS: 23.5 mm; WDFl: 15 mm; WFl: 32 mm
Classification: FI00 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.000125527 m3; Průměr připojení: 32 mm; Velikost: ø32-ø32
Jiné - Typ: DN 25; Id typu: 13040057; Rodina: Filtr závitový.LH; Rodina a typ: Filtr závitový.LH: DN 25
Name (Filtr závitový.LH:DN 25:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13071722 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | FI00.12.0124 | 0124
13072581 | 4.NP_SO-101 | 4.NP_SO-101 | 2973.69 | FI00.12.0129 | 0129

# IfcValve: Kulový kohout závitový.LH:DN15 (4)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 54 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; VÝŠKA: 33.7 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN15; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN15; Označení typu: 05; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 16.5 mm; Body Height: 24.3389 mm; Body Radius: 8.25 mm; Half Nut Height: 2.475 mm; Handle Width: 9.5 mm; Length 1: 26 mm; Length 2: 11.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 4.5 mm; Nut Height: 4.95 mm; Nut Radius: 2.25 mm; Páka_Délka: 78 mm; Páka_Tloušťka: 4.95 mm; Příruba_Průměr: 23 mm; Příruba_Tloušťka: 14 mm; Radius: 23.2 mm; Seal Length: 15.4 mm; Stem Diameter: 3 mm; Stem Height: 9.36111 mm; Stem Radius: 1.5 mm; VS: 54 mm
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000248726 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Id typu: 12958572; Rodina: Kulový kohout závitový.LH; Rodina a typ: Kulový kohout závitový.LH: DN15; Typ: DN15
Name (Kulový kohout závitový.LH:DN15:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13064959 | -1.PP_SO-101 | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.05.0097 | 0097
13065785 | -1.PP_SO-101 | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.05.0101 | 0101 | Jiné - Páteřní trasa: yes
13265366 | 2.NP_SO-101 | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.05.0199 | 0199
13265384 | 2.NP_SO-101 | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.05.0200 | 0200

# IfcValve: Kulový kohout závitový.LH:DN20 (13)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 62 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; VÝŠKA: 45.5 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN20; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN20; Označení typu: 07; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 22 mm; Body Height: 32.8611 mm; Body Radius: 11 mm; Half Nut Height: 3.3 mm; Handle Width: 10 mm; Length 1: 34 mm; Length 2: 15.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 6 mm; Nut Height: 6.6 mm; Nut Radius: 3 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 6.6 mm; Příruba_Průměr: 29 mm; Příruba_Tloušťka: 14 mm; Radius: 31.2 mm; Seal Length: 15.4 mm; Stem Diameter: 4 mm; Stem Height: 12.6389 mm; Stem Radius: 2 mm; VS: 62 mm
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000472561 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Jiné - Rodina: Kulový kohout závitový.LH; Id typu: 12958580; Rodina a typ: Kulový kohout závitový.LH: DN20; Typ: DN20
Name (Kulový kohout závitový.LH:DN20:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13065837 | -1.PP_SO-101 | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.07.0102 | 0102 | Jiné - Páteřní trasa: yes
13065853 | -1.PP_SO-101 | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.07.0103 | 0103 | Jiné - Páteřní trasa: yes
13066421 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | VE01.07.0114 | 0114 | Jiné - Páteřní trasa: yes; Mechanické – tok - Tlaková ztráta: 0 Pa
13066637 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.07.0115 | 0115
13066653 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.07.0116 | 0116
13066724 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.07.0117 | 0117
13066754 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.07.0118 | 0118
13067023 | 2.NP_SO-101 | 2.NP_SO-101 | 3350 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | VE01.07.0121 | 0121 | Jiné - Páteřní trasa: yes; Mechanické – tok - Tlaková ztráta: 0 Pa
13070040 | 4.NP_SO-101 | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.07.0122 | 0122
13072659 | 4.NP_SO-101 | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.07.0130 | 0130
13072677 | 4.NP_SO-101 | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.07.0131 | 0131
13072945 | 3.NP_SO-101 | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.07.0133 | 0133 | Mechanické – tok - Tlaková ztráta: 0 Pa
13309379 | 4.NP_SO-101 | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.07.0216 | 0216

# IfcValve: Kulový kohout závitový.LH:DN25 (10)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 71 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm; VÝŠKA: 49.6 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN25; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN25; Označení typu: 06; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 27.5 mm; Body Height: 35.8222 mm; Body Radius: 13.75 mm; Half Nut Height: 4.125 mm; Handle Width: 10.5 mm; Length 1: 36 mm; Length 2: 16.25 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 7.5 mm; Nut Height: 8.25 mm; Nut Radius: 3.75 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 35 mm; Příruba_Tloušťka: 17.5 mm; Radius: 32.5 mm; Seal Length: 19.25 mm; Stem Diameter: 5 mm; Stem Height: 13.7778 mm; Stem Radius: 2.5 mm; VS: 71 mm
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.0000753155 m3; Průměr připojení: 32 mm; Velikost: ø32-ø32
Jiné - Rodina: Kulový kohout závitový.LH; Id typu: 12958586; Rodina a typ: Kulový kohout závitový.LH: DN25; Typ: DN25
Name (Kulový kohout závitový.LH:DN25:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení | Páteřní trasa
13065026 | -1.PP_SO-101 | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.06.0098 | 0098 | no
13065123 | -1.PP_SO-101 | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.06.0099 | 0099 | no
13065201 | -1.PP_SO-101 | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.06.0100 | 0100 | no
13065974 | -1.PP_SO-101 | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.06.0104 | 0104
13065990 | -1.PP_SO-101 | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.06.0105 | 0105
13066176 | -1.PP_SO-101 | -1.PP_SO-101 | 2400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | VE01.06.0108 | 0108 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13066978 | 2.NP_SO-101 | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.06.0119 | 0119 | yes
13066996 | 2.NP_SO-101 | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.06.0120 | 0120 | yes
13071692 | 1.NP_SO-101 | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.06.0123 | 0123 | Mechanické – tok - Tlaková ztráta: 0 Pa
13072536 | 4.NP_SO-101 | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.06.0127 | 0127 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcValve: Kulový kohout závitový.LH:DN32 (2)
In: 1.NP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 84 mm; Jmenovitá velikost vstupu: 32 mm; Jmenovitá velikost výstupu: 32 mm; JMENOVITÝ PRŮMĚR: 32 mm; VÝŠKA: 53.7 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN32; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN32; Označení typu: 11; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 35.2 mm; Body Height: 38.7833 mm; Body Radius: 17.6 mm; Half Nut Height: 5.28 mm; Handle Width: 11.2 mm; Length 1: 48 mm; Length 2: 22.2 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 9.6 mm; Nut Height: 10.56 mm; Nut Radius: 4.8 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 43.4 mm; Příruba_Tloušťka: 18 mm; Radius: 44.4 mm; Seal Length: 19.8 mm; Stem Diameter: 6.4 mm; Stem Height: 14.9167 mm; Stem Radius: 3.2 mm; VS: 84 mm
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 3400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.000135563 m3; Průměr připojení: 40 mm; Velikost: ø40-ø40
Jiné - Páteřní trasa: yes; Rodina: Kulový kohout závitový.LH; Id typu: 12958588; Rodina a typ: Kulový kohout závitový.LH: DN32; Typ: DN32
Name (Kulový kohout závitový.LH:DN32:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13066380 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.11.0112 | 0112
13066399 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.11.0113 | 0113

# IfcValve: Kulový kohout závitový.LH:DN40 (2)
In: -1.PP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 93 mm; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 40 mm; VÝŠKA: 68 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN40; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN40; Označení typu: 08; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 44 mm; Body Height: 49.1111 mm; Body Radius: 22 mm; Half Nut Height: 6.6 mm; Handle Width: 12 mm; Length 1: 56 mm; Length 2: 26.15 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 12 mm; Nut Height: 13.2 mm; Nut Radius: 6 mm; Páka_Délka: 138 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 53 mm; Příruba_Tloušťka: 18.5 mm; Radius: 52.3 mm; Seal Length: 20.35 mm; Stem Diameter: 8 mm; Stem Height: 18.8889 mm; Stem Radius: 4 mm; VS: 93 mm
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2450 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000228158 m3; Průměr připojení: 50 mm; Velikost: ø50-ø50
Jiné - Páteřní trasa: yes; Rodina: Kulový kohout závitový.LH; Id typu: 12958590; Rodina a typ: Kulový kohout závitový.LH: DN40; Typ: DN40
Name (Kulový kohout závitový.LH:DN40:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13066112 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | VE01.08.0106 | 0106
13066130 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | VE01.08.0107 | 0107

# IfcValve: Nezámrzný ventil:G 1/2" (2)
Type - Material: 128-128-128
Type - Mechanické – tok - Průtok: 0 m3/s
Type - Text - Profese: Vodovod; Tabulka rozměrů: Voda_kohout kulovy
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm
Type - Identifikační data - ID kategorie: NV.01; Kód sestavy: VE24; Komentáře k typům: NZV; Název typu: G 1/2"; Označení typu: 18; Popis sestavy: Mrazuvzdorný
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Nezámrzný ventil
Classification: VE24 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPC; CCI Technický systém: JB
Vazby - Pomocná 1: 30 mm; Pomocná 2: 35 mm; Pomocná 3: 30 mm; Pomocná 4: 9 mm; Pomocná 5: 9 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti
Grafika - Použít měřítko poznámky: no
Kóty - A1: 14.5 mm; L1: 65 mm; Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.000230089 m3; t1: 5 mm; Velikost: ø20
Jiné - Id typu: 13165532; Rodina: Nezámrzný ventil; Rodina a typ: Nezámrzný ventil: G 1/2"; Typ: G 1/2"
Name (Nezámrzný ventil:G 1/2":...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Název systému | Kód prvku | Označení
