Properties of the parts of a building model (IFC4), part 11 of 26

# IfcDistributionPort (5006)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_13276216_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13276181_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277787_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278505_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277787_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277816_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277802_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277816_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277802_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278255_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277822_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278255_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277822_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278259_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277938_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277950_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277938_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277962_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277956_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277962_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277956_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278357_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278243_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278352_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278243_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278572_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278259_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278572_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278319_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278352_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278319_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278357_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278497_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278593_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278497_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278558_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278505_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278929_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278505_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278593_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278511_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13278558_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278971_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278603_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278763_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278775_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278786_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278763_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278780_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278786_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279337_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278780_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278858_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279329_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278929_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278858_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278995_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278971_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279330_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13278995_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279264_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279241_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279241_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279268_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279261_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279250_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279250_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279264_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279252_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279278_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279252_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279261_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279278_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279253_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279329_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279311_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279311_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279337_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279329_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279330_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279634_1 | SINK | PIPE | SEWAGE
OutPort_13279625_1 | SOURCE | PIPE | SEWAGE
InPort_13279626_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
InPort_13279628_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
OutPort_13279626_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
InPort_13279627_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
InPort_13279630_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
OutPort_13279627_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
InPort_13279632_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
OutPort_13279628_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
InPort_13279632_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
OutPort_13279630_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
Port_13279634_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13279978_1 | SINK | PIPE | SEWAGE
OutPort_13279969_1 | SOURCE | PIPE | SEWAGE
InPort_13279970_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_13279972_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
OutPort_13279970_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_13279971_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
InPort_13279974_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
OutPort_13279971_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
InPort_13279976_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
OutPort_13279972_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_13279976_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
OutPort_13279974_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
Port_13279978_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13280393_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281087_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13280889_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281083_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281087_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13280889_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13280966_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13280987_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281068_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13280966_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281052_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281068_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281083_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281052_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281200_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281517_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281521_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281200_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281477_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432884_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281517_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13281477_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13281692_1 | SINK | PIPE | SEWAGE
OutPort_13281683_1 | SOURCE | PIPE | SEWAGE
InPort_13281684_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_13281686_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
OutPort_13281684_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_13281685_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
InPort_13281688_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
OutPort_13281685_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
InPort_13281690_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
OutPort_13281686_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_13281690_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
OutPort_13281688_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
Port_13281692_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13281838_1 | SINK | PIPE | SEWAGE
OutPort_13281829_1 | SOURCE | PIPE | SEWAGE
InPort_13281830_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_13281832_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
OutPort_13281830_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_13281831_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
InPort_13281834_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
OutPort_13281831_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
InPort_13281836_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
OutPort_13281832_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_13281836_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
OutPort_13281834_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
Port_13281838_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13286940_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 3
OutPort_13286945_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 3
OutPort_13286940_3 | SOURCE | PIPE | SEWAGE
Port_13286940_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_13286942_1 | SOURCE | PIPE | SEWAGE
Port_13286944_1 | SOURCEANDSINK | PIPE
Port_13286944_2 | SOURCEANDSINK | PIPE
InPort_13286945_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 3
Port_13286947_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 9
Port_13286947_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 9
InPort_13286954_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
OutPort_13286958_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
OutPort_13286954_3 | SOURCE | PIPE | SEWAGE
Port_13286954_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_13286955_1 | SOURCE | PIPE | SEWAGE
Port_13286957_1 | SOURCEANDSINK | PIPE
Port_13286957_2 | SOURCEANDSINK | PIPE
InPort_13286958_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
Port_13286960_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13286960_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13287012_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287599_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13287598_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13287014_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13287014_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13287627_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287182_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287322_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287182_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287326_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287293_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291376_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287293_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287322_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13287508_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13287623_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13287627_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
OutPort_13287508_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287598_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287599_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287598_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291383_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13289159_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288069_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288532_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288524_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288524_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288543_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288543_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288537_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288537_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289132_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289132_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288563_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288563_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288780_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288780_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288774_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288774_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289231_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288966_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288964_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288976_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288990_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288998_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288976_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288992_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288998_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289031_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288992_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289002_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289031_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289248_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289002_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289209_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289159_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289231_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289182_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289182_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289209_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289231_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289241_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13289241_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13289248_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289829_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430578_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289829_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289914_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289830_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289912_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289830_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289914_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13291359_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291379_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291359_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291382_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291382_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291383_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13291432_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13291386_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13291428_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13291405_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13291405_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13291432_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13291531_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436649_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13291655_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13291531_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13291651_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13291630_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13291630_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13291655_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
Port_13309379_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13309381_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13315238_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
InPort_13315240_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
OutPort_13315238_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
InPort_13315239_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
InPort_13315242_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
OutPort_13315239_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
InPort_13315245_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
OutPort_13315240_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
InPort_13315245_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
OutPort_13315242_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
InPort_13315246_1 | SINK | PIPE | SEWAGE
OutPort_13315244_1 | SOURCE | PIPE | SEWAGE
Port_13315246_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13315363_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13315404_1 | SOURCE | PIPE | SEWAGE
InPort_13315540_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13315556_1 | SOURCE | PIPE | SEWAGE
InPort_13315642_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_13315644_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
OutPort_13315642_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_13315643_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
InPort_13315646_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
OutPort_13315643_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
InPort_13315649_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
OutPort_13315644_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_13315649_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
OutPort_13315646_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
Port_13315650_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13315650_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13315670_1 | SOURCE | PIPE | SEWAGE
Port_13373783_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374554_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13373783_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374600_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13373903_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373960_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373946_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373959_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373946_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377097_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373959_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373960_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13373959_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374729_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374592_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374602_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374600_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13374602_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13374614_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13374624_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13374624_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13374618_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13374618_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13374628_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13374673_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374681_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374675_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374681_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374675_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374685_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13374729_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374792_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374731_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374792_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374731_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374798_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374796_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13374798_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13375549_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378879_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13377087_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377091_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377087_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377093_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13377103_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13377107_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13377103_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13377109_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13377118_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13377123_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13377118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13377125_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13377135_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13377133_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13377133_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13377137_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13377144_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13377146_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13377144_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13377148_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13378051_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381313_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13378051_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381692_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13378079_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381307_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13381732_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13378079_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13378108_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381301_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378108_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381775_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378138_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382900_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13378138_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13381813_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13378845_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378877_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378845_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378881_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378877_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13378879_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13380145_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382923_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13380145_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381301_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13380735_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13380898_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13380900_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13380735_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13385118_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13380888_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13380888_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13380900_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13380962_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13380962_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13380974_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13381005_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13385051_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13381017_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381005_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13381039_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384987_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381039_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381051_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381079_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384897_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381079_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381091_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381511_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381668_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381511_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381552_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381552_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13382302_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381660_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381668_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381660_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381900_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381684_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381692_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381684_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381912_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13381724_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381732_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13381921_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381724_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13381767_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381775_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381767_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381930_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381805_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13381813_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13381805_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13381936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13381898_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381900_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381898_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381902_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13381910_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381912_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381910_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13381914_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13381919_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381921_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13381923_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13381919_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13381928_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381930_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381928_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13381932_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382302_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383021_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13382779_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382896_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382779_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382900_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382869_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382881_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382869_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382896_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13382908_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382923_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382908_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382927_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13382927_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384275_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13383029_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13382937_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13382937_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383033_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13382964_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383011_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13382964_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383015_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13382990_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383021_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13382990_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383025_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383015_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383257_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383133_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384873_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383133_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383216_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383141_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383142_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383141_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384873_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383145_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384893_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383145_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384897_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383214_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383216_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383214_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13384893_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383248_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384915_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383248_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383371_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383257_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383351_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383351_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383352_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383351_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384915_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383369_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383371_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383369_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383402_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383402_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384975_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13383418_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13384923_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13383509_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383418_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13383426_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383427_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13384923_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383426_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13383507_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383509_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13383511_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383507_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13385037_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13383511_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13383537_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384284_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383537_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384296_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383623_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384284_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383627_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383627_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385070_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13383650_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385369_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13385369_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13383722_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13383722_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13384436_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13384275_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384288_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384288_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384289_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384288_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384296_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13384436_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13385106_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13384975_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384985_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384977_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384985_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384977_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13384987_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13385049_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13385037_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13385041_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13385049_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13385051_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13385041_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13385070_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385080_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385072_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385080_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13385082_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13385106_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13385116_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13385116_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13385108_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13385108_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13385118_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385268_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385285_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385285_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385381_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385369_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385399_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385379_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385399_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385379_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385391_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385381_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13385391_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13413557_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13413559_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_13413654_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13413657_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13413840_1 | SINK | PIPE | SEWAGE
OutPort_13413831_1 | SOURCE | PIPE | SEWAGE
InPort_13413832_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_13413834_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
OutPort_13413832_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_13413833_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
InPort_13413836_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
OutPort_13413833_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
InPort_13413838_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
OutPort_13413834_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_13413838_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
OutPort_13413836_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
Port_13413840_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13413879_1 | SINK | PIPE | SEWAGE
OutPort_13413870_1 | SOURCE | PIPE | SEWAGE
InPort_13413871_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13413873_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
OutPort_13413871_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13413872_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
InPort_13413875_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
OutPort_13413872_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
InPort_13413877_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
OutPort_13413873_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13413877_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
OutPort_13413875_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
Port_13413879_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13414481_1 | SINK | PIPE | SEWAGE
OutPort_13414472_1 | SOURCE | PIPE | SEWAGE
InPort_13414473_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13414475_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
OutPort_13414473_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13414474_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
InPort_13414477_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
OutPort_13414474_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
InPort_13414479_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
OutPort_13414475_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13414479_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
OutPort_13414477_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
Port_13414481_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13414537_1 | SINK | PIPE | SEWAGE
OutPort_13414528_1 | SOURCE | PIPE | SEWAGE
InPort_13414529_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_13414531_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
OutPort_13414529_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_13414530_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 36
InPort_13414533_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 36
OutPort_13414530_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 36
InPort_13414535_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
OutPort_13414531_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_13414535_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 36
OutPort_13414533_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 36
Port_13414537_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13425322_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428374_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13425322_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428376_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13428411_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13425329_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13425329_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428413_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13425447_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428444_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13425447_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428446_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13425477_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428477_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13425477_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428479_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13425561_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428514_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13425561_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428516_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13427364_1 | SOURCE | PIPE | SEWAGE
OutPort_13427368_1 | SOURCE | PIPE | SEWAGE
OutPort_13427370_1 | SOURCE | PIPE | SEWAGE
OutPort_13427410_1 | SOURCE | PIPE | SEWAGE
OutPort_13427659_1 | SOURCE | PIPE | SEWAGE
InPort_13427660_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13427661_1 | SOURCE | PIPE | SEWAGE
Port_13427661_2 | SOURCEANDSINK | PIPE
OutPort_13427750_1 | SOURCE | PIPE | SEWAGE
InPort_13427751_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13427752_1 | SOURCE | PIPE | SEWAGE
Port_13427752_2 | SOURCEANDSINK | PIPE
Port_13427844_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13427847_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_13427890_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13427893_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13428039_1 | SINK | PIPE | SEWAGE
OutPort_13428030_1 | SOURCE | PIPE | SEWAGE
InPort_13428031_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
InPort_13428033_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
OutPort_13428031_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
InPort_13428032_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
InPort_13428035_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
OutPort_13428032_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
InPort_13428037_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
OutPort_13428033_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
InPort_13428037_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
OutPort_13428035_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
Port_13428039_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13428364_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428366_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428364_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428376_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13428401_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428403_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13428413_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428401_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13428434_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428436_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428434_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428446_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428467_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428469_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428467_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428479_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428504_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428506_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428504_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428516_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13428607_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13429031_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13429035_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13428607_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13428645_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428996_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428645_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13429000_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13428961_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428669_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13428669_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428965_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13428779_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428922_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428779_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428926_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428823_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428879_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428877_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428879_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428877_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428891_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13428912_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428914_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428912_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13428926_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13428951_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428953_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13428965_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13428951_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13428986_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428988_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13428986_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13429000_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13429023_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13429021_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13429021_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13429035_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13429428_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429450_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429512_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429428_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429454_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429516_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429590_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429454_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429510_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429512_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429516_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429510_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429579_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429590_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429600_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429579_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429888_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430051_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429888_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430054_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429970_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429982_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13429970_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430051_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
