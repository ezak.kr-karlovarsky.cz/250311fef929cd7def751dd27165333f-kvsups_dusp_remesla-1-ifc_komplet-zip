Properties of the parts of a building model (IFC4), part 21 of 26

# IfcPipeSegment: Typy trubek:PP-RCT (581)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Reynoldsovo číslo = Třecí faktor = Tření = Doplňkový průtok (m3/s) = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13056002 | 3.NP_SO-101 | 1927.81 | 0.00125645 | 0.242256 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3470 | 3450 | 3450 | 3430 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11434.5 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1927.81 | ø40 | 31 | TR10.02.0152 | 0152 | yes | WS_Teplá vnitřní 155 | 0
13056022 | 3.NP_SO-101 | 5675.08 | 0.0004908 | 0.44572 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5675.08 | ø25 | 19.4 | TR10.02.0153 | 0153 | yes | WS_Cirkulace vnitřní 2 | 0
13056033 | 3.NP_SO-101 | 13808.7 | 0.0004908 | 1.08453 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13808.7 | ø25 | 19.4 | TR10.02.0154 | 0154 | yes | WS_Cirkulace vnitřní 2 | 0
13056101 | 3.NP_SO-101 | 1799.67 | 0.000804127 | 0.180922 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11437.6 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1799.67 | ø32 | 24.8 | TR10.02.0155 | 0155 | yes | WS_Cirkulace vnitřní 2 | 0
13056138 | 3.NP_SO-101 | 5556.11 | 0.000804127 | 0.558561 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5556.11 | ø32 | 24.8 | TR10.02.0156 | 0156 | yes | WS_Studená vnitřní 151 | 0
13056159 | 3.NP_SO-101 | 6771.16 | 0.0004908 | 0.531805 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11440.3 | PP–RCT S4 | 25 | 46 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6771.16 | ø25 | 19.4 | TR10.02.0157 | 0157 | yes | WS_Studená vnitřní 151 | 0
13056221 | 3.NP_SO-101 | 857.459 | 0.000804127 | 0.0862012 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 857.459 | ø32 | 24.8 | TR10.02.0158 | 0158 | yes | WS_Studená vnitřní 151 | 0
13056227 | 3.NP_SO-101 | 1664.71 | 0.00125645 | 0.209194 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3470 | 3450 | 3450 | 3430 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11434.5 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1664.71 | ø40 | 31 | TR10.02.0159 | 0159 | yes | WS_Studená vnitřní 151 | 0
13056268 | 3.NP_SO-101 | 289.516 | 0.000314112 | 0.0181909 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 289.516 | ø20 | 15.4 | TR10.02.0160 | 0160 | no | WS_Studená vnitřní 151 | 0
13056278 | 3.NP_SO-101 | 458.738 | 0.000314112 | 0.0288234 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 458.738 | ø20 | 15.4 | TR10.02.0161 | 0161 | no | WS_Studená vnitřní 151 | 0
13056352 | 3.NP_SO-101 | 305.075 | 0.000314112 | 0.0191684 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 305.075 | ø20 | 15.4 | TR10.02.0162 | 0162 | no | WS_Teplá vnitřní 155 | 0
13056409 | 3.NP_SO-101 | 417.803 | 0.000314112 | 0.0262513 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 417.803 | ø20 | 15.4 | TR10.02.0163 | 0163 | no | WS_Teplá vnitřní 155 | 0
13056476 | 3.NP_SO-101 | 607.113 | 0.000314112 | 0.038146 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 607.113 | ø20 | 15.4 | TR10.02.0164 | 0164 | no | WS_Teplá vnitřní 155 | 0
13056482 | 3.NP_SO-101 | 2438.73 | 0.000314112 | 0.15323 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2438.72 | ø20 | 15.4 | TR10.02.0165 | 0165 | no | WS_Teplá vnitřní 155 | 0
13056496 | 3.NP_SO-101 | 265.075 | 0.000314112 | 0.0166552 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 265.075 | ø20 | 15.4 | TR10.02.0166 | 0166 | no | WS_Teplá vnitřní 155 | 0
13056506 | 3.NP_SO-101 | 114.15 | 0.000314112 | 0.00717223 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 114.15 | ø20 | 15.4 | TR10.02.0167 | 0167 | no | WS_Teplá vnitřní 155 | 0
13056561 | 3.NP_SO-101 | 205.075 | 0.000314112 | 0.0128852 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 19 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.075 | ø20 | 15.4 | TR10.02.0168 | 0168 | no | WS_Studená vnitřní 151 | 0
13056571 | 3.NP_SO-101 | 362.537 | 0.000314112 | 0.0227789 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 19 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 362.537 | ø20 | 15.4 | TR10.02.0169 | 0169 | no | WS_Studená vnitřní 151 | 0
13056598 | 3.NP_SO-101 | 784.354 | 0.000314112 | 0.0492824 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 19 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 784.354 | ø20 | 15.4 | TR10.02.0170 | 0170 | no | WS_Studená vnitřní 151 | 0
13056604 | 3.NP_SO-101 | 2013.1 | 0.000314112 | 0.126487 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2013.1 | ø20 | 15.4 | TR10.02.0171 | 0171 | no | WS_Studená vnitřní 151 | 0
13056616 | 3.NP_SO-101 | 2426.82 | 0.0004908 | 0.190602 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11440.3 | PP–RCT S4 | 25 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2426.82 | ø25 | 19.4 | TR10.02.0172 | 0172 | no | WS_Studená vnitřní 151 | 0
13056655 | 3.NP_SO-101 | 6410.6 | 0.000804127 | 0.644464 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6410.6 | ø32 | 24.8 | TR10.02.0173 | 0173 | yes | WS_Studená vnitřní 151 | 0
13056671 | 3.NP_SO-101 | 2746.82 | 0.0004908 | 0.215735 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2746.82 | ø25 | 19.4 | TR10.02.0174 | 0174 | no | WS_Teplá vnitřní 155 | 0
13056726 | 3.NP_SO-101 | 6004.17 | 0.000804127 | 0.603605 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6004.17 | ø32 | 24.8 | TR10.02.0175 | 0175 | yes | WS_Teplá vnitřní 155 | 0
13056760 | 3.NP_SO-101 | 1647.06 | 0.0004908 | 0.129359 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 46 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1647.06 | ø25 | 19.4 | TR10.02.0176 | 0176 | no | WS_Teplá vnitřní 155 | 0
13056850 | 3.NP_SO-101 | 22.0563 | 0.0004908 | 0.00173229 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 45 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 22.0563 | ø25 | 19.4 | TR10.02.0177 | 0177 | yes | WS_Teplá vnitřní 155 | 0
13056862 | 3.NP_SO-101 | 535.924 | 0.0019632 | 0.0841828 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 3.NP_SO-101 | 3475 | 3450 | 3450 | 3425 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11430.6 | PP–RCT S4 | 50 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 535.924 | ø50 | 38.8 | TR10.02.0178 | 0178 | yes | WS_Teplá vnitřní 155 | 0
13056907 | 3.NP_SO-101 | 585.904 | 0.000314112 | 0.0368134 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 585.904 | ø20 | 15.4 | TR10.02.0179 | 0179 | no | WS_Teplá vnitřní 155 | 0
13056938 | 3.NP_SO-101 | 1012.91 | 0.000314112 | 0.0636431 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 31 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1012.91 | ø20 | 15.4 | TR10.02.0180 | 0180 | no | WS_Teplá vnitřní 155 | 0
13056946 | 3.NP_SO-101 | 1762.73 | 0.000314112 | 0.110756 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1762.73 | ø20 | 15.4 | TR10.02.0181 | 0181 | no | WS_Teplá vnitřní 155 | 0
13056977 | 3.NP_SO-101 | 542.537 | 0.000314112 | 0.0340886 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 33 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 542.537 | ø20 | 15.4 | TR10.02.0182 | 0182 | no | WS_Teplá vnitřní 155 | 0
13057031 | 3.NP_SO-101 | 1990.79 | 0.0004908 | 0.156356 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 48 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1990.79 | ø25 | 19.4 | TR10.02.0183 | 0183 | no | WS_Teplá vnitřní 155 | 0
13057085 | 3.NP_SO-101 | 1578.73 | 0.000314112 | 0.0991942 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 33 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1578.73 | ø20 | 15.4 | TR10.02.0184 | 0184 | no | WS_Teplá vnitřní 155 | 0
13057124 | 3.NP_SO-101 | 473.48 | 0.0004908 | 0.037187 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 46 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 473.48 | ø25 | 19.4 | TR10.02.0185 | 0185 | no | WS_Teplá vnitřní 155 | 0
13057174 | 3.NP_SO-101 | 527.741 | 0.0019632 | 0.0828973 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 3.NP_SO-101 | 3475 | 3450 | 3450 | 3425 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11430.6 | PP–RCT S4 | 50 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 527.741 | ø50 | 38.8 | TR10.02.0186 | 0186 | yes | WS_Studená vnitřní 151 | 0
13057216 | 3.NP_SO-101 | 1708.41 | 0.0004908 | 0.134178 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11440.3 | PP–RCT S4 | 25 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1708.41 | ø25 | 19.4 | TR10.02.0187 | 0187 | no | WS_Studená vnitřní 151 | 0
13057236 | 3.NP_SO-101 | 518.037 | 0.000314112 | 0.0325492 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 36 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 518.037 | ø20 | 15.4 | TR10.02.0188 | 0188 | no | WS_Studená vnitřní 151 | 0
13057304 | 3.NP_SO-101 | 1076.19 | 0.000314112 | 0.0676189 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1076.19 | ø20 | 15.4 | TR10.02.0189 | 0189 | no | WS_Studená vnitřní 151 | 0
13057310 | 3.NP_SO-101 | 1618.72 | 0.000314112 | 0.101707 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 36 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1618.72 | ø20 | 15.4 | TR10.02.0190 | 0190 | no | WS_Studená vnitřní 151 | 0
13057318 | 3.NP_SO-101 | 1378.73 | 0.000314112 | 0.0866278 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1378.73 | ø20 | 15.4 | TR10.02.0191 | 0191 | no | WS_Studená vnitřní 151 | 0
13057327 | 3.NP_SO-101 | 502.538 | 0.000314112 | 0.0315754 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 502.538 | ø20 | 15.4 | TR10.02.0192 | 0192 | no | WS_Studená vnitřní 151 | 0
13057345 | 3.NP_SO-101 | 5441.58 | 0.0004908 | 0.427381 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5441.58 | ø25 | 19.4 | TR10.02.0193 | 0193 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13057358 | 3.NP_SO-101 | 7248.73 | 0.0004908 | 0.569314 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7248.73 | ø25 | 19.4 | TR10.02.0194 | 0194 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13057428 | 3.NP_SO-101 | 2572.5 | 0.000804127 | 0.258616 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11437.6 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2572.5 | ø32 | 24.8 | TR10.02.0195 | 0195 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13057440 | 3.NP_SO-101 | 1593.3 | 0.000804127 | 0.160176 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11437.6 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1593.3 | ø32 | 24.8 | TR10.02.0196 | 0196 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13057507 | 3.NP_SO-101 | 362.537 | 0.000314112 | 0.0227789 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11442.3 | PP–RCT S4 | 20 | 97 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 362.537 | ø20 | 15.4 | TR10.02.0197 | 0197 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13057525 | 3.NP_SO-101 | 1748.41 | 0.0004908 | 0.13732 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1748.41 | ø25 | 19.4 | TR10.02.0198 | 0198 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13057534 | 3.NP_SO-101 | 1118.72 | 0.0004908 | 0.0878645 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1118.72 | ø25 | 19.4 | TR10.02.0199 | 0199 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13057542 | 3.NP_SO-101 | 197.002 | 0.0004908 | 0.0154725 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 197.002 | ø25 | 19.4 | TR10.02.0200 | 0200 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13057562 | 3.NP_SO-101 | 10448.8 | 0.000314112 | 0.656516 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 40 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10448.8 | ø20 | 15.4 | TR10.02.0201 | 0201 | no | WS_Teplá vnitřní 155 | 0
13057623 | 3.NP_SO-101 | 1037.74 | 0.000804127 | 0.104325 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 20 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1037.74 | ø32 | 24.8 | TR10.02.0202 | 0202 | yes | WS_Teplá vnitřní 155 | 0
13057639 | 3.NP_SO-101 | 15165.9 | 0.000314112 | 0.9529 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11442.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15165.9 | ø20 | 15.4 | TR10.02.0203 | 0203 | no | WS_Cirkulace vnitřní 2 | 0
13057723 | 3.NP_SO-101 | 1275.56 | 0.0004908 | 0.100182 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1275.56 | ø25 | 19.4 | TR10.02.0204 | 0204 | yes | WS_Cirkulace vnitřní 2 | 0
13057739 | 3.NP_SO-101 | 10521.9 | 0.000314112 | 0.661107 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10521.9 | ø20 | 15.4 | TR10.02.0205 | 0205 | no | WS_Studená vnitřní 151 | 0
13057794 | 3.NP_SO-101 | 1490.68 | 0.000804127 | 0.14986 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 17 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1490.68 | ø32 | 24.8 | TR10.02.0206 | 0206 | yes | WS_Studená vnitřní 151 | 0
13057810 | 3.NP_SO-101 | 216.188 | 0.000314112 | 0.0135835 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 43 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 216.188 | ø20 | 15.4 | TR10.02.0207 | 0207 | no | WS_Studená vnitřní 151 | 0
13057867 | 3.NP_SO-101 | 4711.63 | 0.000314112 | 0.29604 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11442.3 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4711.63 | ø20 | 15.4 | TR10.02.0208 | 0208 | no | WS_Studená vnitřní 151 | 0
13057877 | 3.NP_SO-101 | 400.106 | 0.000314112 | 0.0251394 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 400.106 | ø20 | 15.4 | TR10.02.0209 | 0209 | no | WS_Teplá vnitřní 155 | 0
13057934 | 3.NP_SO-101 | 4564.71 | 0.000314112 | 0.286809 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11442.3 | PP–RCT S4 | 20 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4564.71 | ø20 | 15.4 | TR10.02.0210 | 0210 | no | WS_Teplá vnitřní 155 | 0
13058043 | 3.NP_SO-101 | 498.23 | 0.0004908 | 0.0391309 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11440.3 | PP–RCT S4 | 25 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 498.23 | ø25 | 19.4 | TR10.02.0211 | 0211 | no | WS_Studená vnitřní 151 | 0
13058049 | 3.NP_SO-101 | 2326.04 | 0.0004908 | 0.182687 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11440.3 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2326.04 | ø25 | 19.4 | TR10.02.0212 | 0212 | no | WS_Studená vnitřní 151 | 0
13058124 | 3.NP_SO-101 | 1530.02 | 0.000314112 | 0.0961342 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 3.NP_SO-101 | 3460 | 3450 | 3450 | 3440 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11442.3 | PP–RCT S4 | 20 | 97 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1530.02 | ø20 | 15.4 | TR10.02.0213 | 0213 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13058130 | 3.NP_SO-101 | 3141.13 | 0.0004908 | 0.246704 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3141.13 | ø25 | 19.4 | TR10.02.0214 | 0214 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13058345 | 2.NP_SO-101 | 383.202 | 0.000804127 | 0.0385237 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3417.7 | 3401.7 | 3400.01 | 3384.01 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7387.61 | PP–RCT S4 | 32 | 327 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 383.202 | ø32 | 24.8 | TR10.02.0215 | 0215 | yes | WS_"Jiný typ" studená vnitřní 1 | 0.443167
13058415 | 2.NP_SO-101 | 322.22 | 0.00125645 | 0.0404914 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 2.NP_SO-101 | 3070 | 3050 | 3050 | 3030 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7034.5 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 322.22 | ø40 | 31 | TR10.02.0216 | 0216 | yes | WS_Studená vnitřní 151 | 0
13058432 | 2.NP_SO-101 | 464.255 | 0.0019632 | 0.072925 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7380.6 | PP–RCT S4 | 50 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 464.255 | ø50 | 38.8 | TR10.02.0217 | 0217 | yes | WS_Studená vnitřní 151 | 0
13058488 | 3.NP_SO-101 | 4403.04 | 0.000804127 | 0.442642 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3642.85 | -760.188 | 3642.85 | -760.188 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7239.81 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4403.04 | ø32 | 24.8 | TR10.02.0218 | 0218 | yes | WS_Cirkulace vnitřní 2
13058506 | 2.NP_SO-101 | 583.305 | 0.000804127 | 0.0586402 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7387.6 | PP–RCT S4 | 32 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 583.305 | ø32 | 24.8 | TR10.02.0219 | 0219 | yes | WS_Cirkulace vnitřní 2 | 0
13058563 | 2.NP_SO-101 | 664.255 | 0.0019632 | 0.104341 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7380.6 | PP–RCT S4 | 50 | 147 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 664.255 | ø50 | 38.8 | TR10.02.0220 | 0220 | yes | WS_Teplá vnitřní 155 | 0
13058957 | 2.NP_SO-101 | 3434.65 | 0.0004908 | 0.269757 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.28 | 3348.78 | 3348.78 | 3336.28 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7339.08 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3434.65 | ø25 | 19.4 | TR10.02.0221 | 0221 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13058967 | 2.NP_SO-101 | 6558.72 | 0.0004908 | 0.515121 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.42 | 3348.92 | 3348.92 | 3336.42 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7339.22 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6558.72 | ø25 | 19.4 | TR10.02.0222 | 0222 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13058978 | 2.NP_SO-101 | 3558.72 | 0.0004908 | 0.279502 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.42 | 3348.92 | 3348.92 | 3336.42 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7339.22 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3558.72 | ø25 | 19.4 | TR10.02.0223 | 0223 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13058988 | 2.NP_SO-101 | 3528.41 | 0.0004908 | 0.27712 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.42 | 3348.92 | 3348.92 | 3336.42 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7339.22 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3528.41 | ø25 | 19.4 | TR10.02.0224 | 0224 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13059048 | 2.NP_SO-101 | 396.188 | 0.000314112 | 0.0248932 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3358.92 | 3348.92 | 3348.92 | 3338.92 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7341.22 | PP–RCT S4 | 20 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 396.188 | ø20 | 15.4 | TR10.02.0225 | 0225 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13059056 | 2.NP_SO-101 | 656.187 | 0.000314112 | 0.0412295 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3358.92 | 3348.92 | 3348.92 | 3338.92 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7341.22 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 656.187 | ø20 | 15.4 | TR10.02.0226 | 0226 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13059093 | 2.NP_SO-101 | 2154.05 | 0.000804127 | 0.216549 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7336.77 | PP–RCT S4 | 32 | 85 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2154.05 | ø32 | 24.8 | TR10.02.0227 | 0227 | yes | WS_Studená vnitřní 151 | 0
13059179 | 2.NP_SO-101 | 975.483 | 0.000314112 | 0.0612914 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 975.483 | ø20 | 15.4 | TR10.02.0228 | 0228 | no | WS_Studená vnitřní 151 | 0
13059187 | 2.NP_SO-101 | 205.075 | 0.000314112 | 0.0128852 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.075 | ø20 | 15.4 | TR10.02.0229 | 0229 | no | WS_Studená vnitřní 151 | 0
13059197 | 2.NP_SO-101 | 562.538 | 0.000314112 | 0.0353453 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 562.538 | ø20 | 15.4 | TR10.02.0230 | 0230 | no | WS_Studená vnitřní 151 | 0
13059243 | 2.NP_SO-101 | 455.743 | 0.000804127 | 0.0458163 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7387.6 | PP–RCT S4 | 32 | 85 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 455.743 | ø32 | 24.8 | TR10.02.0231 | 0231 | yes | WS_Studená vnitřní 151 | 0
13059251 | 2.NP_SO-101 | 1204.24 | 0.0019632 | 0.189161 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7380.6 | PP–RCT S4 | 50 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1204.24 | ø50 | 38.8 | TR10.02.0232 | 0232 | yes | WS_Studená vnitřní 151 | 0
13059270 | 2.NP_SO-101 | 493.206 | 0.0004908 | 0.0387363 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7390.3 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 493.206 | ø25 | 19.4 | TR10.02.0233 | 0233 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13059278 | 2.NP_SO-101 | 1198.29 | 0.000804127 | 0.120465 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7387.6 | PP–RCT S4 | 32 | 327 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1198.29 | ø32 | 24.8 | TR10.02.0234 | 0234 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13059297 | 2.NP_SO-101 | 473.206 | 0.0004908 | 0.0371655 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7390.3 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 473.206 | ø25 | 19.4 | TR10.02.0235 | 0235 | yes | WS_Cirkulace vnitřní 2 | 0
13059305 | 2.NP_SO-101 | 1248.29 | 0.000804127 | 0.125492 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7387.6 | PP–RCT S4 | 32 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1248.29 | ø32 | 24.8 | TR10.02.0236 | 0236 | yes | WS_Cirkulace vnitřní 2 | 0
13059319 | 2.NP_SO-101 | 2056.61 | 0.0004908 | 0.161526 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7339.47 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2056.61 | ø25 | 19.4 | TR10.02.0237 | 0237 | yes | WS_Cirkulace vnitřní 2 | 0
13059329 | 2.NP_SO-101 | 19114 | 0.000201032 | 0.960774 | ø16 mm | 0 | 0 | Laminární | 0.000862069 | F | JB | 2.NP_SO-101 | 3357.17 | 3349.17 | 3349.17 | 3341.17 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S3.2 | WS_Cirkulace vnitřní 2 | 7343.37 | PP–RCT S3,2 | 16 | 23 | Trubka Evo, S3.2 - ø16 | ø16 | 19114 | ø16 | 11.6 | TR10.02.0238 | 0238 | yes | WS_Cirkulace vnitřní 2 | 0
13059337 | 2.NP_SO-101 | 13652.7 | 0.000314112 | 0.857822 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7341.47 | PP–RCT S4 | 20 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13652.7 | ø20 | 15.4 | TR10.02.0239 | 0239 | yes | WS_Cirkulace vnitřní 2 | 0
13059422 | 2.NP_SO-101 | 3703.64 | 0.000804127 | 0.372331 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7336.77 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3703.64 | ø32 | 24.8 | TR10.02.0240 | 0240 | yes | WS_Studená vnitřní 151 | 0
13059508 | 2.NP_SO-101 | 1009.51 | 0.000314112 | 0.0634294 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1009.51 | ø20 | 15.4 | TR10.02.0241 | 0241 | no | WS_Teplá vnitřní 155 | 0
13059519 | 2.NP_SO-101 | 245.075 | 0.000314112 | 0.0153985 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 245.075 | ø20 | 15.4 | TR10.02.0242 | 0242 | no | WS_Teplá vnitřní 155 | 0
13059527 | 2.NP_SO-101 | 3067.61 | 0.000314112 | 0.192744 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3067.61 | ø20 | 15.4 | TR10.02.0243 | 0243 | no | WS_Teplá vnitřní 155 | 0
13059545 | 2.NP_SO-101 | 938.725 | 0.000314112 | 0.0589818 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7342.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 938.725 | ø20 | 15.4 | TR10.02.0244 | 0244 | no | WS_Studená vnitřní 151 | 0
13059554 | 2.NP_SO-101 | 285.075 | 0.000314112 | 0.0179118 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7342.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 285.075 | ø20 | 15.4 | TR10.02.0245 | 0245 | no | WS_Studená vnitřní 151 | 0
13059562 | 2.NP_SO-101 | 2847.08 | 0.000314112 | 0.178887 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7342.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2847.08 | ø20 | 15.4 | TR10.02.0246 | 0246 | no | WS_Studená vnitřní 151 | 0
13059622 | 2.NP_SO-101 | 4413.78 | 0.000804127 | 0.443721 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7336.77 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4413.78 | ø32 | 24.8 | TR10.02.0247 | 0247 | yes | WS_Studená vnitřní 151 | 0
13059636 | 2.NP_SO-101 | 1064.52 | 0.000314112 | 0.0668858 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1064.52 | ø20 | 15.4 | TR10.02.0248 | 0248 | no | WS_Teplá vnitřní 155 | 0
13059643 | 2.NP_SO-101 | 165.075 | 0.000314112 | 0.010372 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 165.075 | ø20 | 15.4 | TR10.02.0249 | 0249 | no | WS_Teplá vnitřní 155 | 0
13059653 | 2.NP_SO-101 | 682.537 | 0.000314112 | 0.0428851 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7342.3 | PP–RCT S4 | 20 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 682.537 | ø20 | 15.4 | TR10.02.0250 | 0250 | no | WS_Teplá vnitřní 155 | 0
13059703 | 2.NP_SO-101 | 4016.11 | 0.000314112 | 0.252339 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4016.11 | ø20 | 15.4 | TR10.02.0251 | 0251 | yes | WS_Teplá vnitřní 155 | 0
13059784 | 2.NP_SO-101 | 2387.06 | 0.000314112 | 0.149983 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2387.06 | ø20 | 15.4 | TR10.02.0252 | 0252 | no | WS_Studená vnitřní 151 | 0
13059794 | 2.NP_SO-101 | 360.187 | 0.000314112 | 0.0226312 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 360.187 | ø20 | 15.4 | TR10.02.0253 | 0253 | no | WS_Studená vnitřní 151 | 0
13059806 | 2.NP_SO-101 | 635.075 | 0.000314112 | 0.0399029 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 635.075 | ø20 | 15.4 | TR10.02.0254 | 0254 | no | WS_Studená vnitřní 151 | 0
13059814 | 2.NP_SO-101 | 447.426 | 0.000314112 | 0.0281126 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 447.426 | ø20 | 15.4 | TR10.02.0255 | 0255 | no | WS_Studená vnitřní 151 | 0
13059926 | 2.NP_SO-101 | 345.075 | 0.000314112 | 0.0216817 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 345.075 | ø20 | 15.4 | TR10.02.0256 | 0256 | no | WS_Teplá vnitřní 155 | 0
13059936 | 2.NP_SO-101 | 585.075 | 0.000314112 | 0.0367613 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 585.075 | ø20 | 15.4 | TR10.02.0257 | 0257 | no | WS_Teplá vnitřní 155 | 0
13059944 | 2.NP_SO-101 | 342.537 | 0.000314112 | 0.0215223 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.537 | ø20 | 15.4 | TR10.02.0258 | 0258 | no | WS_Teplá vnitřní 155 | 0
13059975 | 2.NP_SO-101 | 2409.9 | 0.000314112 | 0.151419 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2409.9 | ø20 | 15.4 | TR10.02.0259 | 0259 | no | WS_Teplá vnitřní 155 | 0
13059981 | 2.NP_SO-101 | 47.5491 | 0.000314112 | 0.0029876 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 60 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 47.5491 | ø20 | 15.4 | TR10.02.0260 | 0260 | yes | WS_Teplá vnitřní 155 | 0
13059989 | 2.NP_SO-101 | 690.26 | 0.000314112 | 0.0433703 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 690.26 | ø20 | 15.4 | TR10.02.0261 | 0261 | no | WS_Studená vnitřní 151 | 0
13060006 | 2.NP_SO-101 | 28.5748 | 0.000176688 | 0.00134656 | ø15 mm | 0 | 0 | Laminární | 0 | F | JB | 2.NP_SO-101 | 587.5 | 580 | 580 | 572.5 | WS_Studená vnitřní | 0 | Studená voda v domácnosti |  | WS_Studená vnitřní 151 | 4572.5 |  | 15 | 1 |  |  | 28.5748 | ø15 | 15 | TR10.02.0262 | 0262 | no | WS_Studená vnitřní 151 | 0
13060007 | 2.NP_SO-101 | 2731.86 | 0.000314112 | 0.171648 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3331.71 | 3331.71 | 599.844 | 599.844 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4599.84 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2731.86 | ø20 | 15.4 | TR10.02.0263 | 0263 | no | WS_Studená vnitřní 151
13060063 | 2.NP_SO-101 | 1262.23 | 0.000314112 | 0.0793084 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1262.23 | ø20 | 15.4 | TR10.02.0264 | 0264 | yes | WS_Studená vnitřní 151 | 0
13060071 | 2.NP_SO-101 | 6117.06 | 0.0004908 | 0.480433 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7339.47 | PP–RCT S4 | 25 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6117.06 | ø25 | 19.4 | TR10.02.0265 | 0265 | yes | WS_Studená vnitřní 151 | 0
13060079 | 2.NP_SO-101 | 899.299 | 0.000314112 | 0.0565046 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 899.299 | ø20 | 15.4 | TR10.02.0266 | 0266 | no | WS_Teplá vnitřní 155 | 0
13060089 | 2.NP_SO-101 | 28.5748 | 0.000176688 | 0.00134656 | ø15 mm | 0 | 0 | Laminární | 0 | F | JB | 2.NP_SO-101 | 587.5 | 580 | 580 | 572.5 | WS_Teplá vnitřní | 0 | Teplá voda v domácnosti |  | WS_Teplá vnitřní 155 | 4572.5 |  | 15 | 1 |  |  | 28.5748 | ø15 | 15 | TR10.02.0267 | 0267 | no | WS_Teplá vnitřní 155 | 0
13060090 | 2.NP_SO-101 | 2731.86 | 0.000314112 | 0.171648 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3331.71 | 3331.71 | 599.844 | 599.844 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4599.84 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2731.86 | ø20 | 15.4 | TR10.02.0268 | 0268 | no | WS_Teplá vnitřní 155
13060133 | 2.NP_SO-101 | 1268.83 | 0.000314112 | 0.079723 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 60 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1268.83 | ø20 | 15.4 | TR10.02.0269 | 0269 | yes | WS_Teplá vnitřní 155 | 0
13060141 | 2.NP_SO-101 | 6327.08 | 0.0004908 | 0.496927 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7339.47 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6327.08 | ø25 | 19.4 | TR10.02.0270 | 0270 | yes | WS_Teplá vnitřní 155 | 0
13060149 | 2.NP_SO-101 | 2876.19 | 0.000314112 | 0.180716 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 65 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2876.19 | ø20 | 15.4 | TR10.02.0271 | 0271 | no | WS_Teplá vnitřní 155 | 0
13060190 | 2.NP_SO-101 | 1962.81 | 0.0004908 | 0.154158 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7339.47 | PP–RCT S4 | 25 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1962.81 | ø25 | 19.4 | TR10.02.0272 | 0272 | yes | WS_Teplá vnitřní 155 | 0
13060200 | 2.NP_SO-101 | 2896.19 | 0.000314112 | 0.181973 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 75 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2896.19 | ø20 | 15.4 | TR10.02.0273 | 0273 | no | WS_Studená vnitřní 151 | 0
13060255 | 2.NP_SO-101 | 2179.42 | 0.0004908 | 0.171171 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7339.47 | PP–RCT S4 | 25 | 79 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2179.42 | ø25 | 19.4 | TR10.02.0274 | 0274 | yes | WS_Studená vnitřní 151 | 0
13060332 | 2.NP_SO-101 | 435.743 | 0.000804127 | 0.0438057 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7387.6 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 435.743 | ø32 | 24.8 | TR10.02.0275 | 0275 | yes | WS_Teplá vnitřní 155 | 0
13060340 | 2.NP_SO-101 | 1254.24 | 0.0019632 | 0.197015 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3425 | 3400 | 3400 | 3375 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7380.6 | PP–RCT S4 | 50 | 147 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1254.24 | ø50 | 38.8 | TR10.02.0276 | 0276 | yes | WS_Teplá vnitřní 155 | 0
13060372 | 2.NP_SO-101 | 4515.54 | 0.000314112 | 0.28372 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4515.54 | ø20 | 15.4 | TR10.02.0277 | 0277 | yes | WS_Teplá vnitřní 155 | 0
13060431 | 2.NP_SO-101 | 7141.9 | 0.000314112 | 0.448739 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7141.9 | ø20 | 15.4 | TR10.02.0278 | 0278 | yes | WS_Studená vnitřní 151 | 0
13060441 | 2.NP_SO-101 | 1261.43 | 0.000314112 | 0.0792583 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1261.43 | ø20 | 15.4 | TR10.02.0279 | 0279 | no | WS_Studená vnitřní 151 | 0
13060449 | 2.NP_SO-101 | 1128.25 | 0.000314112 | 0.0708902 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1128.25 | ø20 | 15.4 | TR10.02.0280 | 0280 | no | WS_Studená vnitřní 151 | 0
13060459 | 2.NP_SO-101 | 822.538 | 0.000314112 | 0.0516816 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 822.538 | ø20 | 15.4 | TR10.02.0281 | 0281 | no | WS_Studená vnitřní 151 | 0
13060500 | 2.NP_SO-101 | 2139 | 0.000314112 | 0.134397 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2139 | ø20 | 15.4 | TR10.02.0282 | 0282 | yes | WS_Studená vnitřní 151 | 0
13060531 | 2.NP_SO-101 | 7367.44 | 0.000201032 | 0.370328 | ø16 mm | 0 | 0 | Laminární | 0.000862069 | F | JB | 2.NP_SO-101 | 3357.17 | 3349.17 | 3349.17 | 3341.17 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S3.2 | WS_Cirkulace vnitřní 2 | 7343.37 | PP–RCT S3,2 | 16 | 23 | Trubka Evo, S3.2 - ø16 | ø16 | 7367.44 | ø16 | 11.6 | TR10.02.0283 | 0283 | yes | WS_Teplá vnitřní 155; WS_Cirkulace vnitřní 2 | 0
13060620 | 2.NP_SO-101 | 1963.27 | 0.000804127 | 0.197369 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3365.17 | 3349.17 | 3349.17 | 3333.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7336.77 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1963.27 | ø32 | 24.8 | TR10.02.0284 | 0284 | yes | WS_Teplá vnitřní 155 | 0
13060631 | 2.NP_SO-101 | 7465.08 | 0.000314112 | 0.469044 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7465.08 | ø20 | 15.4 | TR10.02.0285 | 0285 | yes | WS_Teplá vnitřní 155 | 0
13060649 | 2.NP_SO-101 | 905.075 | 0.000314112 | 0.0568675 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 905.075 | ø20 | 15.4 | TR10.02.0286 | 0286 | no | WS_Teplá vnitřní 155 | 0
13060659 | 2.NP_SO-101 | 662.538 | 0.000314112 | 0.0416285 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 662.538 | ø20 | 15.4 | TR10.02.0287 | 0287 | no | WS_Teplá vnitřní 155 | 0
13060686 | 2.NP_SO-101 | 1163.76 | 0.000314112 | 0.0731212 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1163.76 | ø20 | 15.4 | TR10.02.0288 | 0288 | no | WS_Teplá vnitřní 155 | 0
13060692 | 2.NP_SO-101 | 114.254 | 0.000314112 | 0.00717879 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 114.254 | ø20 | 15.4 | TR10.02.0289 | 0289 | no | WS_Teplá vnitřní 155 | 0
13060766 | 2.NP_SO-101 | 6621.41 | 0.0004908 | 0.520044 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3361.67 | 3349.17 | 3349.17 | 3336.67 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7339.47 | PP–RCT S4 | 25 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6621.41 | ø25 | 19.4 | TR10.02.0290 | 0290 | yes | WS_Cirkulace vnitřní 2 | 0
13060819 | 2.NP_SO-101 | 2081.36 | 0.000314112 | 0.130775 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2081.36 | ø20 | 15.4 | TR10.02.0291 | 0291 | yes | WS_Teplá vnitřní 155 | 0
13060825 | 2.NP_SO-101 | 19353.6 | 0.000314112 | 1.21602 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19353.6 | ø20 | 15.4 | TR10.02.0292 | 0292 | yes | WS_Teplá vnitřní 155 | 0
13061290 | 1.NP_SO-101 | 334.32 | 0.0019632 | 0.0525149 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | -108.596 | -442.916 | -108.596 | -442.916 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -442.916 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 334.32 | ø50 | 38.8 | TR10.02.0293 | 0293 | yes | WS_Teplá vnitřní 155
13061327 | 1.NP_SO-101 | 560.64 | 0.00125645 | 0.0704521 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3384.5 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 560.64 | ø40 | 31 | TR10.02.0294 | 0294 | yes | WS_Teplá vnitřní 155 | 0
13061343 | 1.NP_SO-101 | 2887.84 | 0.00125645 | 0.362897 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3420 | 3400 | 3400 | 3380 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3384.5 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2887.84 | ø40 | 31 | TR10.02.0295 | 0295 | yes | WS_Teplá vnitřní 155 | 0
