Properties of the parts of a building model (IFC4), part 10 of 26

# IfcDistributionPort (5006)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_13192408_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
OutPort_13192399_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
InPort_13192400_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
InPort_13192406_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
OutPort_13192400_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
Port_13192401_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192402_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192401_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192404_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
OutPort_13192408_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
InPort_13192404_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
OutPort_13192406_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
InPort_13192425_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_13192434_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
OutPort_13192425_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_13192426_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
InPort_13192432_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
OutPort_13192426_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
Port_13192427_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192428_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192427_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192430_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
OutPort_13192434_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_13192430_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
OutPort_13192432_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
InPort_13192451_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_13192460_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
OutPort_13192451_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_13192452_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
InPort_13192458_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
OutPort_13192452_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
Port_13192453_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192454_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192453_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192456_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
OutPort_13192460_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_13192456_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
OutPort_13192458_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
InPort_13192535_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_13192544_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
OutPort_13192535_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_13192536_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
InPort_13192542_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
OutPort_13192536_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_13192537_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192538_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13192537_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13192540_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
OutPort_13192544_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_13192540_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
OutPort_13192542_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_13192628_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192629_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13192649_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13192650_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13192674_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13192674_3 | SOURCE | PIPE | SEWAGE
Port_13192674_4 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_13199665_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13198765_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13198877_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13198973_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13199359_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13198877_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13198941_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13198965_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13198965_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13198966_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13198973_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13198965_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13198977_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13199359_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13199363_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13198977_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13199068_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199487_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199491_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199068_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199077_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199087_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199487_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199077_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13199079_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13199080_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199087_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199079_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199347_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13234168_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13234172_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13199347_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13234168_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13199348_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13199348_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
OutPort_13199363_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13199475_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13234175_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13234179_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199475_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13234175_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199476_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13199476_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13199491_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13199617_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199848_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199626_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199677_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199679_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199626_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199665_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199669_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199891_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199666_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199666_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199679_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199669_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199891_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199712_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199714_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199802_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199751_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199802_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199847_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199848_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13199875_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13199847_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13199928_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203677_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13199928_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13200209_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203730_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13200209_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13239392_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200501_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200501_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275814_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239418_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200514_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200514_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275817_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239090_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200527_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200527_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275819_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240018_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200538_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200538_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279408_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239875_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200568_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200568_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279410_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239414_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13200854_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13200854_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239418_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239602_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13201954_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13201954_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239392_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13202762_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203677_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13202762_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203681_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13202960_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228159_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203033_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203145_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203033_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203241_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203132_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203145_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203132_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203157_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203157_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203682_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203219_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203730_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203219_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203241_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203424_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203598_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203424_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203602_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203598_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203674_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203674_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203681_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203681_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13203682_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13205378_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205198_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205382_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205204_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205377_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205282_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205282_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205382_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275421_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205377_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13205377_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13205378_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13206830_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13221848_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13206830_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13207155_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207380_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207155_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207372_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207380_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207372_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13207397_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13240317_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13209791_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13209791_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279412_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13238785_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13209804_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13209804_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279414_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13210458_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13238782_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239640_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13210458_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13211340_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288966_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288990_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13211340_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13211847_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13234220_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288069_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13211847_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288493_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13212569_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13212569_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288532_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13214134_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288497_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13214505_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13214134_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13214300_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13288493_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13288497_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13214300_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13214497_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13279252_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278775_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13214497_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13279253_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13214505_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13215383_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289799_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13215383_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430054_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216085_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217140_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216085_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216231_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216225_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216226_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216225_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216231_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13216871_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13216850_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13216850_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13216873_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216862_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217084_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13216862_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289799_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13216862_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13216871_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217084_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13289912_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217140_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430579_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217161_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430554_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217161_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430586_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13217581_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13217554_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13217554_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13217586_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13217579_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13217581_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13217586_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13438421_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217729_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430838_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217729_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217817_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217802_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217821_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217802_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217823_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217815_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217817_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217815_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13217821_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13218078_1 | SINK | PIPE | SEWAGE
OutPort_13218069_1 | SOURCE | PIPE | SEWAGE
InPort_13218070_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
InPort_13218072_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
OutPort_13218070_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
InPort_13218071_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
InPort_13218074_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
OutPort_13218071_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
InPort_13218076_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
OutPort_13218072_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
InPort_13218076_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
OutPort_13218074_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
Port_13218078_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13218190_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13218190_2 | SINK | PIPE | DOMESTICHOTWATER
Port_13218190_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_13218191_1 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13218192_1 | SOURCE | PIPE | SEWAGE
Port_13218240_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13218243_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13218426_1 | SINK | PIPE | SEWAGE
OutPort_13218417_1 | SOURCE | PIPE | SEWAGE
InPort_13218418_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
InPort_13218420_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
OutPort_13218418_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
InPort_13218419_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
InPort_13218422_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
OutPort_13218419_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
InPort_13218424_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
OutPort_13218420_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
InPort_13218424_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
OutPort_13218422_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
Port_13218426_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13218522_1 | SINK | PIPE | SEWAGE
OutPort_13218513_1 | SOURCE | PIPE | SEWAGE
InPort_13218514_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
InPort_13218516_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
OutPort_13218514_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
InPort_13218515_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
InPort_13218518_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
OutPort_13218515_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
InPort_13218520_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
OutPort_13218516_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
InPort_13218520_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
OutPort_13218518_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
Port_13218522_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13218557_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219192_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13218557_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
InPort_13218689_1 | SINK | PIPE | SEWAGE
OutPort_13218680_1 | SOURCE | PIPE | SEWAGE
InPort_13218681_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13218683_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
OutPort_13218681_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13218682_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
InPort_13218685_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
OutPort_13218682_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
InPort_13218687_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
OutPort_13218683_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13218687_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
OutPort_13218685_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
Port_13218689_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13219217_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235672_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13219217_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13219230_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235885_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13219230_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13219263_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291379_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219263_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219750_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291382_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219750_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13291376_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219810_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221859_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13219810_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287012_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13220059_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13287326_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13220059_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221846_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13277950_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13221846_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13221848_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13221857_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221864_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221857_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221870_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221859_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221860_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221859_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221864_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221867_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221870_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13221867_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 8
Port_13222501_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235885_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13222501_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235889_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13222907_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234865_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13222907_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13222942_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234905_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13222942_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13227585_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228154_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13227585_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13227622_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235200_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13227622_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228018_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228154_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228018_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228165_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228158_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228159_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228158_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235179_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228158_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13228165_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13229443_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229447_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229443_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229449_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229444_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229449_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13229491_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13229495_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13229491_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13229497_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13229492_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13229497_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231690_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242396_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13231690_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242398_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13233991_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13383352_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13234026_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13384289_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13383427_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13234031_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13234039_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13383142_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13234220_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13234222_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13234751_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234765_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234751_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234869_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234765_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234766_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234765_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234799_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234771_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234865_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234869_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234799_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234970_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234826_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234905_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234826_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13234970_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235168_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235178_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235168_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235204_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235178_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235179_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235184_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235200_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235184_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235204_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13235460_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235468_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235460_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235676_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235468_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235469_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235469_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236029_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235474_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235672_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235474_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235676_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235537_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235580_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235537_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235572_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235580_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235572_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235641_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235825_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235833_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235825_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235889_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235833_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235834_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235908_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235914_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235908_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235910_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235914_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235910_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236025_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235912_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236025_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13235912_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236029_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236029_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13236030_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13261786_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13236467_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13236467_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13236542_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13238782_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13238785_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239075_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239090_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239109_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239075_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239415_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239109_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239259_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239414_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239600_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239259_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239523_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239388_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239388_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239600_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239388_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239602_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239414_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239415_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274370_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239523_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239626_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239640_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239669_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239626_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239644_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239669_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240600_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239644_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239669_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239680_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239680_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239749_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239749_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239734_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239734_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239899_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239821_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239875_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239894_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239821_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240023_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239894_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239899_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240308_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13239920_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240018_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240022_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13239920_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240322_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240022_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240022_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240023_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240255_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240317_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240329_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240255_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240308_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240321_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240321_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240339_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240321_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240329_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240339_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240322_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240464_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240600_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240721_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240464_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240650_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240721_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240725_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240650_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240714_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240725_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13268067_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240714_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240725_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13240726_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13240726_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275510_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13242383_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242399_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242385_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242393_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242393_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242398_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242398_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13242399_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13261788_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13247143_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13247143_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13261786_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13259811_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13261781_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13261779_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13261783_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13261781_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
Port_13261783_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 81
InPort_13261789_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13261788_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13262368_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262370_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262368_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13265034_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262370_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13262371_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13262763_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13262447_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13262542_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13262760_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13262762_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13262774_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13262760_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13262762_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13262763_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13264345_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264346_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13264659_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13264673_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13264659_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13264676_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13264669_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13264670_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13264673_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
OutPort_13264669_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13264874_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264956_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264944_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264955_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264955_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264956_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264955_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13264963_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13265366_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13265368_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13265384_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13265386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13267380_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13271544_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13272538_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267380_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13271544_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267513_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13267513_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267758_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13267758_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267748_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13267748_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267910_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13267910_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13267895_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13267895_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13268067_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13268459_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429701_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273715_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13268459_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13268601_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13429600_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429701_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13268601_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13271593_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273715_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13272538_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13271593_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13278603_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13272538_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273394_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273383_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273383_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273413_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273395_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273394_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273413_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273401_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273401_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273425_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273425_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273419_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273419_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275803_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273528_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273543_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273554_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273528_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275978_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273554_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273728_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273998_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274003_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13273728_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13273998_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275962_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274004_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274003_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13429450_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274004_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274382_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274370_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274659_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274382_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274391_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274659_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274663_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274391_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274510_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274453_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13274453_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13274663_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275718_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275421_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275510_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275500_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275500_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275552_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275723_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275550_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275550_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275639_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275552_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275724_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275615_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275635_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275639_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275615_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275675_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275718_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275723_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275675_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275724_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275723_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275977_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275922_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275922_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275981_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275962_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275977_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13275977_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13275978_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13276095_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13433048_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13276211_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13276095_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13276181_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13276211_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
