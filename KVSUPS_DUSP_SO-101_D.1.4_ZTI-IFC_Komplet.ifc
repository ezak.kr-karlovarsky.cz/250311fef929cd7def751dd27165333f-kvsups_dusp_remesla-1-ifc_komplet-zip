Properties of the parts of a building model (IFC4), part 17 of 26

# IfcPipeFitting: M_Křížení, obecné:Standardní (2)
Kóty - Úhel 1: 90 deg; Úhel 2: 90 deg; Jmenovitý poloměr: 10 mm; Jmenovitý průměr: 20 mm; Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000296322 m3; Od středu ke konci: 23.8125 mm; Velikost: ø20-ø20-ø20-ø20; Velikost značky: 8.89 mm; Vnější průměr tvarovky: 22.225 mm
Jiné - Páteřní trasa: no; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Štítek, od středu ke konci: 23.8125 mm; Vnější poloměr tvarovky: 11.1125 mm
Name (M_Křížení, obecné:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13192068 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | TT06.06.0487 | 0487
13192160 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | TT06.06.0489 | 0489

# IfcPipeFitting: M_Křížení, obecné:Standardní (2)
In: -1.PP_SO-101
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 06; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm-ø25 mm-ø25 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: 2300 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Jmenovitý poloměr: 12.5 mm; Jmenovitý průměr: 25 mm; Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000536717 m3; Od středu ke konci: 26.9875 mm; Úhel 2: 90 deg; Velikost: ø25-ø25-ø25-ø25; Velikost značky: 11.43 mm; Vnější průměr tvarovky: 28.575 mm
Jiné - Páteřní trasa: no; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Štítek, od středu ke konci: 26.9875 mm; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Vnější poloměr tvarovky: 14.2875 mm
Name (M_Křížení, obecné:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13190677 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | TT06.06.0476 | 0476
13190706 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | TT06.06.0479 | 0479

# IfcPipeFitting: M_Přechod, obecný:Standardní (47)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13053586 | 4.NP_SO-101 | ø50 mm-ø20 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0052 | 0052 | no | 53.975 | yes | no | 11.1125 | 26.9875
13054530 | 4.NP_SO-101 | ø50 mm-ø25 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0070 | 0070 | no | 53.975 | yes | no | 14.2875 | 26.9875
13054532 | 4.NP_SO-101 | ø50 mm-ø25 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0071 | 0071 | no | 53.975 | yes | no | 14.2875 | 26.9875
13054536 | 4.NP_SO-101 | ø50 mm-ø25 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0072 | 0072 | no | 53.975 | yes | no | 14.2875 | 26.9875
13054538 | 4.NP_SO-101 | ø50 mm-ø25 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0073 | 0073 | no | 53.975 | yes | no | 14.2875 | 26.9875
13054540 | 4.NP_SO-101 | ø50 mm-ø25 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0074 | 0074 | no | 53.975 | yes | no | 14.2875 | 26.9875
13057977 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0121 | 0121 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13057985 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0122 | 0122 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13058085 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0129 | 0129 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13058094 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0131 | 0131 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13058144 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0135 | 0135 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13058153 | 3.NP_SO-101 | ø50 mm-ø25 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0136 | 0136 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13060012 | 2.NP_SO-101 | ø20 mm-ø15 mm | WPA | 2.NP_SO-101 | 594.287 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT00.04.0170 | 0170 | no | 22.225 | no | yes | 11.1125 | 7.9375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060095 | 2.NP_SO-101 | ø20 mm-ø15 mm | WPA | 2.NP_SO-101 | 594.287 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT00.04.0174 | 0174 | no | 22.225 | no | yes | 11.1125 | 7.9375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061001 | 2.NP_SO-101 | ø32 mm-ø20 mm | WPA | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.04.0205 | 0205 | yes | 34.925 | no | yes | 17.4625 | 11.1125
13061003 | 2.NP_SO-101 | ø32 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.04.0206 | 0206 | yes | 34.925 | no | yes | 17.4625 | 11.1125
13061030 | 2.NP_SO-101 | ø32 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.04.0209 | 0209 | yes | 34.925 | no | yes | 17.4625 | 11.1125
13061053 | 2.NP_SO-101 | ø32 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.04.0211 | 0211 | yes | 34.925 | no | yes | 17.4625 | 11.1125
13062030 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0230 | 0230 | no | 53.975 | yes | no | 14.2875 | 26.9875
13062934 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0253 | 0253 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13062950 | 1.NP_SO-101 | ø50 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0254 | 0254 | no | 53.975 | yes | no | 11.1125 | 26.9875
13063000 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0255 | 0255 | no | 53.975 | yes | no | 14.2875 | 26.9875
13063005 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0256 | 0256 | no | 53.975 | yes | no | 14.2875 | 26.9875
13063007 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0257 | 0257 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13063042 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0259 | 0259 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13063049 | 1.NP_SO-101 | ø50 mm-ø25 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0260 | 0260 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13064142 | -1.PP_SO-101 | ø50 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0275 | 0275 | no | 53.975 | yes | no | 11.1125 | 26.9875
13064251 | -1.PP_SO-101 | ø50 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0279 | 0279 | no | 53.975 | yes | no | 11.1125 | 26.9875
13064474 | -1.PP_SO-101 | ø50 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0282 | 0282 | no | 53.975 | yes | no | 11.1125 | 26.9875
13064476 | -1.PP_SO-101 | ø50 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.04.0283 | 0283 | no | 53.975 | yes | no | 11.1125 | 26.9875
13064482 | -1.PP_SO-101 | ø50 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0284 | 0284 | no | 53.975 | yes | no | 14.2875 | 26.9875
13064491 | -1.PP_SO-101 | ø50 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0285 | 0285 | no | 53.975 | yes | no | 14.2875 | 26.9875
13067630 | -1.PP_SO-101 | ø32 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.04.0296 | 0296 | no | 34.925 | no | yes | 17.4625 | 11.1125
13148646 | -1.PP_SO-101 | ø50 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0401 | 0401 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13148683 | -1.PP_SO-101 | ø50 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.04.0404 | 0404 | yes | 53.975 | yes | no | 14.2875 | 26.9875
13158612 | 3.NP_SO-101 | ø40 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.04.0414 | 0414 | yes | 41.275 | no | yes | 20.6375 | 17.4625
13158647 | 3.NP_SO-101 | ø40 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.04.0417 | 0417 | yes | 41.275 | no | yes | 20.6375 | 17.4625
13160140 | 1.NP_SO-101 | ø40 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.04.0424 | 0424 | yes | 41.275 | no | yes | 20.6375 | 17.4625
13160588 | 1.NP_SO-101 | ø40 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.04.0428 | 0428 | yes | 41.275 | yes | no | 17.4625 | 20.6375
13160590 | 1.NP_SO-101 | ø40 mm-ø32 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.04.0429 | 0429 | yes | 41.275 | yes | no | 17.4625 | 20.6375
13234172 | 1.NP_SO-101 | ø20 mm-ø15 mm | WPA | 1.NP_SO-101 | 580 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT00.04.0573 | 0573 | no | 22.225 | yes | no | 7.9375 | 11.1125 | Mechanické – tok - Tlaková ztráta: 0 Pa
13234179 | 1.NP_SO-101 | ø20 mm-ø15 mm | WPA | 1.NP_SO-101 | 580 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT00.04.0575 | 0575 | no | 22.225 | yes | no | 7.9375 | 11.1125 | Mechanické – tok - Tlaková ztráta: 0 Pa
13262907 | -1.PP_SO-101 | ø32 mm-ø25 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.04.0654 | 0654 | no | 34.925 | no | yes | 17.4625 | 14.2875
13377129 | 2.NP_SO-101 | ø50 mm-ø32 mm | WPA | 2.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 16 | 25 | 32 | 50 | 50 | 32 | 0.0000212148 | 0.00315461 | ø50-ø32 | 13.97 | 21.59 | 34.925 | 53.975 | TT00.04.0788 | 0788 | yes | 53.975 | no | yes | 26.9875 | 17.4625
13377152 | 2.NP_SO-101 | ø50 mm-ø32 mm | WPA | 2.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 16 | 25 | 32 | 50 | 50 | 32 | 0.0000212148 | 0.00315461 | ø50-ø32 | 13.97 | 21.59 | 34.925 | 53.975 | TT00.04.0794 | 0794 | yes | 53.975 | no | yes | 26.9875 | 17.4625
13384296 | 1.NP_SO-101 | ø50 mm-ø40 mm | QMA | 1.NP_SO-101 | 3200 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.04.0846 | 0846 | yes | 53.975 | yes | no | 20.6375 | 26.9875
13384915 | 1.NP_SO-101 | ø50 mm-ø40 mm | QMA | 1.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.04.0851 | 0851 | yes | 53.975 | yes | no | 20.6375 | 26.9875

# IfcPipeFitting: M_Přechod, obecný:Standardní (13)
Type - Material: 032-175-175
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13161835 | -1.PP_SO-101 | ø28 mm-ø25 mm | WPA | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.04.0433 | 0433 | yes | no | yes | 31.175 | 15.5875 | 14.2875
13162474 | 2.NP_SO-101 | ø28 mm-ø25 mm | WPA | 2.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.04.0437 | 0437 | yes | no | yes | 31.175 | 15.5875 | 14.2875
13163589 | 3.NP_SO-101 | ø28 mm-ø25 mm | WPA | 3.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.04.0442 | 0442 | yes | no | yes | 31.175 | 15.5875 | 14.2875
13163737 | 3.NP_SO-101 | ø35 mm-ø28 mm | WPA | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0445 | 0445 | yes | yes | no | 38.175 | 15.5875 | 19.0875
13164491 | 4.NP_SO-101 | ø28 mm-ø25 mm | WPA | 4.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 7.79375 | 14 | 12.5 | 28 | 25 | 28 | 25 | 0.0000054459 | 0.00124003 | ø28-ø25 | 12.47 | 11.43 | 31.175 | 28.575 | TT00.04.0455 | 0455 | yes | yes | no | 31.175 | 14.2875 | 15.5875
13164494 | 3.NP_SO-101 | ø35 mm-ø28 mm | WPA | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0456 | 0456 | yes | yes | no | 38.175 | 15.5875 | 19.0875
13164501 | 3.NP_SO-101 | ø35 mm-ø28 mm | WPA | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0457 | 0457 | yes | yes | no | 38.175 | 15.5875 | 19.0875
13164569 | 1.NP_SO-101 | ø28 mm-ø25 mm | WPA | 1.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.04.0458 | 0458 | yes | no | yes | 31.175 | 15.5875 | 14.2875
13164640 | -1.PP_SO-101 | ø35 mm-ø28 mm | WPA | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0459 | 0459 | yes | yes | no | 38.175 | 15.5875 | 19.0875
13262887 | -1.PP_SO-101 | ø28 mm-ø25 mm | WPA | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.79375 | 14 | 12.5 | 28 | 25 | 28 | 25 | 0.0000054459 | 0.00124003 | ø28-ø25 | 12.47 | 11.43 | 31.175 | 28.575 | TT00.04.0652 | 0652 | no | yes | no | 31.175 | 14.2875 | 15.5875
13374798 | 2.NP_SO-101 | ø35 mm-ø28 mm | QMA | 2.NP_SO-101 | 2990 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0778 | 0778 | yes | yes | no | 38.175 | 15.5875 | 19.0875
13377097 | 2.NP_SO-101 | ø35 mm-ø28 mm | QMA | 2.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 14 | 17.5 | 28 | 35 | 35 | 28 | 0.00000901755 | 0.00175717 | ø35-ø28 | 12.47 | 15.27 | 31.175 | 38.175 | TT00.04.0782 | 0782 | yes | no | yes | 38.175 | 19.0875 | 15.5875
13384873 | 1.NP_SO-101 | ø35 mm-ø28 mm | QMA | 1.NP_SO-101 | 3425 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.04.0848 | 0848 | yes | yes | no | 38.175 | 15.5875 | 19.0875

# IfcPipeFitting: M_Přechod, obecný:Standardní (27)
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Tlaková ztráta (Pa) | CCI Komponenta | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Viditelnost 1 | Viditelnost 2 | Viditelnost 3 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13133973 | -1.PP_SO-101 | ø135 mm-ø78 mm | 0 | WPA | JD | -1.PP_SO-101 | 2318.92 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.04.0372 | 0372 | yes | 3048 | no | yes | no | 3048 | 138.175 | 40.5875 | 69.0875
13134160 | -1.PP_SO-101 | ø135 mm-ø78 mm | 0 | WPA | JD | -1.PP_SO-101 | 2371.37 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.04.0376 | 0376 | yes | 3048 | no | yes | no | 3048 | 138.175 | 40.5875 | 69.0875
13134726 | -1.PP_SO-101 | ø135 mm-ø78 mm |  | WPA | JD | -1.PP_SO-101 | 2495.61 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.04.0379 | 0379 | yes | 3048 | no | yes | no | 3048 | 138.175 | 40.5875 | 69.0875
13135836 | -1.PP_SO-101 | ø135 mm-ø78 mm | 0 | WPA | JD | -1.PP_SO-101 | 2497.17 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.04.0396 | 0396 | yes | 3048 | no | yes | no | 3048 | 138.175 | 40.5875 | 69.0875
13216231 | -1.PP_SO-101 | ø135 mm-ø135 mm |  | WPA | JD | -1.PP_SO-101 | 2410.83 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 67.5 | 135 | 135 | 135 | 135 | 0.000517876 | 67.4316 | 75.7518 | 0.0282116 | ø135-ø135 | 55.27 | 55.27 | 138.175 | 138.175 | TT00.04.0531 | 0531 | yes | 3047.93 | yes | no | no | 3056.25 | 138.175 | 69.0875 | 69.0875
13216871 | -1.PP_SO-101 | ø135 mm-ø110 mm | 8.72125 | WPA | JD | -1.PP_SO-101 | 2767.71 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.356 | 67.5 | 0.0243461 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.04.0533 | 0533 | yes | 3047.86 | no | yes | no | 3048 | 138.175 | 56.5875 | 69.0875
13217581 | 3.NP_SO-101 | ø110 mm-ø78 mm | 0 | WPA | JD | 3.NP_SO-101 | 3307.6 | SW_Splašky vnitřní gravitační 10 | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39.002 | 39 | 0.0151071 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.04.0537 | 0537 | yes | 3048 | no | no | yes | 3048 | 113.175 | 56.5875 | 40.5875
13221864 | -1.PP_SO-101 | ø110 mm-ø110 mm |  | WPA | JD | -1.PP_SO-101 | -1788.98 | SW_Splašky vnitřní gravitační 8 | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 54.9774 | 52.2726 | 0.0187584 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.04.0546 | 0546 | yes | 3047.98 | yes | no | no | 3045.27 | 113.175 | 56.5875 | 56.5875
13228165 | -1.PP_SO-101 | ø110 mm-ø110 mm |  | WPA | JD | -1.PP_SO-101 | -1592.18 | SW_Splašky vnitřní gravitační 4 | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 55.056 | 61.7584 | 0.0188487 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.04.0550 | 0550 | yes | 3048.06 | yes | no | no | 3054.76 | 113.175 | 56.5875 | 56.5875
13234222 | 4.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 4.NP_SO-101 | 127.101 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 29 | 39 | 58 | 78 | 78 | 58 | 0.0000811899 | 29 | 29 | 0.00789529 | ø78-ø58 | 24.47 | 32.47 | 61.175 | 81.175 | TT00.04.0577 | 0577 | no | 3048 | no | no | yes | 3048 | 81.175 | 40.5875 | 30.5875
13235293 | -1.PP_SO-101 | ø110 mm-ø75 mm |  | WPA | JD | -1.PP_SO-101 | -1580.88 | SW_Splašky vnitřní gravitační 3 | 28.2938 | 37.5 | 55 | 75 | 110 | 110 | 75 | 0.000205589 | 37.2446 | 37.58 | 0.0148265 | ø110-ø75 | 31.27 | 45.27 | 78.175 | 113.175 | TT00.04.0586 | 0586 | yes | 3047.74 | no | no | yes | 3048.08 | 113.175 | 56.5875 | 39.0875
13238785 | 1.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 1.NP_SO-101 | 3440.01 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 29 | 39 | 58 | 78 | 78 | 58 | 0.0000811899 | 29 | 29 | 0.00789529 | ø78-ø58 | 24.47 | 32.47 | 61.175 | 81.175 | TT00.04.0601 | 0601 | no | 3048 | no | no | yes | 3048 | 81.175 | 40.5875 | 30.5875
13239600 | 1.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 1.NP_SO-101 | 3365.78 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.04.0608 | 0608 | no | 3048 | no | yes | no | 3048 | 81.175 | 30.5875 | 40.5875
13239602 | 1.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 1.NP_SO-101 | 3435.06 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.04.0609 | 0609 | no | 3048 | no | yes | no | 3048 | 81.175 | 30.5875 | 40.5875
13240329 | 1.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 1.NP_SO-101 | 3475.95 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.04.0620 | 0620 | no | 3048 | no | yes | no | 3048 | 81.175 | 30.5875 | 40.5875
13240339 | 1.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 1.NP_SO-101 | 3407.54 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.04.0621 | 0621 | no | 3048 | no | yes | no | 3048 | 81.175 | 30.5875 | 40.5875
13278572 | -1.PP_SO-101 | ø250 mm-ø200 mm |  | WPA | JD | -1.PP_SO-101 | 2055.99 | SW_Splašky vnitřní gravitační 10 | 64.2938 | 100 | 125 | 200 | 250 | 250 | 200 | 0.00272323 | 100 | 100 | 0.0830327 | ø250-ø200 | 82.55 | 102.87 | 206.375 | 257.175 | TT00.04.0707 | 0707 | yes | 3048 | no | no | yes | 3048 | 257.175 | 128.588 | 103.188
13278593 | -1.PP_SO-101 | ø200 mm-ø135 mm |  | WPA | JD | -1.PP_SO-101 | 2240.82 | SW_Splašky vnitřní gravitační 10 | 51.5938 | 100 | 67.5 | 200 | 135 | 200 | 135 | 0.00121812 | 100 | 100 | 0.0487039 | ø200-ø135 | 82.55 | 55.27 | 206.375 | 138.175 | TT00.04.0708 | 0708 | yes | 3048 | no | yes | no | 3048 | 206.375 | 69.0875 | 103.188
13278603 | -1.PP_SO-101 | ø110 mm-ø78 mm | 0 | WPA | JD | -1.PP_SO-101 | 2366.36 | SW_Splašky vnitřní gravitační 10 | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39 | 39 | 0.015107 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.04.0709 | 0709 | yes | 3048 | no | no | yes | 3048 | 113.175 | 56.5875 | 40.5875
13278929 | -1.PP_SO-101 | ø200 mm-ø160 mm | 0 | WPA | JD | -1.PP_SO-101 | 2240.49 | SW_Splašky vnitřní gravitační 10 | 51.5938 | 100 | 80 | 200 | 160 | 200 | 160 | 0.00138957 | 100 | 100 | 0.0530888 | ø200-ø160 | 82.55 | 65.27 | 206.375 | 163.175 | TT00.04.0712 | 0712 | yes | 3048 | no | yes | no | 3048 | 206.375 | 81.5875 | 103.188
13278995 | -1.PP_SO-101 | ø160 mm-ø110 mm | 0 | WPA | JD | -1.PP_SO-101 | 2279.44 | SW_Splašky vnitřní gravitační 10 | 40.7937 | 55 | 80 | 110 | 160 | 160 | 110 | 0.000618234 | 55 | 55 | 0.0311347 | ø160-ø110 | 45.27 | 65.27 | 113.175 | 163.175 | TT00.04.0713 | 0713 | yes | 3048 | no | no | yes | 3048 | 163.175 | 81.5875 | 56.5875
13279261 | -1.PP_SO-101 | ø160 mm-ø110 mm | 0 | WPA | JD | -1.PP_SO-101 | 2488.07 | SW_Splašky vnitřní gravitační 10 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.04.0715 | 0715 | yes | 3048 | no | yes | no | 3048 | 163.175 | 56.5875 | 81.5875
13279278 | -1.PP_SO-101 | ø160 mm-ø78 mm | 0 | WPA | JD | -1.PP_SO-101 | 2395.67 | SW_Splašky vnitřní gravitační 10 | 40.7937 | 80 | 39 | 160 | 78 | 160 | 78 | 0.000496014 | 80 | 80 | 0.0274148 | ø160-ø78 | 65.27 | 32.47 | 163.175 | 81.175 | TT00.04.0718 | 0718 | yes | 3048 | no | yes | no | 3048 | 163.175 | 40.5875 | 81.5875
13288966 | 4.NP_SO-101 | ø78 mm-ø58 mm | 0 | WPA | JD | 4.NP_SO-101 | 236.266 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 29 | 39 | 58 | 78 | 78 | 58 | 0.0000811899 | 29 | 29 | 0.00789529 | ø78-ø58 | 24.47 | 32.47 | 61.175 | 81.175 | TT00.04.0746 | 0746 | no | 3048 | no | no | yes | 3048 | 81.175 | 40.5875 | 30.5875
13289799 | -1.PP_SO-101 | ø135 mm-ø78 mm |  | WPA | JD | -1.PP_SO-101 | 2649.78 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.04.0754 | 0754 | yes | 3048 | no | yes | no | 3048 | 138.175 | 40.5875 | 69.0875
13430586 | -1.PP_SO-101 | ø135 mm-ø110 mm |  | WPA | JD | -1.PP_SO-101 | 2452.64 | SW_Splašky vnitřní gravitační 10 | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 123.468 | 67.5 | 0.0274896 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.04.0908 | 0908 | yes | 3103.97 | no | yes | no | 3048 | 138.175 | 56.5875 | 69.0875
13432886 | 1.NP_SO-101 | ø78 mm-ø78 mm | 0 | QMA | JB | 1.NP_SO-101 | 3480.82 | SW_Splašky vnitřní gravitační 10 | 20.2938 | 39 | 39 | 78 | 78 | 78 | 78 | 0.000104955 | 37.0863 | 36.5787 | 0.00957247 | ø78-ø78 | 32.47 | 32.47 | 81.175 | 81.175 | TT00.04.0918 | 0918 | yes | 3046.09 | yes | no | no | 3045.58 | 81.175 | 40.5875 | 40.5875

# IfcPipeFitting: M_Přechod, obecný:Standardní (41)
Type - Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13067310 | 4.NP_SO-101 | ø32 mm-ø25 mm | WPA | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.04.0288 | 0288 | no | no | yes | 34.925 | 17.4625 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13067615 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0294 | 0294 | no | yes | no | 28.575 | 11.1125 | 14.2875
13067617 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0295 | 0295 | no | yes | no | 28.575 | 11.1125 | 14.2875
13067749 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0299 | 0299 | no | yes | no | 28.575 | 11.1125 | 14.2875
13067751 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0300 | 0300 | no | yes | no | 28.575 | 11.1125 | 14.2875
13072333 | 4.NP_SO-101 | ø25 mm-ø20 mm | WPA | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0304 | 0304 | no | yes | no | 28.575 | 11.1125 | 14.2875
13127863 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0345 | 0345 | no | yes | no | 28.575 | 11.1125 | 14.2875
13127865 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0346 | 0346 | no | yes | no | 28.575 | 11.1125 | 14.2875
13127912 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0348 | 0348 | no | yes | no | 28.575 | 11.1125 | 14.2875
13157337 | -1.PP_SO-101 | ø40 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.04.0409 | 0409 | yes | yes | no | 41.275 | 11.1125 | 20.6375
13158700 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0419 | 0419 | yes | yes | no | 28.575 | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13158746 | -1.PP_SO-101 | ø40 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.04.0421 | 0421 | yes | yes | no | 41.275 | 11.1125 | 20.6375
13164664 | -1.PP_SO-101 | ø50 mm-ø40 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.04.0461 | 0461 | yes | yes | no | 53.975 | 20.6375 | 26.9875
13190679 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0477 | 0477 | no | yes | no | 28.575 | 11.1125 | 14.2875
13190681 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0478 | 0478 | no | yes | no | 28.575 | 11.1125 | 14.2875
13190708 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0480 | 0480 | no | yes | no | 28.575 | 11.1125 | 14.2875
13190710 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0481 | 0481 | no | yes | no | 28.575 | 11.1125 | 14.2875
13198973 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3373.01 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0497 | 0497 | no | yes | no | 28.575 | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199087 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3373.01 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0499 | 0499 | no | yes | no | 28.575 | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199875 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0511 | 0511 | yes | yes | no | 28.575 | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13199891 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 820.638 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0512 | 0512 | no | yes | no | 28.575 | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13229447 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0552 | 0552 | no | yes | no | 28.575 | 11.1125 | 14.2875
13229449 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0553 | 0553 | no | yes | no | 28.575 | 11.1125 | 14.2875
13229495 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0555 | 0555 | no | yes | no | 28.575 | 11.1125 | 14.2875
13229497 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0556 | 0556 | no | yes | no | 28.575 | 11.1125 | 14.2875
13229558 | 1.NP_SO-101 | ø25 mm-ø20 mm | WPA | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0559 | 0559 | no | yes | no | 28.575 | 11.1125 | 14.2875
13229780 | 1.NP_SO-101 | ø40 mm-ø32 mm | WPA | 1.NP_SO-101 | 3094.84 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.04.0560 | 0560 | yes | no | yes | 41.275 | 20.6375 | 17.4625
13262076 | 4.NP_SO-101 | ø25 mm-ø20 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0632 | 0632 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262099 | 4.NP_SO-101 | ø25 mm-ø20 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0633 | 0633 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262122 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0634 | 0634 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262124 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0635 | 0635 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262141 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0636 | 0636 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262143 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0637 | 0637 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262849 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0648 | 0648 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262851 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0649 | 0649 | no | yes | no | 28.575 | 11.1125 | 14.2875
13262905 | -1.PP_SO-101 | ø25 mm-ø20 mm | WPA | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0653 | 0653 | no | yes | no | 28.575 | 11.1125 | 14.2875
13377113 | 2.NP_SO-101 | ø32 mm-ø25 mm | WPA | 2.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.04.0785 | 0785 | yes | no | yes | 34.925 | 17.4625 | 14.2875
13377141 | 2.NP_SO-101 | ø32 mm-ø25 mm | WPA | 2.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.04.0791 | 0791 | yes | no | yes | 34.925 | 17.4625 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13378879 | 2.NP_SO-101 | ø50 mm-ø40 mm | QMA | 2.NP_SO-101 | 3220.21 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.04.0796 | 0796 | yes | yes | no | 53.975 | 20.6375 | 26.9875
13385399 | 1.NP_SO-101 | ø32 mm-ø20 mm | QMA | 1.NP_SO-101 | 3155.16 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.04.0864 | 0864 | yes | yes | no | 34.925 | 11.1125 | 17.4625
13439103 | -1.PP_SO-101 | ø25 mm-ø20 mm | QMA | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.04.0957 | 0957 |  | yes | no | 28.575 | 11.1125 | 14.2875

# IfcPipeFitting: M_Přechod, obecný:Standardní (50)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Komponenta | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 1 | Viditelnost 2 | Viditelnost 3 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13054550 | 4.NP_SO-101 | ø50 mm-ø32 mm | WPA | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0075 | 0075 | no | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13054558 | 4.NP_SO-101 | ø50 mm-ø32 mm | WPA | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0076 | 0076 | no | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13058014 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0123 | 0123 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13058016 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0124 | 0124 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13058056 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0127 | 0127 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13058058 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0128 | 0128 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13058087 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0130 | 0130 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13058096 | 3.NP_SO-101 | ø25 mm-ø20 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0132 | 0132 | no | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13058169 | 3.NP_SO-101 | ø50 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0137 | 0137 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Teplá vnitřní 155
13058179 | 3.NP_SO-101 | ø50 mm-ø32 mm | WPA | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.04.0138 | 0138 | yes | no | yes | no | 3048 | 53.975 | 17.4625 | 26.9875 | WS_Studená vnitřní 151
13058246 | 4.NP_SO-101 | ø32 mm-ø25 mm | WPA | 4.NP_SO-101 | 2728.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.04.0139 | 0139 | yes | no | yes | no | 3048 | 34.925 | 14.2875 | 17.4625 | WS_Teplá vnitřní 155
13060284 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0179 | 0179 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13060286 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0180 | 0180 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13060296 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0181 | 0181 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13060298 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0182 | 0182 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Studená vnitřní 151
13060304 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0183 | 0183 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
13060306 | 2.NP_SO-101 | ø25 mm-ø20 mm | WPA | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.04.0184 | 0184 | yes | no | no | yes | 3048 | 28.575 | 14.2875 | 11.1125 | WS_Teplá vnitřní 155
