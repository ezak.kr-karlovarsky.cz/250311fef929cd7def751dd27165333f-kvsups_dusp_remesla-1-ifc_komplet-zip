Properties of the parts of a building model (IFC4), part 24 of 26

# IfcPipeSegment: Typy trubek:PP-RCT (581)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Reynoldsovo číslo = Třecí faktor = Tření = Doplňkový průtok (m3/s) = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13429021 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3626.19 | 3626.19 | 3473.81 | 3473.81 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11473.8 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0905 | 0905 | yes | WS_"Jiný typ" studená vnitřní 1
13434646 | 3.NP_SO-101 | 473.307 | 0.000804127 | 0.047582 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3266 | 3250 | 3250 | 3234 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11237.6 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 473.307 | ø32 | 24.8 | TR10.02.0930 | 0930 | yes | WS_Teplá vnitřní 155 | 0
13434665 | 3.NP_SO-101 | 486.983 | 0.0004908 | 0.0382476 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3262.5 | 3250 | 3250 | 3237.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11240.3 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 486.983 | ø25 | 19.4 | TR10.02.0931 | 0931 | yes | WS_Cirkulace vnitřní 2 | 0
13434679 | 3.NP_SO-101 | 484.859 | 0.000804127 | 0.0487433 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3266 | 3250 | 3250 | 3234 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11237.6 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 484.859 | ø32 | 24.8 | TR10.02.0932 | 0932 | yes | WS_Studená vnitřní 151 | 0
13434695 | 3.NP_SO-101 | 488.323 | 0.0004908 | 0.0383528 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3262.5 | 3250 | 3250 | 3237.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11240.3 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 488.323 | ø25 | 19.4 | TR10.02.0933 | 0933 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13434760 | 3.NP_SO-101 | 928.017 | 0.0004908 | 0.0728862 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11440.3 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 928.017 | ø25 | 19.4 | TR10.02.0935 | 0935 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13434776 | 3.NP_SO-101 | 769.807 | 0.000804127 | 0.0773894 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11437.6 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 769.807 | ø32 | 24.8 | TR10.02.0936 | 0936 | yes | WS_Studená vnitřní 151 | 0
13434793 | 3.NP_SO-101 | 635.852 | 0.0004908 | 0.0499397 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11440.3 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 635.852 | ø25 | 19.4 | TR10.02.0937 | 0937 | yes | WS_Cirkulace vnitřní 2 | 0
13434813 | 3.NP_SO-101 | 474.471 | 0.000804127 | 0.047699 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3466 | 3450 | 3450 | 3434 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11437.6 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 474.471 | ø32 | 24.8 | TR10.02.0938 | 0938 | yes | WS_Teplá vnitřní 155 | 0
13434848 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3426.19 | 3273.81 | 3426.19 | 3273.81 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11273.8 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0939 | 0939 | yes | WS_Teplá vnitřní 155
13434879 | 3.NP_SO-101 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3429.36 | 3270.64 | 3429.36 | 3270.64 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11270.6 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.02.0940 | 0940 | yes | WS_Cirkulace vnitřní 2
13434910 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3426.19 | 3273.81 | 3426.19 | 3273.81 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11273.8 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0941 | 0941 | yes | WS_Studená vnitřní 151
13434941 | 3.NP_SO-101 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3429.36 | 3270.64 | 3429.36 | 3270.64 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11270.6 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.02.0942 | 0942 | yes | WS_"Jiný typ" studená vnitřní 1
13435005 | 3.NP_SO-101 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3429.36 | 3270.64 | 3429.36 | 3270.64 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11270.6 | PP–RCT S4 | 25 | 218 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.02.0944 | 0944 | yes | WS_"Jiný typ" studená vnitřní 1
13435042 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3426.19 | 3273.81 | 3426.19 | 3273.81 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11273.8 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0945 | 0945 | yes | WS_Studená vnitřní 151
13435077 | 3.NP_SO-101 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3429.36 | 3270.64 | 3429.36 | 3270.64 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11270.6 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.02.0946 | 0946 | yes | WS_Cirkulace vnitřní 2
13435112 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3426.19 | 3273.81 | 3426.19 | 3273.81 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11273.8 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0947 | 0947 | yes | WS_Teplá vnitřní 155
13439097 | -1.PP_SO-101 | 25.3999 | 0.0004908 | 0.00199491 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 25.3999 | ø25 | 19.4 | TR10.02.0958 | 0958 |  | WS_"Jiný typ" studená vnitřní 1 | 0
13439098 | -1.PP_SO-101 | 65.075 | 0.000314112 | 0.00408878 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2482.54 | 2417.46 | 2482.54 | 2417.46 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -732.537 | PP–RCT S4 | 20 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 65.075 | ø20 | 15.4 | TR10.02.0959 | 0959 |  | WS_"Jiný typ" studená vnitřní 1

# IfcPipeSegment: Typy trubek:PP_HT systém Plus (22)
Type - Material: 255-0-255
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR08; Název typu: PP_HT systém Plus; Označení typu: 04; Popis: PP; Popis sestavy: Polypropylen (PP); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR08 Uniformat (Uniformat)
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.00950189 m2; NetCrossSectionArea: 0.00950189 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø110 mm
Text - CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Výkaz/typ: –; Typ systému: SW_Odvětrání kanalizace; Drsnost: 0.01 mm; Klasifikace systému: Průduch; Materiál: PP_HT SYSTEM PLUS; Název systému: SW_Odvětrání kanalizace 1; Popis úseku: PP–HTEM; Průměr: 110 mm; Řez: 20; Typ přípoje: Obecné; Úsek potrubí: PP_HT SYSTEM PLUS - –
Kóty - Velikost: ø110; Vnější průměr: 110 mm; Vnitřní průměr: 104.6 mm
Jiné - Rodina: Typy trubek; Páteřní trasa: yes; Id typu: 9442183; Rodina a typ: Typy trubek: PP_HT systém Plus; Typ: PP_HT systém Plus
Name (Typy trubek:PP_HT systém Plus:...) | In | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) = Plocha (m2) | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Obrátit výšku (mm) | Kód prvku | Označení | Group
13132190 | -1.PP_SO-101 | 993.643 | 0.343378 | 0.000140449 | G | JD | -1.PP_SO-101 | -558.938 | -558.939 | -1552.58 | -1552.58 | -4702.58 | TR08.04.0483 | 0483 | SW_Splašky vnitřní gravitační 3; SW_Odvětrání kanalizace 1
13132292 | -1.PP_SO-101 | 3738.41 | 1.2919 | 0.000140449 | G | JD | -1.PP_SO-101 | -441.002 | -496.002 | -496.002 | -551.002 | -3698.3 | TR08.04.0484 | 0484 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13132419 | -1.PP_SO-101 | 4170.38 | 1.44118 | 0.000140449 | G | JD | -1.PP_SO-101 | -356.363 | -411.352 | -494.743 | -549.732 | -3697.03 | TR08.04.0485 | 0485 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 2
13132484 | 4.NP_SO-101 | 2359.78 | 0.815481 | 0 | G | JD | 4.NP_SO-101 | 6340 | 3980.22 | 6340 | 3980.22 | 15980.2 | TR08.04.0486 | 0486 | SW_Odvětrání kanalizace 1
13291531 | 4.NP_SO-101 | 3850.66 | 1.33069 | 0.0000956023 | G | JD | 4.NP_SO-101 | 3854.35 | 3854.35 | 3.68826 | 3.68826 | 12003.7 | TR08.04.0810 | 0810 | SW_Odvětrání kanalizace 1
13291630 | 4.NP_SO-101 | 500.642 | 0.173009 | 0.0000956023 | G | JD | 4.NP_SO-101 | 3972.28 | 3917.28 | 3917.28 | 3862.28 | 15865 | TR08.04.0811 | 0811 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13430260 | 4.NP_SO-101 | 2742.99 | 0.947908 | 0.0000956023 | G | JD | 4.NP_SO-101 | -12755.4 | -15498.4 | -12755.4 | -15498.4 | -3498.43 | TR08.04.0912 | 0912 | SW_Odvětrání kanalizace 1
13431830 | 4.NP_SO-101 | 3683.14 | 1.2728 | 0.0000956023 | G | JD | 4.NP_SO-101 | -8280.79 | -8280.79 | -11963.9 | -11963.9 | 36.0696 | TR08.04.0920 | 0920 | SW_Odvětrání kanalizace 1
13431856 | 4.NP_SO-101 | 136.635 | 0.0472177 | 0.0000956023 | G | JD | 4.NP_SO-101 | -8100.78 | -8236.29 | -8139.67 | -8275.18 | 3726.73 | TR08.04.0921 | 0921 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 100
13434023 | 4.NP_SO-101 | 256.691 | 0.088706 | 0.0000956023 | G | JD | 4.NP_SO-101 | -12490.5 | -12529.4 | -12710.9 | -12749.8 | -747.92 | TR08.04.0927 | 0927 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 100
13434035 | 4.NP_SO-101 | 130.417 | 0.0450688 | 0.0000956023 | G | JD | 4.NP_SO-101 | -11969.5 | -12100.7 | -12008.4 | -12139.5 | -137.634 | TR08.04.0928 | 0928 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 100
13434083 | 4.NP_SO-101 | 339.771 | 0.117416 | 0 | G | JD | 4.NP_SO-101 | -12145.2 | -12145.2 | -12484.9 | -12484.9 | -484.927 | TR08.04.0929 | 0929 | SW_Odvětrání kanalizace 1
13435566 | 4.NP_SO-101 | 3484.39 | 1.20412 | 0.0000956023 | G | JD | 4.NP_SO-101 | -4610.77 | -4610.77 | -8095.17 | -8095.17 | 3904.83 | TR08.04.0949 | 0949 | SW_Odvětrání kanalizace 1
13435642 | 4.NP_SO-101 | 217.14 | 0.0750384 | 0.0000956023 | G | JD | 4.NP_SO-101 | -4141.49 | -4141.49 | -4358.63 | -4358.63 | 7641.37 | TR08.04.0950 | 0950 | SW_Odvětrání kanalizace 1
13436006 | 4.NP_SO-101 | 3204.91 | 1.10754 | 0.0000956023 | G | JD | 4.NP_SO-101 | -810.712 | -810.712 | -4015.62 | -4015.62 | 7984.38 | TR08.04.0951 | 0951 | SW_Odvětrání kanalizace 1
13436118 | 4.NP_SO-101 | 134.841 | 0.0465976 | 0.0000956023 | G | JD | 4.NP_SO-101 | -122.187 | -122.187 | -257.027 | -257.027 | 11743 | TR08.04.0952 | 0952 | SW_Odvětrání kanalizace 1
13436433 | 4.NP_SO-101 | 74.125 | 0.0256158 | 0.0000956023 | G | JD | 4.NP_SO-101 | -4.24924 | -59.2492 | -59.2492 | -114.249 | 11888.5 | TR08.04.0953 | 0953 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13436495 | 4.NP_SO-101 | 4.125 | 0.0014255 | 0.0000956023 | G | JD | 4.NP_SO-101 | -4023.56 | -4078.56 | -4078.56 | -4133.56 | 7869.14 | TR08.04.0954 | 0954 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13436561 | 4.NP_SO-101 | 230.704 | 0.0797254 | 0.0000956023 | G | JD | 4.NP_SO-101 | -4364.25 | -4566.27 | -4403.14 | -4605.16 | 7396.75 | TR08.04.0955 | 0955 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 100
13439169 | 4.NP_SO-101 | 65.375 | 0.022592 | 0.0000956023 | F | JB | 4.NP_SO-101 | -264.965 | -319.965 | -319.965 | -374.965 | 11627.7 | TR08.04.0960 | 0960 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13439606 | 4.NP_SO-101 | 171.845 | 0.0593855 | 0.0000956023 | F | JB | 4.NP_SO-101 | -692.774 | -747.774 | -747.774 | -802.774 | 11199.9 | TR08.04.0961 | 0961 | SW_Odvětrání kanalizace 1 | Vazby - Sklon: 0
13439614 | 4.NP_SO-101 | 301.934 | 0.104341 | 0 | F | JB | 4.NP_SO-101 | -382.902 | -684.837 | -382.902 | -684.837 | 11315.2 | TR08.04.0962 | 0962 | SW_Odvětrání kanalizace 1

# IfcPipeSegment: Typy trubek:PP_Skolan SAFE dB (179)
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR08; Název typu: PP_Skolan SAFE dB; Označení typu: 01; Popis: PP; Popis sestavy: Polypropylen (PP); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR08 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.01 mm; Materiál: PP_SKOLAN dB; Popis úseku: PP–SKEM; Typ přípoje: Obecné; Úsek potrubí: PP_SKOLAN dB - –; Výkaz/typ: –
Jiné - Id typu: 9442253; Rodina: Typy trubek; Rodina a typ: Typy trubek: PP_Skolan SAFE dB; Typ: PP_Skolan SAFE dB
Name (Typy trubek:PP_Skolan SAFE dB:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
12912020 | 1.NP_SO-101 | 46.9158 | 0.00477764 | 0.0114964 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 2936.78 | 2936.78 | 2889.86 | 2889.86 | Sanitární | SW_Splašky vnitřní gravitační 10 | 2889.86 | 78 | 155 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0001 | 0001 | no
12912046 | 4.NP_SO-101 | 8014.93 | 0.0143117 | 3.39925 | ø135 mm |  | 0.0000803859 | G | JD | 4.NP_SO-101 | 6020 | 6020 | -1994.93 | -1994.93 | Průduch | SW_Odvětrání kanalizace 2 | 10005.1 | 135 | 27 | SW_Odvětrání kanalizace | ø135 | 124.4 | TR08.01.0002 | 0002 | yes
12912057 | 1.NP_SO-101 | 1940.95 | 0.00477764 | 0.475617 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 1518.04 | -422.909 | 1518.04 | -422.909 | Sanitární | SW_Splašky vnitřní gravitační 10 | -422.909 | 78 | 48 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0003 | 0003 | yes
12912070 | 1.NP_SO-101 | 1954.33 | 0.00477764 | 0.478897 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 1238.1 | 1238.1 | -716.226 | -716.226 | Sanitární | SW_Splašky vnitřní gravitační 10 | -716.226 | 78 | 33 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0004 | 0004 | yes
12912758 | 1.NP_SO-101 | 232.823 | 0.00477747 | 0.057052 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3606.6 | 3373.78 | 3606.6 | 3373.78 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3373.78 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0005 | 0005 | no | Identifikační data - Komentáře: S2
12912775 | 3.NP_SO-101 | 2411.04 | 0.00477764 | 0.590811 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 1778.12 | 1778.11 | -632.928 | -632.943 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7367.06 | 78 | 66 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0006 | 0006 | no | 263569 | Identifikační data - Komentáře: S2
12912805 | 3.NP_SO-101 | 1968.2 | 0.00477764 | 0.482297 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 1578.04 | 1578.04 | -390.167 | -390.167 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7609.83 | 78 | 102 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0007 | 0007 | yes | Identifikační data - Komentáře: S2
12912861 | 3.NP_SO-101 | 718.309 | 0.00950189 | 0.24823 | ø110 mm | 0 | 0.000100604 | G | JD | 3.NP_SO-101 | 229.2 | 229.2 | -489.109 | -489.109 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7510.89 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0008 | 0008 | yes
12912907 | 2.NP_SO-101 | 6207.11 | 0.00477764 | 1.52102 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 1878.04 | 1878.04 | -4329.07 | -4329.07 | Sanitární | SW_Splašky vnitřní gravitační 10 | -329.074 | 78 | 43 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0009 | 0009 | yes
12912922 | 2.NP_SO-101 | 5034.28 | 0.00477764 | 1.23362 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 530.001 | 530 | -4504.28 | -4504.28 | Sanitární | SW_Splašky vnitřní gravitační 10 | -504.28 | 78 | 47 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0010 | 0010 | yes | 7711316
12913160 | 3.NP_SO-101 | 11342.8 | 0.00477764 | 2.77949 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 2778.04 | 2778.04 | -8564.76 | -8564.76 | Sanitární | SW_Splašky vnitřní gravitační 10 | -564.763 | 78 | 42 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0011 | 0011 | yes | Identifikační data - Komentáře: S3
12913177 | 3.NP_SO-101 | 2867.3 | 0.00477764 | 0.702616 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 3260.67 | 393.371 | 3260.67 | 393.371 | Sanitární | SW_Splašky vnitřní gravitační 10 | 8393.37 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0012 | 0012 | yes | Identifikační data - Komentáře: S4
12913723 | 1.NP_SO-101 | 1620.56 | 0.00477764 | 0.397108 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 1686.11 | 1686.11 | 65.5511 | 65.5506 | Sanitární | SW_Splašky vnitřní gravitační 10 | 65.5507 | 78 | 83 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0013 | 0013 | yes
12914629 | -1.PP_SO-101 | 600 | 0.00950189 | 0.207345 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 742.429 | 742.429 | 142.429 | 142.429 | Sanitární | SW_Splašky vnitřní gravitační 81 | -3007.57 | 110 | 11 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0014 | 0014 | yes
12924362 | 4.NP_SO-101 | 3428.77 | 0.00950189 | 1.1849 | ø110 mm |  | 0.0000669344 | G | JD | 4.NP_SO-101 | 6060 | 6060 | 2631.23 | 2631.23 | Průduch | SW_Odvětrání kanalizace 10 | 14631.2 | 110 | 3 | SW_Odvětrání kanalizace | ø110 | 99.4 | TR08.01.0021 | 0021 | yes | Identifikační data - Komentáře: S4
12924364 | 4.NP_SO-101 | 2549.29 | 0.00950189 | 0.88097 | ø110 mm | 0 | 0.000100604 | G | JD | 4.NP_SO-101 | 1971.71 | -577.581 | 1971.71 | -577.581 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11422.4 | 110 | 227 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0022 | 0022 | yes
12924406 | 4.NP_SO-101 | 992.105 | 0.00264168 | 0.180774 | ø58 mm | 0 | 0.0002 | G | JD | 4.NP_SO-101 | 1119.21 | 1119.21 | 127.101 | 127.101 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12127.1 | 58 | 6 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0023 | 0023 | no | Identifikační data - Komentáře: S1
12924431 | 4.NP_SO-101 | 2806.8 | 0.00264168 | 0.511434 | ø58 mm | 0 | 0.0002 | G | JD | 4.NP_SO-101 | 3080 | 273.2 | 3080 | 273.2 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12273.2 | 58 | 77 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0024 | 0024 | no | Identifikační data - Komentáře: S1
13103037 | -1.PP_SO-101 | 1134.25 | 0.00950189 | 0.391968 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 84.3063 | 84.3063 | -1049.94 | -1049.94 | Sanitární | SW_Splašky vnitřní gravitační 81 | -4199.94 | 110 | 39 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0426 | 0426 | yes
13129170 | -1.PP_SO-101 | 1373.1 | 0.0143117 | 0.582352 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2440.03 | 2345.08 | 2372.54 | 2277.6 | Sanitární | SW_Splašky vnitřní gravitační 10 | -867.105 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0476 | 0476 | yes | 2
13129556 | -1.PP_SO-101 | 544.185 | 0.0143117 | 0.230797 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2411.32 | 2332.96 | 2343.83 | 2265.47 | Sanitární | SW_Splašky vnitřní gravitační 10 | -879.231 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0477 | 0477 | yes | 1.99903
13129694 | -1.PP_SO-101 | 105.516 | 0.0143117 | 0.044751 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2953.11 | 2905.38 | 2830.77 | 2783.04 | Sanitární | SW_Splašky vnitřní gravitační 10 | -363.209 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0478 | 0478 | yes | 100
13129810 | -1.PP_SO-101 | 2645.51 | 0.00477764 | 0.648267 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2589.76 | 2550.76 | 2497.86 | 2458.87 | Sanitární | SW_Splašky vnitřní gravitační 10 | -686.63 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0479 | 0479 | yes | 2
13130760 | 2.NP_SO-101 | 712.6 | 0.00477764 | 0.174619 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 1257.46 | 1257.46 | 544.859 | 544.859 | Sanitární | SW_Splašky vnitřní gravitační 10 | 4544.86 | 78 | 148 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0480 | 0480 | no
13131534 | 1.NP_SO-101 | 6828.6 | 0.00477764 | 1.67331 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3529.24 | 3353.71 | 3490.25 | 3314.71 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3319.21 | 78 | 172 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0481 | 0481 | no | 2 | Identifikační data - Komentáře: VEDENO POD STROPEM
13131667 | 1.NP_SO-101 | 158.63 | 0.00477764 | 0.0388713 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3643.73 | 3503.99 | 3616.16 | 3476.41 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3479.59 | 78 | 172 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0482 | 0482 | no | 100
13132585 | 3.NP_SO-101 | 10127.3 | 0.0143117 | 4.29512 | ø135 mm | 0 | 0.0000803859 | G | JD | 3.NP_SO-101 | 1935.98 | 1935.98 | -8191.27 | -8191.27 | Sanitární | SW_Splašky vnitřní gravitační 10 | -191.274 | 135 | 8 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0487 | 0487 | yes
13133739 | -1.PP_SO-101 | 1578.83 | 0.00477764 | 0.386882 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2425.84 | 2355.28 | 2386.85 | 2316.28 | Sanitární | SW_Splašky vnitřní gravitační 10 | -829.218 | 78 | 33 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0488 | 0488 | yes | 2
13133760 | -1.PP_SO-101 | 715.849 | 0.00477764 | 0.175415 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2393.49 | 2340.18 | 2354.5 | 2301.19 | Sanitární | SW_Splašky vnitřní gravitační 10 | -844.309 | 78 | 33 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0489 | 0489 | yes | 2
13133904 | -1.PP_SO-101 | 990.034 | 0.00477764 | 0.242602 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2378.4 | 2339.41 | 2319.61 | 2280.62 | Sanitární | SW_Splašky vnitřní gravitační 10 | -864.883 | 78 | 33 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0490 | 0490 | yes | 2
13133962 | -1.PP_SO-101 | 442.894 | 0.0143117 | 0.187838 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2395.26 | 2318.92 | 2327.78 | 2251.43 | Sanitární | SW_Splašky vnitřní gravitační 10 | -893.269 | 135 | 30 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0491 | 0491 | yes | 2
13134060 | -1.PP_SO-101 | 983.869 | 0.00477764 | 0.241091 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2439.85 | 2381.19 | 2400.86 | 2342.19 | Sanitární | SW_Splašky vnitřní gravitační 10 | -803.306 | 78 | 224 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0492 | 0492 | yes | 2
13134095 | -1.PP_SO-101 | 417.667 | 0.00477764 | 0.102347 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2419.4 | 2380.41 | 2372.06 | 2333.07 | Sanitární | SW_Splašky vnitřní gravitační 10 | -812.435 | 78 | 224 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0493 | 0493 | yes | 2
13134104 | -1.PP_SO-101 | 1590.67 | 0.0143117 | 0.674626 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2433.74 | 2366.25 | 2334.45 | 2266.96 | Sanitární | SW_Splašky vnitřní gravitační 10 | -877.741 | 135 | 34 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0494 | 0494 | yes | 2
13134614 | -1.PP_SO-101 | 926.184 | 0.00477764 | 0.226956 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2553.82 | 2496.31 | 2514.83 | 2457.31 | Sanitární | SW_Splašky vnitřní gravitační 10 | -688.188 | 78 | 39 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0495 | 0495 | yes | 2
13134782 | -1.PP_SO-101 | 978.417 | 0.00477764 | 0.239756 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2577.3 | 2518.74 | 2538.31 | 2479.75 | Sanitární | SW_Splašky vnitřní gravitační 10 | -665.748 | 78 | 42 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0496 | 0496 | yes | 2
13134969 | -1.PP_SO-101 | 259.887 | 0.00477764 | 0.0636837 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2815.31 | 2603.97 | 2787.74 | 2576.39 | Sanitární | SW_Splašky vnitřní gravitační 10 | -570.427 | 78 | 43 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0497 | 0497 | yes | 100
13135054 | -1.PP_SO-101 | 595.74 | 0.00477764 | 0.145983 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2569.65 | 2518.74 | 2530.66 | 2479.75 | Sanitární | SW_Splašky vnitřní gravitační 10 | -665.748 | 78 | 44 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0498 | 0498 | yes | 2
13135464 | -1.PP_SO-101 | 673.511 | 0.00477764 | 0.16504 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2637.78 | 2585.32 | 2598.79 | 2546.33 | Sanitární | SW_Splašky vnitřní gravitační 10 | -599.169 | 78 | 47 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0499 | 0499 | yes | 2
13135490 | -1.PP_SO-101 | 369.074 | 0.00477764 | 0.0904395 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2623.54 | 2577.17 | 2584.55 | 2538.17 | Sanitární | SW_Splašky vnitřní gravitační 10 | -607.326 | 78 | 47 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0500 | 0500 | yes | 2
13135503 | -1.PP_SO-101 | 583.749 | 0.00477764 | 0.143044 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2615.38 | 2564.72 | 2576.39 | 2525.72 | Sanitární | SW_Splašky vnitřní gravitační 10 | -619.776 | 78 | 47 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0501 | 0501 | yes | 2
13135643 | -1.PP_SO-101 | 102.571 | 0.00477764 | 0.0251345 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2721.48 | 2621.37 | 2693.9 | 2593.8 | Sanitární | SW_Splašky vnitřní gravitační 10 | -553.023 | 78 | 48 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0502 | 0502 | yes | 100
13135684 | -1.PP_SO-101 | 668.718 | 0.00477764 | 0.163865 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2587.05 | 2534.69 | 2548.06 | 2495.7 | Sanitární | SW_Splašky vnitřní gravitační 10 | -649.804 | 78 | 49 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0503 | 0503 | yes | 2
13135692 | -1.PP_SO-101 | 592.435 | 0.00477764 | 0.145173 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2602.93 | 2552.09 | 2563.94 | 2513.1 | Sanitární | SW_Splašky vnitřní gravitační 10 | -632.4 | 78 | 47 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0504 | 0504 | yes | 2
13135740 | -1.PP_SO-101 | 968.701 | 0.00477764 | 0.237375 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2641.28 | 2582.92 | 2602.29 | 2543.93 | Sanitární | SW_Splašky vnitřní gravitační 10 | -601.572 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0505 | 0505 | yes | 2
13135754 | -1.PP_SO-101 | 392.764 | 0.00477764 | 0.0962446 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2621.14 | 2574.29 | 2582.14 | 2535.3 | Sanitární | SW_Splašky vnitřní gravitační 10 | -610.203 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0506 | 0506 | yes | 2
13135765 | -1.PP_SO-101 | 733.885 | 0.00477764 | 0.179834 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2612.51 | 2558.84 | 2573.51 | 2519.85 | Sanitární | SW_Splašky vnitřní gravitační 10 | -625.655 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0507 | 0507 | yes | 2
13135781 | -1.PP_SO-101 | 326.081 | 0.00477764 | 0.0799043 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2597.05 | 2551.54 | 2558.06 | 2512.55 | Sanitární | SW_Splašky vnitřní gravitační 10 | -632.953 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0508 | 0508 | yes | 2
13135952 | -1.PP_SO-101 | 4000.82 | 0.0143117 | 1.69681 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2557.99 | 2490.5 | 2410.5 | 2343.01 | Sanitární | SW_Splašky vnitřní gravitační 10 | -801.687 | 135 | 9 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0509 | 0509 | yes | 2 | Identifikační data - Komentáře: VEDENO POD STROPEM
13200501 | 2.NP_SO-101 | 773.534 | 0.00264168 | 0.140947 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 299.149 | 299.116 | -474.418 | -474.451 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3525.55 | 58 | 117 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0620 | 0620 | no | 86866.9
13200514 | 2.NP_SO-101 | 728.836 | 0.00264168 | 0.132803 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 304.317 | 304.316 | -424.52 | -424.521 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3575.48 | 58 | 115 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0621 | 0621 | no | 2079356
13200527 | 2.NP_SO-101 | 700.873 | 0.00264168 | 0.127708 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 247.335 | 247.335 | -453.538 | -453.539 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3546.46 | 58 | 114 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0622 | 0622 | no
13200538 | 2.NP_SO-101 | 606.313 | 0.00264168 | 0.110478 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 181.791 | 181.789 | -424.524 | -424.526 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3575.47 | 58 | 108 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0623 | 0623 | no | 1620892
13200568 | 2.NP_SO-101 | 578.091 | 0.00264168 | 0.105335 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 168.356 | 168.354 | -409.737 | -409.739 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3590.26 | 58 | 107 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0624 | 0624 | no | 1349182
13200854 | 1.NP_SO-101 | 142.291 | 0.00264168 | 0.0259271 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3569.87 | 3549.36 | 3448.75 | 3428.24 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3431.07 | 58 | 115 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0625 | 0625 | no | 100
13201954 | 1.NP_SO-101 | 70.7915 | 0.00264168 | 0.0128991 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3519.97 | 3499.46 | 3449.41 | 3428.9 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3431.73 | 58 | 117 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0626 | 0626 | no | 100
13205204 | 3.NP_SO-101 | 2097.7 | 0.00477764 | 0.51403 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 1578.04 | -519.669 | 1578.04 | -519.669 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7480.33 | 78 | 58 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0634 | 0634 | no | Identifikační data - Komentáře: S2
13205282 | 2.NP_SO-101 | 184.041 | 0.00477764 | 0.0450981 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3474.72 | 3447.14 | 3317 | 3289.43 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7292.61 | 78 | 58 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0635 | 0635 | no | 100
13205378 | 2.NP_SO-101 | 3621.57 | 0.00477764 | 0.887444 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3359.14 | 3247.73 | 3320.14 | 3208.73 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7213.23 | 78 | 66 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0636 | 0636 | no | 2 | Identifikační data - Komentáře: VEDENO POD STROPEM
13209791 | 2.NP_SO-101 | 585.161 | 0.00264168 | 0.106624 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 187.194 | 187.193 | -397.967 | -397.968 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3602.03 | 58 | 96 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0640 | 0640 | no
13209804 | 2.NP_SO-101 | 739.996 | 0.00264168 | 0.134836 | ø58 mm | 0 | 0.0002 | G | JD | 2.NP_SO-101 | 180.002 | 180.002 | -559.993 | -559.993 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3440.01 | 58 | 110 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0641 | 0641 | no
13210458 | 1.NP_SO-101 | 412.346 | 0.00477764 | 0.101043 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3411.78 | 3364.54 | 3372.78 | 3325.55 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3330.05 | 78 | 89 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0642 | 0642 | no | 2
13211340 | 4.NP_SO-101 | 426.3 | 0.00477764 | 0.104462 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 274.975 | 229.947 | 235.979 | 190.95 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12195.4 | 78 | 209 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0643 | 0643 | no | 1.4152
13211847 | 4.NP_SO-101 | 1235.9 | 0.00477764 | 0.30285 | ø78 mm | 0 | 0.000144928 | G | JD | 4.NP_SO-101 | 98.8714 | 35.1662 | 59.8792 | -3.82604 | Sanitární | SW_Splašky vnitřní gravitační 10 | 12000.7 | 78 | 208 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0644 | 0644 | no | 2
13212569 | 3.NP_SO-101 | 7627.98 | 0.00477764 | 1.86919 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 2946.96 | 2946.96 | -4681.02 | -4681.02 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3318.98 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0645 | 0645 | yes
13214134 | 1.NP_SO-101 | 3884.26 | 0.00477764 | 0.951815 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3211.09 | -673.169 | 3211.09 | -673.169 | Sanitární | SW_Splašky vnitřní gravitační 10 | -673.169 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0646 | 0646 | yes | Identifikační data - Komentáře: S1
13214300 | 1.NP_SO-101 | 701.847 | 0.00477764 | 0.171984 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3311.05 | 3258.02 | 3272.05 | 3219.03 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3223.53 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0647 | 0647 | yes | 2
13214497 | -1.PP_SO-101 | 241.131 | 0.0201032 | 0.121206 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2471.89 | 2387.08 | 2391.9 | 2307.1 | Sanitární | SW_Splašky vnitřní gravitační 10 | -837.605 | 160 | 189 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0648 | 0648 | yes | 2
13215383 | -1.PP_SO-101 | 1088.87 | 0.00477764 | 0.266821 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2711.24 | 2672.24 | 2650.47 | 2611.48 | Sanitární | SW_Splašky vnitřní gravitační 10 | -534.023 | 78 | 83 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0649 | 0649 | yes | 2
13216085 | -1.PP_SO-101 | 347.307 | 0.0143117 | 0.147298 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2493.87 | 2419.44 | 2426.39 | 2351.96 | Sanitární | SW_Splašky vnitřní gravitační 10 | -792.746 | 135 | 92 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0650 | 0650 | yes | 2.00002
13216226 | -1.PP_SO-101 | 1545.51 | 0.0143117 | 0.655472 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2471.32 | 2403.83 | 2372.93 | 2305.44 | Sanitární | SW_Splašky vnitřní gravitační 10 | -839.262 | 135 | 78 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0651 | 0651 | yes | 2
13217084 | -1.PP_SO-101 | 1519.13 | 0.0143117 | 0.644287 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2710.4 | 2612.54 | 2642.92 | 2545.05 | Sanitární | SW_Splašky vnitřní gravitační 10 | -599.649 | 135 | 215 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0653 | 0653 | yes | 2
13217161 | -1.PP_SO-101 | 968.699 | 0.00950189 | 0.334758 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 2583.57 | 2509.21 | 2528.58 | 2454.22 | Sanitární | SW_Splašky vnitřní gravitační 10 | -690.482 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0654 | 0654 | yes | 2
13217554 | 3.NP_SO-101 | 934.472 | 0.00950189 | 0.32293 | ø110 mm | 0 | 0.000100604 | G | JD | 3.NP_SO-101 | 3381.84 | 3326.85 | 3308.17 | 3253.18 | Sanitární | SW_Splašky vnitřní gravitační 10 | 11258.5 | 110 | 227 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0655 | 0655 | yes | 2
13217729 | 2.NP_SO-101 | 7478.28 | 0.00950189 | 2.58431 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | 3377.75 | 3377.75 | -4100.52 | -4100.52 | Sanitární | SW_Splašky vnitřní gravitační 10 | -100.523 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0656 | 0656 | yes
13217802 | 2.NP_SO-101 | 300.967 | 0.00950189 | 0.104007 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | 3502.96 | 3447.97 | 3441.95 | 3386.96 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7392.26 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0657 | 0657 | yes | 2
13217815 | 2.NP_SO-101 | 3.88612 | 0.00950189 | 0.00134295 | ø110 mm | 0 | 0.000100604 | G | JD | 2.NP_SO-101 | 3495.69 | 3440.69 | 3440.69 | 3385.69 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7390.99 | 110 | 88 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0658 | 0658 | yes | 0
13227585 | -1.PP_SO-101 | 1558.31 | 0.00950189 | 0.538513 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 52.7774 | 52.7766 | -1505.53 | -1505.53 | Sanitární | SW_Splašky vnitřní gravitační 4 | -4655.53 | 110 | 16 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0675 | 0675 | yes
13227622 | -1.PP_SO-101 | 2527.63 | 0.00950189 | 0.873485 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 1022.73 | 1022.73 | -1504.89 | -1504.89 | Sanitární | SW_Splašky vnitřní gravitační 4 | -4654.89 | 110 | 18 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0676 | 0676 | yes | 6488101
13228018 | -1.PP_SO-101 | 820.288 | 0.00950189 | 0.283471 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | -1513.47 | -1584.86 | -1568.46 | -1639.85 | Sanitární | SW_Splašky vnitřní gravitační 4 | -4784.55 | 110 | 16 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0677 | 0677 | yes | 2
13239075 | 1.NP_SO-101 | 135.363 | 0.00264168 | 0.0246648 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3540.85 | 3424.63 | 3520.34 | 3404.12 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3406.95 | 58 | 114 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0702 | 0702 | no | 100
13239259 | 1.NP_SO-101 | 1465.97 | 0.00264168 | 0.267118 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3424.49 | 3366.18 | 3395.5 | 3337.19 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3341.19 | 58 | 113 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0703 | 0703 | no | 2
13239415 | 1.NP_SO-101 | 764.128 | 0.00264168 | 0.139234 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3442.81 | 3398.54 | 3413.82 | 3369.54 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3373.54 | 58 | 114 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0704 | 0704 | no | 2
13239523 | 1.NP_SO-101 | 1493.35 | 0.00477764 | 0.365937 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3400.74 | 3331.88 | 3361.75 | 3292.89 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3297.39 | 78 | 155 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0705 | 0705 | no | 2
13239626 | 1.NP_SO-101 | 207.611 | 0.00477764 | 0.0508739 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3402.84 | 3359.69 | 3363.85 | 3320.7 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3325.2 | 78 | 89 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0706 | 0706 | no | 2
13239644 | 1.NP_SO-101 | 4699.52 | 0.00477764 | 1.15159 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3397.24 | 3264.28 | 3358.25 | 3225.28 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3229.78 | 78 | 111 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0707 | 0707 | no | 2 | Identifikační data - Komentáře: VEDENO POD STROPEM
13239680 | 1.NP_SO-101 | 523.44 | 0.00477764 | 0.128266 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3411.63 | 3372.63 | 3362.17 | 3323.17 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3327.67 | 78 | 105 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0708 | 0708 | no | 2
13239734 | 1.NP_SO-101 | 432.431 | 0.00477764 | 0.105965 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3421.05 | 3382.06 | 3373.41 | 3334.42 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3338.92 | 78 | 105 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0709 | 0709 | no | 2
13239821 | 1.NP_SO-101 | 137.717 | 0.00264168 | 0.0250938 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3584.65 | 3466.76 | 3564.15 | 3446.26 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3449.09 | 58 | 107 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0710 | 0710 | no | 100
13239920 | 1.NP_SO-101 | 84.8433 | 0.00264168 | 0.0154595 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3569.86 | 3489.36 | 3549.36 | 3468.86 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3471.69 | 58 | 108 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0711 | 0711 | no | 100
13240023 | 1.NP_SO-101 | 840.151 | 0.00264168 | 0.153086 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3484.95 | 3439.15 | 3455.95 | 3410.16 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3414.16 | 58 | 107 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0712 | 0712 | no | 2
13240255 | 1.NP_SO-101 | 121.08 | 0.00264168 | 0.0220624 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3596.42 | 3490.3 | 3575.91 | 3469.79 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3472.62 | 58 | 96 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0713 | 0713 | no | 100
13240308 | 1.NP_SO-101 | 1033.71 | 0.00477764 | 0.253305 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3442.5 | 3382.84 | 3403.51 | 3343.84 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3348.34 | 78 | 105 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0714 | 0714 | no | 2
13240322 | 1.NP_SO-101 | 1408.83 | 0.00264168 | 0.256706 | ø58 mm | 0 | 0.0002 | G | JD | 1.NP_SO-101 | 3465.11 | 3407.94 | 3436.11 | 3378.95 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3382.95 | 58 | 106 | SW_Splašky vnitřní gravitační | ø58 | 50 | TR08.01.0715 | 0715 | no | 2
13240464 | 1.NP_SO-101 | 391.975 | 0.00477764 | 0.0960512 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3302.49 | 3255.66 | 3263.5 | 3216.67 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3221.17 | 78 | 111 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0716 | 0716 | no | 2
13240650 | 1.NP_SO-101 | 65.0486 | 0.00477764 | 0.0159398 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3267.34 | 3193.17 | 3240.74 | 3166.57 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3169.64 | 78 | 111 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0717 | 0717 | yes | 107.237
13240714 | 1.NP_SO-101 | 3673.21 | 0.00477764 | 0.900098 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3014.78 | -658.431 | 3014.78 | -658.432 | Sanitární | SW_Splašky vnitřní gravitační 10 | -658.432 | 78 | 144 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0718 | 0718 | yes | 2237372 | Identifikační data - Komentáře: S2
13240726 | 2.NP_SO-101 | 3370.13 | 0.00477764 | 0.825831 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 2590.98 | -779.149 | 2590.98 | -779.149 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3220.85 | 78 | 171 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0719 | 0719 | yes | Identifikační data - Komentáře: S2
13267380 | -1.PP_SO-101 | 830.856 | 0.00477764 | 0.203596 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2425.45 | 2369.85 | 2386.46 | 2330.86 | Sanitární | SW_Splašky vnitřní gravitační 10 | -814.645 | 78 | 144 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0737 | 0737 | yes | 2
13267513 | -1.PP_SO-101 | 1510.05 | 0.00477764 | 0.370028 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2456.33 | 2417.34 | 2387.14 | 2348.15 | Sanitární | SW_Splašky vnitřní gravitační 10 | -797.348 | 78 | 144 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0738 | 0738 | yes | 2
13267748 | -1.PP_SO-101 | 373.605 | 0.00477764 | 0.0915497 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2464.58 | 2425.59 | 2418.12 | 2379.12 | Sanitární | SW_Splašky vnitřní gravitační 10 | -766.376 | 78 | 144 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0739 | 0739 | yes | 2
13267895 | -1.PP_SO-101 | 914.002 | 0.00477764 | 0.223971 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2483.63 | 2444.64 | 2426.36 | 2387.37 | Sanitární | SW_Splašky vnitřní gravitační 10 | -758.128 | 78 | 144 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0740 | 0740 | yes | 2
13268459 | -1.PP_SO-101 | 1201.12 | 0.00477764 | 0.294328 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2687.88 | 2624.87 | 2648.89 | 2585.88 | Sanitární | SW_Splašky vnitřní gravitační 10 | -559.62 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0741 | 0741 | yes | 2
13268601 | -1.PP_SO-101 | 1129.21 | 0.00477764 | 0.276707 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2711.24 | 2649.67 | 2672.25 | 2610.68 | Sanitární | SW_Splašky vnitřní gravitační 10 | -534.824 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0742 | 0742 | yes | 2
13271593 | -1.PP_SO-101 | 12704.4 | 0.00477764 | 3.11315 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2663.09 | 2369.85 | 2624.1 | 2330.86 | Sanitární | SW_Splašky vnitřní gravitační 10 | -814.644 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0743 | 0743 | yes | 2.00164 | Identifikační data - Komentáře: VEDENO POD STROPEM
13273383 | 2.NP_SO-101 | 133.552 | 0.00477764 | 0.0327261 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 638.172 | 610.595 | 516.16 | 488.582 | Sanitární | SW_Splašky vnitřní gravitační 10 | 4491.76 | 78 | 151 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0744 | 0744 | no | 100
13273395 | 2.NP_SO-101 | 699.539 | 0.00477764 | 0.171418 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 348.886 | 348.886 | -350.653 | -350.653 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3649.35 | 78 | 172 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0745 | 0745 | no
13273401 | 2.NP_SO-101 | 136.137 | 0.00477764 | 0.0333596 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 673.076 | 634.093 | 630.011 | 591.029 | Sanitární | SW_Splašky vnitřní gravitační 10 | 4595.53 | 78 | 151 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0746 | 0746 | no | 3
13273419 | 2.NP_SO-101 | 620.667 | 0.00477764 | 0.152091 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 692.853 | 653.87 | 635.259 | 596.276 | Sanitární | SW_Splašky vnitřní gravitační 10 | 4600.77 | 78 | 151 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0747 | 0747 | no | 3
13273528 | 1.NP_SO-101 | 455.477 | 0.00477764 | 0.111612 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3391.92 | 3343.82 | 3352.93 | 3304.83 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3309.33 | 78 | 172 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0748 | 0748 | no | 2
13273728 | 1.NP_SO-101 | 550.855 | 0.00477764 | 0.134984 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3278.25 | 2861.16 | 3250.68 | 2833.59 | Sanitární | SW_Splašky vnitřní gravitační 10 | 2836.77 | 78 | 166 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0749 | 0749 | no | 100
13274004 | 1.NP_SO-101 | 2632.24 | 0.00477764 | 0.645014 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 2693.89 | 2693.89 | 61.652 | 61.652 | Sanitární | SW_Splašky vnitřní gravitační 10 | 61.652 | 78 | 156 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0750 | 0750 | yes
13274382 | 1.NP_SO-101 | 576.178 | 0.00477764 | 0.141189 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3370.1 | 3319.59 | 3331.11 | 3280.59 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3285.09 | 78 | 155 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0751 | 0751 | no | 2
13274391 | 1.NP_SO-101 | 693.433 | 0.00477764 | 0.169922 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3357.8 | 3304.94 | 3318.81 | 3265.95 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3270.45 | 78 | 155 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0752 | 0752 | no | 2
13274453 | 1.NP_SO-101 | 454.297 | 0.00477764 | 0.111323 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3318.78 | 3291.2 | 2969.97 | 2942.39 | Sanitární | SW_Splašky vnitřní gravitační 10 | 2945.57 | 78 | 155 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0753 | 0753 | no | 100
13275421 | 2.NP_SO-101 | 6471.53 | 0.00477764 | 1.58581 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3282.69 | 3114.29 | 3243.69 | 3075.3 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7079.8 | 78 | 61 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0754 | 0754 | no | 2
13275500 | 2.NP_SO-101 | 290.707 | 0.00477764 | 0.071236 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 2857.31 | 2829.73 | 2624.17 | 2596.59 | Sanitární | SW_Splašky vnitřní gravitační 10 | 6599.77 | 78 | 171 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0755 | 0755 | yes | 100
13275550 | 2.NP_SO-101 | 343.735 | 0.00477764 | 0.0842303 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3433.62 | 3433.62 | 3089.89 | 3089.89 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7089.89 | 78 | 102 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0756 | 0756 | yes
13275615 | 2.NP_SO-101 | 155.327 | 0.00477764 | 0.0380621 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3604.22 | 3466.81 | 3576.64 | 3439.23 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7442.41 | 78 | 102 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0757 | 0757 | yes | 100
13275675 | 2.NP_SO-101 | 55.6717 | 0.00477764 | 0.013642 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 3128.13 | 3061.19 | 3100.55 | 3033.61 | Sanitární | SW_Splašky vnitřní gravitační 10 | 7036.79 | 78 | 61 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0758 | 0758 | no | 100
13275724 | 2.NP_SO-101 | 30.991 | 0.00477764 | 0.00759417 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | 2893.91 | 2893.91 | 2862.92 | 2862.92 | Sanitární | SW_Splašky vnitřní gravitační 10 | 6862.92 | 78 | 171 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0759 | 0759 | yes
13275922 | 1.NP_SO-101 | 275.458 | 0.00477764 | 0.0674994 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3365.84 | 3326.85 | 3321.34 | 3282.35 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3286.85 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0760 | 0760 | no | 2
13275962 | 1.NP_SO-101 | 2655.98 | 0.00477764 | 0.650833 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3356.41 | 3264.31 | 3317.42 | 3225.32 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3229.82 | 78 | 166 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0761 | 0761 | no | 2
13275978 | 1.NP_SO-101 | 1070.37 | 0.00477764 | 0.262287 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3381.74 | 3321.34 | 3342.74 | 3282.35 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3286.85 | 78 | 172 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0762 | 0762 | no | 2
13276095 | 3.NP_SO-101 | 3400.07 | 0.00477747 | 0.833167 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | -634.449 | -4034.52 | -634.449 | -4034.52 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3965.48 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0763 | 0763 | no | Identifikační data - Komentáře: S2
13276181 | 2.NP_SO-101 | 413.664 | 0.00477764 | 0.101366 | ø78 mm | 0 | 0.000144928 | G | JD | 2.NP_SO-101 | -40.1281 | -360.21 | -67.7053 | -387.787 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3615.39 | 78 | 174 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0764 | 0764 | no | 100
13277787 | -1.PP_SO-101 | 426.865 | 0.0314112 | 0.268207 | ø200 mm | 0 | 0.0000533049 | G | JD | -1.PP_SO-101 | 2330.51 | 2221.99 | 2230.53 | 2122.01 | Sanitární | SW_Splašky vnitřní gravitační 10 | -1021.79 | 200 | 127 | SW_Splašky vnitřní gravitační | ø200 | 187.6 | TR08.01.0765 | 0765 | yes | 2
13277802 | -1.PP_SO-101 | 721.566 | 0.0314112 | 0.453373 | ø200 mm | 0 | 0.0000533049 | G | JD | -1.PP_SO-101 | 2320.16 | 2205.75 | 2220.18 | 2105.77 | Sanitární | SW_Splašky vnitřní gravitační 10 | -1038.03 | 200 | 127 | SW_Splašky vnitřní gravitační | ø200 | 187.6 | TR08.01.0766 | 0766 | yes | 2
13277822 | -1.PP_SO-101 | 1921.66 | 0.0314112 | 1.20741 | ø200 mm | 0 | 0.0000533049 | G | JD | -1.PP_SO-101 | 2303.91 | 2165.51 | 2203.93 | 2065.53 | Sanitární | SW_Splašky vnitřní gravitační 10 | -1078.27 | 200 | 127 | SW_Splašky vnitřní gravitační | ø200 | 187.6 | TR08.01.0767 | 0767 | yes | 2
13278243 | -1.PP_SO-101 | 2630.84 | 0.04908 | 2.06626 | ø250 mm | 0 | 0.00004 | G | JD | -1.PP_SO-101 | 1991.7 | 1991.7 | -639.145 | -639.146 | Sanitární | SW_Splašky vnitřní gravitační 10 | -3789.15 | 250 | 180 | SW_Splašky vnitřní gravitační | ø250 | 250 | TR08.01.0770 | 0770 | yes
13278497 | -1.PP_SO-101 | 467.814 | 0.0143117 | 0.198407 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2318.36 | 2250.88 | 2241.52 | 2174.04 | Sanitární | SW_Splašky vnitřní gravitační 10 | -970.665 | 135 | 177 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0772 | 0772 | yes | 2
13278511 | -1.PP_SO-101 | 3006.66 | 0.0143117 | 1.27517 | ø135 mm | 0 | 0.0000803859 | G | JD | -1.PP_SO-101 | 2379.73 | 2312.25 | 2252.13 | 2184.64 | Sanitární | SW_Splašky vnitřní gravitační 10 | -960.062 | 135 | 177 | SW_Splašky vnitřní gravitační | ø135 | 124.4 | TR08.01.0773 | 0773 | yes | 2 | Identifikační data - Komentáře: VEDENO POD STROPEM
13278763 | -1.PP_SO-101 | 219.914 | 0.0201032 | 0.110541 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2465.61 | 2381.23 | 2385.62 | 2301.24 | Sanitární | SW_Splašky vnitřní gravitační 10 | -843.459 | 160 | 189 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0774 | 0774 | yes | 2
13278780 | -1.PP_SO-101 | 1122.64 | 0.0201032 | 0.564303 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2459.75 | 2357.32 | 2379.77 | 2277.34 | Sanitární | SW_Splašky vnitřní gravitační 10 | -867.364 | 160 | 189 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0775 | 0775 | yes | 2
13278858 | -1.PP_SO-101 | 537.042 | 0.0201032 | 0.269947 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2332.24 | 2241.52 | 2252.26 | 2161.54 | Sanitární | SW_Splašky vnitřní gravitační 10 | -983.163 | 160 | 194 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0776 | 0776 | yes | 1.99999
13278971 | -1.PP_SO-101 | 4318.6 | 0.00950189 | 1.4924 | ø110 mm | 0 | 0.000100604 | G | JD | -1.PP_SO-101 | 2420.79 | 2279.44 | 2365.8 | 2224.46 | Sanitární | SW_Splašky vnitřní gravitační 10 | -920.246 | 110 | 187 | SW_Splašky vnitřní gravitační | ø110 | 99.4 | TR08.01.0777 | 0777 | yes | 1.99999 | Identifikační data - Komentáře: VEDENO POD STROPEM
13279253 | -1.PP_SO-101 | 1671.09 | 0.00477764 | 0.409491 | ø78 mm | 0 | 0.000144928 | G | JD | -1.PP_SO-101 | 2468.9 | 2396.49 | 2429.9 | 2357.5 | Sanitární | SW_Splašky vnitřní gravitační 10 | -788.005 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0780 | 0780 | yes | 2
13279311 | -1.PP_SO-101 | 341.444 | 0.0201032 | 0.171628 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2428.88 | 2350.12 | 2290.41 | 2211.64 | Sanitární | SW_Splašky vnitřní gravitační 10 | -933.142 | 160 | 189 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0781 | 0781 | yes | 17.7611
13279330 | -1.PP_SO-101 | 930.544 | 0.0201032 | 0.467742 | ø160 mm | 0 | 0.0000669344 | G | JD | -1.PP_SO-101 | 2358.61 | 2260.02 | 2278.63 | 2180.04 | Sanitární | SW_Splašky vnitřní gravitační 10 | -964.664 | 160 | 188 | SW_Splašky vnitřní gravitační | ø160 | 149.4 | TR08.01.0782 | 0782 | yes | 1.99999
13280393 | 3.NP_SO-101 | 8529.88 | 0.00477764 | 2.0902 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 29.1009 | 29.1007 | -8500.78 | -8500.78 | Sanitární | SW_Splašky vnitřní gravitační 10 | -500.78 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0783 | 0783 | yes | Identifikační data - Komentáře: S4
13280889 | 3.NP_SO-101 | 219.617 | 0.00477764 | 0.0538158 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 245.16 | 62.2906 | 217.583 | 34.7134 | Sanitární | SW_Splašky vnitřní gravitační 10 | 8037.9 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0784 | 0784 | yes | 100
13280966 | 3.NP_SO-101 | 155.829 | 0.00477764 | 0.038185 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 387.668 | 249.903 | 360.091 | 222.326 | Sanitární | SW_Splašky vnitřní gravitační 10 | 8225.51 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0785 | 0785 | yes | 100
13281052 | 3.NP_SO-101 | 143.624 | 0.00477764 | 0.0351941 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 275.154 | 231.304 | 236.177 | 192.326 | Sanitární | SW_Splašky vnitřní gravitační 10 | 8196.82 | 78 | 199 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0786 | 0786 | yes | 3.39497
13281200 | 1.NP_SO-101 | 4086.27 | 0.00477764 | 1.00132 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3384.06 | -702.211 | 3384.06 | -702.212 | Sanitární | SW_Splašky vnitřní gravitační 10 | -702.212 | 78 | 224 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0787 | 0787 | yes | Identifikační data - Komentáře: S3
13281477 | 1.NP_SO-101 | 61.5538 | 0.00477764 | 0.0150834 | ø78 mm | 0 | 0.000144928 | G | JD | 1.NP_SO-101 | 3488.35 | 3417.25 | 3460.77 | 3389.67 | Sanitární | SW_Splašky vnitřní gravitační 10 | 3392.85 | 78 | 224 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0788 | 0788 | yes | 100
13288524 | 3.NP_SO-101 | 114.59 | 0.00477764 | 0.0280797 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 3035.18 | 2996.18 | 2993.89 | 2954.9 | Sanitární | SW_Splašky vnitřní gravitační 10 | 10959.4 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0794 | 0794 | yes | 2
13288537 | 3.NP_SO-101 | 241.724 | 0.00477764 | 0.059233 | ø78 mm | 0 | 0.000144928 | G | JD | 3.NP_SO-101 | 3040.79 | 3001.79 | 2996.96 | 2957.97 | Sanitární | SW_Splašky vnitřní gravitační 10 | 10962.5 | 78 | 212 | SW_Splašky vnitřní gravitační | ø78 | 69 | TR08.01.0795 | 0795 | yes | 2
