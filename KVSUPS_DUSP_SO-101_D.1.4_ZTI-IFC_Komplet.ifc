Properties of the parts of a building model (IFC4), part 16 of 26

# IfcPipeFitting: M_Koleno, obecné:Standardní (577)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | CCI Funkční systém | CCI Komponenta | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13289248 | 4.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 4.NP_SO-101 | 86.5728 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0753 | 0753 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13289912 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2611.93 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.0755 | 0755 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10
13289914 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2461.08 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.0756 | 0756 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10
13291376 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1691.49 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497207 | 26.0673 | 44.9965 | ø110-ø110 | 18.7498 | 113.175 | TT01.02.0757 | 0757 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13291379 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1517.82 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497215 | 26.0677 | 44.9971 | ø110-ø110 | 18.7501 | 113.175 | TT01.02.0758 | 0758 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13291428 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 4.NP_SO-101 | 2568.29 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0760 | 0760 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13291432 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 4.NP_SO-101 | 2568.29 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0761 | 0761 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13291651 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 4.NP_SO-101 | 3917.28 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0762 | 0762 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13291655 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | 4.NP_SO-101 | 3917.28 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0763 | 0763 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13373903 | 2.NP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0764 | 0764 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13373955 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3635.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0765 | 0765 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13374554 | 2.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 2.NP_SO-101 | 3220 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0767 | 0767 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13374570 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0768 | 0768 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13374578 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0769 | 0769 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13374600 | 2.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 2.NP_SO-101 | 3220 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0770 | 0770 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13374624 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3216 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0772 | 0772 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13374628 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3216 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0773 | 0773 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13374681 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3050 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0774 | 0774 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13374685 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3050 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0775 | 0775 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13374792 | 2.NP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | 2.NP_SO-101 | 2990 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0776 | 0776 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13374796 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 2.NP_SO-101 | 2990 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0777 | 0777 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13375525 | 2.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 2.NP_SO-101 | 3050 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0779 | 0779 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13377091 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 2.NP_SO-101 | 3325 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0780 | 0780 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13377093 | 2.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 2.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0781 | 0781 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13377107 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 2.NP_SO-101 | 3348.78 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0783 | 0783 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13377109 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 2.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0784 | 0784 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13377123 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0786 | 0786 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13377125 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0787 | 0787 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13377135 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0789 | 0789 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13377137 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 2.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0790 | 0790 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13377146 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0792 | 0792 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13377148 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 2.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0793 | 0793 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13378877 | 2.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 2.NP_SO-101 | 3195.54 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.02.0795 | 0795 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13378881 | 2.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 2.NP_SO-101 | 3050 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.02.0797 | 0797 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13380898 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0798 | 0798 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13380900 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0799 | 0799 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13380974 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0800 | 0800 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13381017 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0801 | 0801 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13381051 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0802 | 0802 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13381089 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0803 | 0803 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13381091 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 1.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0804 | 0804 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13381301 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2560 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0805 | 0805 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13381307 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | -1.PP_SO-101 | 2612.55 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0806 | 0806 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13381313 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2673.75 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0807 | 0807 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13381552 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | -1.PP_SO-101 | 2731.66 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000457331 | 25.4376 | 90.0002 | ø35-ø35 | 15.2701 | 38.175 | TT01.02.0808 | 0808 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13381668 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | -1.PP_SO-101 | 2731.66 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0809 | 0809 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13381692 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2673.75 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0810 | 0810 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13381732 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | -1.PP_SO-101 | 2612.62 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0811 | 0811 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13381775 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2560 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0812 | 0812 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13381813 | -1.PP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0813 | 0813 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13381900 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | -1.PP_SO-101 | 2731.66 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0814 | 0814 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13381902 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | -1.PP_SO-101 | 2450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0815 | 0815 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13381906 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000457329 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0816 | 0816 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13381912 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2673.75 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0817 | 0817 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13381914 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0818 | 0818 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13381921 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | -1.PP_SO-101 | 2612.62 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0819 | 0819 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13381923 | -1.PP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | -1.PP_SO-101 | 2400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0820 | 0820 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13381930 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2560 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0821 | 0821 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13381932 | -1.PP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | -1.PP_SO-101 | 2450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0822 | 0822 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13381936 | -1.PP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0823 | 0823 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13382881 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | -40.1938 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.02.0824 | 0824 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13382896 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | -90.1938 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.02.0825 | 0825 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13382900 | -1.PP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0826 | 0826 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13382923 | 1.NP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | 1.NP_SO-101 | -90.6688 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.02.0827 | 0827 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13382927 | 1.NP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | 1.NP_SO-101 | -40.6688 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.02.0828 | 0828 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13383011 | 1.NP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | 1.NP_SO-101 | -94.7872 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.02.0829 | 0829 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13383015 | 1.NP_SO-101 | ø50 mm-ø50 mm | F | QMA | JB | 1.NP_SO-101 | -44.7872 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.02.0830 | 0830 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13383021 | 1.NP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | 1.NP_SO-101 | -94.5059 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000228662 | 10.5366 | 45 | ø35-ø35 | 6.32504 | 38.175 | TT01.02.0831 | 0831 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13383025 | 1.NP_SO-101 | ø35 mm-ø35 mm | F | QMA | JB | 1.NP_SO-101 | -44.5059 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000228662 | 10.5366 | 45 | ø35-ø35 | 6.32504 | 38.175 | TT01.02.0832 | 0832 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13383029 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | -102.634 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.02.0833 | 0833 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13383033 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | -52.6335 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.02.0834 | 0834 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13383216 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 1.NP_SO-101 | 3425 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0836 | 0836 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13383371 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0838 | 0838 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13383402 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3268.1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0839 | 0839 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13383509 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 1.NP_SO-101 | 3275 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0841 | 0841 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13383511 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 1.NP_SO-101 | 3193.1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0842 | 0842 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13383627 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3118.1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0843 | 0843 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13384284 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3200 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0844 | 0844 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13384436 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | 3043.1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0847 | 0847 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13384893 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 1.NP_SO-101 | 3343.1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0849 | 0849 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13384897 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 1.NP_SO-101 | 3343.1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0850 | 0850 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13384985 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3268.1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0853 | 0853 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13384987 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3268.1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0854 | 0854 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13385049 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 1.NP_SO-101 | 3193.1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0855 | 0855 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13385051 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 1.NP_SO-101 | 3193.1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0856 | 0856 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13385080 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3118.1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0857 | 0857 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13385082 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 1.NP_SO-101 | 3118.1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0858 | 0858 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13385116 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | 3043.1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0859 | 0859 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13385118 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 1.NP_SO-101 | 3043.1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0860 | 0860 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13385285 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | QMA | JB | 1.NP_SO-101 | 3500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0861 | 0861 |  | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13385391 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | QMA | JB | 1.NP_SO-101 | 3500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0863 | 0863 |  | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13428366 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0865 | 0865 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13428374 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0866 | 0866 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13428376 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 3.NP_SO-101 | 3666.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0867 | 0867 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13428403 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0868 | 0868 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428411 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0869 | 0869 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428413 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3666.66 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0870 | 0870 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428436 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0871 | 0871 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13428444 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0872 | 0872 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13428446 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | QMA | JB | 3.NP_SO-101 | 3666.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0873 | 0873 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13428469 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0874 | 0874 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13428477 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0875 | 0875 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13428479 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3666.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0876 | 0876 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13428506 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0877 | 0877 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428514 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3635.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0878 | 0878 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428516 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3635.98 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0879 | 0879 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428879 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0880 | 0880 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428887 | 4.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 4.NP_SO-101 | -350 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0881 | 0881 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428891 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3650 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0882 | 0882 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13428914 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0883 | 0883 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13428922 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | -350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0884 | 0884 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13428926 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3650 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0885 | 0885 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13428953 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0886 | 0886 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428961 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | -350 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0887 | 0887 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428965 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3650 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0888 | 0888 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428988 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0889 | 0889 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13428996 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | -350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0890 | 0890 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13429000 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3650 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0891 | 0891 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13429023 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0892 | 0892 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429031 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | -350 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0893 | 0893 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429035 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3650 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0894 | 0894 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429450 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | 42.2099 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0895 | 0895 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429512 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | -97.423 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0896 | 0896 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429516 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | -391.335 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0897 | 0897 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429590 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | -472.151 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000250413 | 26.5921 | 59.0667 | ø78-ø78 | 18.3956 | 81.175 | TT01.02.0898 | 0898 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429600 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | -477.363 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0899 | 0899 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429701 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2649.28 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190761 | 19.4403 | 44.9962 | ø78-ø78 | 13.4483 | 81.175 | TT01.02.0900 | 0900 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429982 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | 46.1086 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00019078 | 19.4425 | 45.0007 | ø78-ø78 | 13.4497 | 81.175 | TT01.02.0901 | 0901 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13430051 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 1.NP_SO-101 | -48.8903 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.00019078 | 19.4425 | 45.0007 | ø78-ø78 | 13.4497 | 81.175 | TT01.02.0902 | 0902 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13430054 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2673.16 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376698 | 46.0076 | 88.8535 | ø78-ø78 | 31.8267 | 81.175 | TT01.02.0903 | 0903 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13430357 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -410.119 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0904 | 0904 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13430544 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 2.NP_SO-101 | -4618.55 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0905 | 0905 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13430554 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 2.NP_SO-101 | -4620.9 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0906 | 0906 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13430704 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 2.NP_SO-101 | -4560.18 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497245 | 26.0695 | 44.9999 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0909 | 0909 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13430838 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 2.NP_SO-101 | -4162.21 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0910 | 0910 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13430843 | 2.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 2.NP_SO-101 | -4166.71 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000981846 | 61.6915 | 88.8544 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0911 | 0911 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10
13431605 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | QMA | JD | -1.PP_SO-101 | 2759.31 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.0912 | 0912 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431635 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | QMA | JD | -1.PP_SO-101 | 2373.15 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.0913 | 0913 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431637 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2344.46 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000888209 | 31.2399 | 44.9904 | ø135-ø135 | 22.8882 | 138.175 | TT01.02.0914 | 0914 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431862 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -8121.24 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0915 | 0915 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13432880 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 3.NP_SO-101 | -4494.14 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000227833 | 23.7822 | 53.7407 | ø78-ø78 | 16.4519 | 81.175 | TT01.02.0916 | 0916 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13432884 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3477.59 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000227828 | 23.7816 | 53.7394 | ø78-ø78 | 16.4514 | 81.175 | TT01.02.0917 | 0917 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13433048 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 3.NP_SO-101 | -615.006 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4422 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0919 | 0919 |  | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13433052 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 3.NP_SO-101 | -415.007 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4422 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0920 | 0920 |  | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434031 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -12729.4 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0921 | 0921 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434085 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -12511 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0922 | 0922 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434105 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -12119.1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0923 | 0923 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434434 | 3.NP_SO-101 | ø78 mm-ø78 mm | G | QMA | JD | 3.NP_SO-101 | -4440.43 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0924 | 0924 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434850 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0925 | 0925 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13434881 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0926 | 0926 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434912 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0927 | 0927 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13434943 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0928 | 0928 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13434974 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0929 | 0929 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13434978 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0930 | 0930 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13435007 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0931 | 0931 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13435015 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0932 | 0932 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13435019 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0933 | 0933 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13435044 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0934 | 0934 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13435052 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0935 | 0935 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13435056 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0936 | 0936 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13435079 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0937 | 0937 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13435087 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0938 | 0938 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13435091 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0939 | 0939 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13435114 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0940 | 0940 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13435122 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0941 | 0941 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13435126 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0942 | 0942 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13435167 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3250 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0943 | 0943 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13435173 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0944 | 0944 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13435175 | 3.NP_SO-101 | ø28 mm-ø28 mm | F | QMA | JB | 3.NP_SO-101 | 3450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0945 | 0945 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13436581 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -4384.7 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0946 | 0946 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13436585 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -4584.7 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0947 | 0947 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13436621 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -4078.56 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0948 | 0948 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13436625 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -4078.56 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0949 | 0949 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13436649 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -59.2492 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0950 | 0950 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13436653 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -59.2492 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0951 | 0951 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13438063 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -11990 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0952 | 0952 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13438067 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -8254.72 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0953 | 0953 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13438430 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -639.272 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0954 | 0954 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13438452 | 3.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 3.NP_SO-101 | 3351.4 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000463999 | 24.1539 | 41.9912 | ø110-ø110 | 17.3735 | 113.175 | TT01.02.0955 | 0955 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13439101 | -1.PP_SO-101 | ø20 mm-ø20 mm | G | QMA | JD | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0956 | 0956 |  | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13439105 | -1.PP_SO-101 | ø20 mm-ø20 mm | G | QMA | JD | -1.PP_SO-101 | 2400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0958 | 0958 |  | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13439475 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -319.965 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0959 | 0959 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13439616 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -319.965 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0960 | 0960 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13439751 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -747.774 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0961 | 0961 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13439755 | 4.NP_SO-101 | ø110 mm-ø110 mm | G | QMA | JD | 4.NP_SO-101 | -747.774 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0962 | 0962 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcPipeFitting: M_Křížení, obecné:Standardní (2)
In: 2.NP_SO-101
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 06; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm-ø20 mm-ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
