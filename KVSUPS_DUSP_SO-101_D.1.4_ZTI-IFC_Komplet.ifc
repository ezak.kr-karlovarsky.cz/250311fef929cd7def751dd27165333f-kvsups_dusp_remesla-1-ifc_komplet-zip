Properties of the parts of a building model (IFC4), part 12 of 26

# IfcDistributionPort (5006)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_13434031_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13430260_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13430260_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13430357_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
Port_13430415_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430704_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430415_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430843_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430521_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430704_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430521_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430544_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430534_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430544_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430534_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430554_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430578_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430579_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430578_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430586_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430595_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430838_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430595_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13430843_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431605_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13431435_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431589_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13431605_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431635_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13431589_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13431830_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13438063_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13438067_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13431830_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13431862_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13431856_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13431856_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13438067_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13435566_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13431862_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13434434_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432372_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432617_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13434434_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432880_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432617_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432815_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432880_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432886_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432815_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13432884_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432886_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13433052_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13432981_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13433048_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13433022_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13433022_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13433052_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13434023_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434031_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13434085_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434023_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13438063_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434035_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13434035_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434105_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13434083_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434085_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13434105_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13434083_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
Port_13434646_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435122_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13434646_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435126_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13434665_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13435087_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13435091_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13434665_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13434679_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435052_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13434679_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435056_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13434695_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435015_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434695_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435019_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434717_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434978_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434717_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435167_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434760_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435007_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434776_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435044_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13434793_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13435079_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13434813_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435114_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13434848_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13434850_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13434848_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435122_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
InPort_13434879_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13434881_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13435087_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13434879_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13434910_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13434912_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13434910_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435052_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13434941_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434943_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434941_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435015_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13434972_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434974_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434972_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13434978_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435005_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435007_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435005_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435019_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13435042_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435044_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435042_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
Port_13435056_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 151
InPort_13435079_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13435077_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
InPort_13435077_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
OutPort_13435091_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 2
Port_13435112_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435114_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435112_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435126_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 155
Port_13435165_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435167_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435165_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13435175_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13436585_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13435566_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13435642_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436581_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436625_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13435642_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436006_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436621_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439755_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436006_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436118_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439475_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436653_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436118_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436649_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436433_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436433_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436653_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436621_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436495_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436495_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436625_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436581_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436561_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13436561_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13436585_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13437386_1 | SINK | PIPE | SEWAGE
OutPort_13437377_1 | SOURCE | PIPE | SEWAGE
InPort_13437378_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_13437380_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
OutPort_13437378_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_13437379_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
InPort_13437382_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
OutPort_13437379_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
InPort_13437384_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
OutPort_13437380_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_13437384_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
OutPort_13437382_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
Port_13437386_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13437492_1 | SINK | PIPE | SEWAGE
OutPort_13437483_1 | SOURCE | PIPE | SEWAGE
InPort_13437484_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13437486_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
OutPort_13437484_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13437485_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
InPort_13437488_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
OutPort_13437485_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
InPort_13437490_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
OutPort_13437486_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13437490_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
OutPort_13437488_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
Port_13437492_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13437539_1 | SINK | PIPE | SEWAGE
OutPort_13437530_1 | SOURCE | PIPE | SEWAGE
InPort_13437531_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
InPort_13437533_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
OutPort_13437531_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
InPort_13437532_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
InPort_13437535_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
OutPort_13437532_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
InPort_13437537_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
OutPort_13437533_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
InPort_13437537_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
OutPort_13437535_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
Port_13437539_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13438413_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13438430_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13438452_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13438413_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
InPort_13438421_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
OutPort_13438452_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 10
Port_13439097_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439103_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439098_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439101_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439098_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439105_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439101_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13439103_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13439475_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439169_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439169_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439616_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439751_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439606_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439606_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439755_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439616_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439614_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13439614_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13439751_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1

# IfcDistributionSystem: SW_Odvětrání kanalizace (3)
PredefinedType: VENT
Name
SW_Odvětrání kanalizace 2
SW_Odvětrání kanalizace 10
SW_Odvětrání kanalizace 1

# IfcDistributionSystem: SW_Splašky vnitřní gravitační (8)
PredefinedType: SEWAGE
Name
SW_Splašky vnitřní gravitační 10
SW_Splašky vnitřní gravitační 81
SW_Splašky vnitřní gravitační 4
SW_Splašky vnitřní gravitační 8
SW_Splašky vnitřní gravitační 3
SW_Splašky vnitřní gravitační 7
SW_Splašky vnitřní gravitační 9
SW_Splašky vnitřní gravitační 11

# IfcDistributionSystem: SW_Splašky čerpání, SW_Splašky čerpání 1
PredefinedType: SEWAGE

# IfcDistributionSystem: WS_"ŠEDÁ" studená vnitřní, WS_"Jiný typ" studená vnitřní 1
PredefinedType: DOMESTICCOLDWATER

# IfcDistributionSystem: WS_Cirkulace vnitřní, WS_Cirkulace vnitřní 2
PredefinedType: DOMESTICHOTWATER

# IfcDistributionSystem: WS_Požární zavodněný, WS_Požární zavodněný 1
PredefinedType: FIREPROTECTION

# IfcDistributionSystem: WS_Studená vnitřní (59)
PredefinedType: DOMESTICCOLDWATER
Name
WS_Studená vnitřní 10
WS_Studená vnitřní 11
WS_Studená vnitřní 18
WS_Studená vnitřní 4
WS_Studená vnitřní 20
WS_Studená vnitřní 9
WS_Studená vnitřní 137
WS_Studená vnitřní 142
WS_Studená vnitřní 151
WS_Studená vnitřní 152
WS_Studená vnitřní 153
WS_Studená vnitřní 154
WS_Studená vnitřní 156
WS_Studená vnitřní 157
WS_Studená vnitřní 158
WS_Studená vnitřní 159
WS_Studená vnitřní 160
WS_Studená vnitřní 161
WS_Studená vnitřní 163
WS_Studená vnitřní 164
WS_Studená vnitřní 165
WS_Studená vnitřní 166
WS_Studená vnitřní 167
WS_Studená vnitřní 168
WS_Studená vnitřní 169
WS_Studená vnitřní 170
WS_Studená vnitřní 172
WS_Studená vnitřní 171
WS_Studená vnitřní 89
WS_Studená vnitřní 91
WS_Studená vnitřní 6
WS_Studená vnitřní 7
WS_Studená vnitřní 2
WS_Studená vnitřní 29
WS_Studená vnitřní 30
WS_Studená vnitřní 31
WS_Studená vnitřní 32
WS_Studená vnitřní 33
WS_Studená vnitřní 35
WS_Studená vnitřní 25
WS_Studená vnitřní 14
WS_Studená vnitřní 19
WS_Studená vnitřní 13
WS_Studená vnitřní 5
WS_Studená vnitřní 21
WS_Studená vnitřní 23
WS_Studená vnitřní 24
WS_Studená vnitřní 3
WS_Studená vnitřní 1
WS_Studená vnitřní 22
WS_Studená vnitřní 27
WS_Studená vnitřní 26
WS_Studená vnitřní 16
WS_Studená vnitřní 17
WS_Studená vnitřní 36
WS_Studená vnitřní 15
WS_Studená vnitřní 34
WS_Studená vnitřní 37
WS_Studená vnitřní 12

# IfcDistributionSystem: WS_Teplá vnitřní (56)
PredefinedType: DOMESTICHOTWATER
Name
WS_Teplá vnitřní 14
WS_Teplá vnitřní 15
WS_Teplá vnitřní 22
WS_Teplá vnitřní 11
WS_Teplá vnitřní 24
WS_Teplá vnitřní 13
WS_Teplá vnitřní 141
WS_Teplá vnitřní 146
WS_Teplá vnitřní 155
WS_Teplá vnitřní 156
WS_Teplá vnitřní 157
WS_Teplá vnitřní 158
WS_Teplá vnitřní 160
WS_Teplá vnitřní 161
WS_Teplá vnitřní 162
WS_Teplá vnitřní 163
WS_Teplá vnitřní 164
WS_Teplá vnitřní 165
WS_Teplá vnitřní 167
WS_Teplá vnitřní 168
WS_Teplá vnitřní 169
WS_Teplá vnitřní 170
WS_Teplá vnitřní 171
WS_Teplá vnitřní 172
WS_Teplá vnitřní 173
WS_Teplá vnitřní 174
WS_Teplá vnitřní 176
WS_Teplá vnitřní 175
WS_Teplá vnitřní 90
WS_Teplá vnitřní 92
WS_Teplá vnitřní 4
WS_Teplá vnitřní 5
WS_Teplá vnitřní 7
WS_Teplá vnitřní 8
WS_Teplá vnitřní 9
WS_Teplá vnitřní 10
WS_Teplá vnitřní 19
WS_Teplá vnitřní 25
WS_Teplá vnitřní 20
WS_Teplá vnitřní 18
WS_Teplá vnitřní 23
WS_Teplá vnitřní 17
WS_Teplá vnitřní 2
WS_Teplá vnitřní 26
WS_Teplá vnitřní 27
WS_Teplá vnitřní 28
WS_Teplá vnitřní 16
WS_Teplá vnitřní 30
WS_Teplá vnitřní 29
WS_Teplá vnitřní 12
WS_Teplá vnitřní 21
WS_Teplá vnitřní 31
WS_Teplá vnitřní 6
WS_Teplá vnitřní 32
WS_Teplá vnitřní 33
WS_Teplá vnitřní 3

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Dřez, Sestava Instalační zařizovací předměty:Dřez:13299295
In: 3.NP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13299296; Rodina a typ: Sestava Instalační zařizovací předměty: Dřez; Typ: Dřez
Identifikační data(Type) - ID kategorie: D; Název typu: Dřez
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 1, Sestava Instalační zařizovací předměty:Myčka 1:13299221
In: 2.NP_SO-101
PredefinedType: USERDEFINED; Classification: TR00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13299222; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 1; Typ: Myčka 1
Identifikační data(Type) - ID kategorie: MY; Název typu: Myčka 1
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 3 (2)
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13315424; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 3; Typ: Myčka 3
Identifikační data(Type) - ID kategorie: WCI; Název typu: Myčka 3
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Myčka 3:...) | In
13315290 | 2.NP_SO-101
13315538 | 3.NP_SO-101

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 5, Sestava Instalační zařizovací předměty:Myčka 5:13315651
In: 3.NP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13315656; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 5; Typ: Myčka 5
Identifikační data(Type) - ID kategorie: UMI; Název typu: Myčka 5
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 6 (2)
In: -1.PP_SO-101
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13413849; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 6; Typ: Myčka 6
Identifikační data(Type) - ID kategorie: UM; Název typu: Myčka 6
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Myčka 6:...)
12873075
13413869

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 7 (2)
In: -1.PP_SO-101
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13414490; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 7; Typ: Myčka 7
Identifikační data(Type) - ID kategorie: UM; Název typu: Myčka 7
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Myčka 7:...)
12906252
13414526

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Myčka 8 (2)
In: -1.PP_SO-101
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13426395; Rodina a typ: Sestava Instalační zařizovací předměty: Myčka 8; Typ: Myčka 8
Identifikační data(Type) - ID kategorie: SP; Název typu: Myčka 8
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Myčka 8:...)
12933809
12933838

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Pisoár + modul (7)
PredefinedType: USERDEFINED; Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12878709; Rodina a typ: Sestava Instalační zařizovací předměty: Pisoár + modul; Typ: Pisoár + modul
Identifikační data(Type) - ID kategorie: P; Název typu: Pisoár + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Pisoár + modul:...) | In
12878821 | -1.PP_SO-101
12879005 | -1.PP_SO-101
12879056 | -1.PP_SO-101
12907819 | 2.NP_SO-101
12908656 | 3.NP_SO-101
13427658 | -1.PP_SO-101
13427749 | -1.PP_SO-101

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Sprchový kout - žlab (podomítková baterie) (4)
In: -1.PP_SO-101
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12933216; Rodina a typ: Sestava Instalační zařizovací předměty: Sprchový kout - žlab (podomítková baterie); Typ: Sprchový kout - žlab (podomítková baterie)
Identifikační data(Type) - ID kategorie: SP; Název typu: Sprchový kout - žlab (podomítková baterie)
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Sprchový kout - žlab (podomítková baterie):...)
12933658
12933721
12933780
13218189

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Toaleta + modul (19)
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Id typu: 12822894; Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Rodina a typ: Sestava Instalační zařizovací předměty: Toaleta + modul; Typ: Toaleta + modul
Identifikační data(Type) - ID kategorie: WC; Název typu: Toaleta + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Toaleta + modul:...) | In | Classification
12834107 | -1.PP_SO-101
12834168 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12834220 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12834257 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12834341 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12834394 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12837348 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12906122 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12906130 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12906389 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
12907666 | 2.NP_SO-101 | ZT01 Uniformat (Uniformat)
12907790 | 2.NP_SO-101 | ZT01 Uniformat (Uniformat)
12908716 | 3.NP_SO-101 | ZT01 Uniformat (Uniformat)
12908724 | 3.NP_SO-101 | ZT01 Uniformat (Uniformat)
12944785 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
13218242 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
13413656 | -1.PP_SO-101 | ZT01 Uniformat (Uniformat)
13427846 | 1.NP_SO-101 | ZT01 Uniformat (Uniformat)
13427892 | 1.NP_SO-101 | ZT01 Uniformat (Uniformat)

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Toaleta + modul (madla)_invalida, Sestava Instalační zařizovací předměty:Toaleta + modul (madla)_invalida:13136636
In: -1.PP_SO-101
PredefinedType: USERDEFINED; Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13139398; Rodina a typ: Sestava Instalační zařizovací předměty: Toaleta + modul (madla)_invalida; Typ: Toaleta + modul (madla)_invalida
Identifikační data(Type) - ID kategorie: WCI; Název typu: Toaleta + modul (madla)_invalida
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo (18)
PredefinedType: USERDEFINED; Classification: ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12871338; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo; Typ: Umyvadlo
Identifikační data(Type) - ID kategorie: UM; Název typu: Umyvadlo
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Umyvadlo:...) | In
12872625 | -1.PP_SO-101
12872651 | -1.PP_SO-101
12872828 | -1.PP_SO-101
12872861 | -1.PP_SO-101
12873241 | -1.PP_SO-101
12873275 | -1.PP_SO-101
12905773 | -1.PP_SO-101
12906991 | 2.NP_SO-101
12907381 | 1.NP_SO-101
12907453 | 3.NP_SO-101
12907476 | 3.NP_SO-101
12907723 | 3.NP_SO-101
12907985 | 2.NP_SO-101
12908787 | 3.NP_SO-101
13136481 | -1.PP_SO-101
13218079 | -1.PP_SO-101
13437387 | 1.NP_SO-101
13437493 | 1.NP_SO-101

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo + modul (25)
PredefinedType: USERDEFINED; Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12869983; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo + modul; Typ: Umyvadlo + modul
Identifikační data(Type) - ID kategorie: UM; Název typu: Umyvadlo + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Umyvadlo + modul:...) | In
12906445 | -1.PP_SO-101
12907050 | 1.NP_SO-101
12907117 | 1.NP_SO-101
12907141 | 1.NP_SO-101
12907561 | 2.NP_SO-101
12907585 | 2.NP_SO-101
12908044 | 2.NP_SO-101
12908068 | 2.NP_SO-101
12908151 | 2.NP_SO-101
12908175 | 2.NP_SO-101
12908270 | 2.NP_SO-101
12908340 | -1.PP_SO-101
12908462 | -1.PP_SO-101
12908596 | 3.NP_SO-101
12944906 | -1.PP_SO-101
12944930 | -1.PP_SO-101
13218427 | -1.PP_SO-101
13218523 | -1.PP_SO-101
13218690 | -1.PP_SO-101
13279635 | -1.PP_SO-101
13279979 | -1.PP_SO-101
13281693 | 1.NP_SO-101
13281839 | 1.NP_SO-101
13428040 | 2.NP_SO-101
13437540 | 1.NP_SO-101

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo + modul_invalida, Sestava Instalační zařizovací předměty:Umyvadlo + modul_invalida:13142843
In: -1.PP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13142844; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo + modul_invalida; Typ: Umyvadlo + modul_invalida
Identifikační data(Type) - ID kategorie: UMI; Název typu: Umyvadlo + modul_invalida
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo invalida s předstěnou, Sestava Instalační zařizovací předměty:Umyvadlo invalida s předstěnou:13315247
In: 2.NP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13315248; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo invalida s předstěnou; Typ: Umyvadlo invalida s předstěnou
Identifikační data(Type) - ID kategorie: UMI; Název typu: Umyvadlo invalida s předstěnou
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka + modul, Sestava Instalační zařizovací předměty:Výlevka + modul:12908850
In: -1.PP_SO-101
PredefinedType: USERDEFINED; Classification: MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12828512; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka + modul; Typ: Výlevka + modul
Identifikační data(Type) - ID kategorie: VY; Název typu: Výlevka + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnní (5)
In: 2.NP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13144922; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnní; Typ: Výlevka nástěnní
Identifikační data(Type) - ID kategorie: VL; Název typu: Výlevka nástěnní
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnní:...)
13192354
13192377
13192403
13192429
13192455

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnî, Sestava Instalační zařizovací předměty:Výlevka nástěnnî:13192539
In: 2.NP_SO-101
PredefinedType: USERDEFINED; Classification: VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13192552; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnî; Typ: Výlevka nástěnnî
Identifikační data(Type) - ID kategorie: VL; Název typu: Výlevka nástěnnî
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnð (2)
In: -1.PP_SO-101
PredefinedType: USERDEFINED; Classification: SB01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13286952; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnð; Typ: Výlevka nástěnnð
Identifikační data(Type) - ID kategorie: PR; Název typu: Výlevka nástěnnð
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnð:...)
13286949
13286962

# IfcElementAssembly: Sestava Mechanické zařízení:Myčka, Sestava Mechanické zařízení:Myčka:13297344
In: 1.NP_SO-101
PredefinedType: USERDEFINED; Classification: SB02 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Mechanické zařízení
Jiné - Kategorie: Sestavy; Id typu: 13297345; Rodina: Sestava Mechanické zařízení; Rodina a typ: Sestava Mechanické zařízení: Myčka; Typ: Myčka
Identifikační data(Type) - ID kategorie: MY; Název typu: Myčka
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Mechanické zařízení

# IfcFlowTerminal: Baterie dřezová stojánková:Baterie dřezová stojánková (7)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BD; Kód sestavy: ZT09; Komentáře k typům: stojánková páková; Název typu: Baterie dřezová stojánková; Označení typu: 22; Popis: Baterie stojánková pro dřez; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie dřezová stojánková
Classification: ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 777 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 842 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - Objem: 0.000503789 m3
Jiné - Id typu: 13143004; Rodina: Baterie dřezová stojánková; Rodina a typ: Baterie dřezová stojánková: Baterie dřezová stojánková; Typ: Baterie dřezová stojánková
Name (Baterie dřezová stojánková:Baterie dřezová stojánková:...) | In | Podlaží = Vztažné podlaží | Název systému | Kód prvku | Název sestavy | Označení | Group
13144909 | 3.NP_SO-101 | 3.NP_SO-101 | WS_Teplá vnitřní 5,WS_Studená vnitřní 7 | ZT09.22.0193 | Dřez | 0193 | WS_Teplá vnitřní 5; WS_Studená vnitřní 7
13192355 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 7,WS_Studená vnitřní 29 | ZT09.22.0206 | Výlevka nástěnní | 0206 | WS_Teplá vnitřní 7; WS_Studená vnitřní 29
13192378 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 8,WS_Studená vnitřní 30 | ZT09.22.0209 | Výlevka nástěnní | 0209 | WS_Teplá vnitřní 8; WS_Studená vnitřní 30
13192404 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 9,WS_Studená vnitřní 31 | ZT09.22.0212 | Výlevka nástěnní | 0212 | WS_Teplá vnitřní 9; WS_Studená vnitřní 31
13192430 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 10,WS_Studená vnitřní 32 | ZT09.22.0215 | Výlevka nástěnní | 0215 | WS_Teplá vnitřní 10; WS_Studená vnitřní 32
13192456 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 19,WS_Studená vnitřní 33 | ZT09.22.0218 | Výlevka nástěnní | 0218 | WS_Teplá vnitřní 19; WS_Studená vnitřní 33
13192540 | 2.NP_SO-101 | 2.NP_SO-101 | WS_Teplá vnitřní 25,WS_Studená vnitřní 35 | ZT09.22.0221 | Výlevka nástěnnî | 0221 | WS_Teplá vnitřní 25; WS_Studená vnitřní 35

# IfcFlowTerminal: Baterie sprchová podomítková:Baterie sprchová podomítková (6)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 30 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BP; Kód sestavy: ZT09; Komentáře k typům: Komentáře k typům; Model: Model; Název typu: Baterie sprchová podomítková; Označení typu: 13; Popis: Baterie podomítková; Popis sestavy: Baterie; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie sprchová podomítková
Classification: ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti,Teplá voda v domácnosti; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.00111865 m3; Plocha: 0.060331 m2
Jiné - Id typu: 12831425; Rodina: Baterie sprchová podomítková; Rodina a typ: Baterie sprchová podomítková: Baterie sprchová podomítková; Typ: Baterie sprchová podomítková
Name (Baterie sprchová podomítková:Baterie sprchová podomítková:...) | Kód prvku | Název sestavy | Označení
12933659 | ZT09.13.0156 | Sprchový kout - žlab (podomítková baterie) | 0156
12933722 | ZT09.13.0159 | Sprchový kout - žlab (podomítková baterie) | 0159
12933781 | ZT09.13.0162 | Sprchový kout - žlab (podomítková baterie) | 0162
12933810 | ZT09.13.0165 | Myčka 8 | 0165
12933839 | ZT09.13.0168 | Myčka 8 | 0168
13218190 | ZT09.13.0227 | Sprchový kout - žlab (podomítková baterie) | 0227

# IfcFlowTerminal: Baterie umyvadlová stojánková:Baterie umyvadlová stojánková (47)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BS; Kód sestavy: ZT09; Komentáře k typům: Baterie stojánková; Název typu: Baterie umyvadlová stojánková; Označení typu: 05; Popis: Baterie stojánková; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie umyvadlová stojánková
Classification: ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Umyvadlo : Umyvadlo
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - Objem: 0.00046128 m3
Jiné - Id typu: 12812718; JM: 12.5 mm; Rodina: Baterie umyvadlová stojánková; Rodina a typ: Baterie umyvadlová stojánková: Baterie umyvadlová stojánková; Typ: Baterie umyvadlová stojánková
Name (Baterie umyvadlová stojánková:Baterie umyvadlová stojánková:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Název systému | Kód prvku | Název sestavy | Označení | Group
12872622 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 14,WS_Studená vnitřní 10 | ZT09.05.0020 | Umyvadlo | 0020 | WS_Teplá vnitřní 14; WS_Studená vnitřní 10
12872648 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 15,WS_Studená vnitřní 11 | ZT09.05.0023 | Umyvadlo | 0023 | WS_Teplá vnitřní 15; WS_Studená vnitřní 11
12872825 | -1.PP_SO-101 | -1.PP_SO-101 | 93.3325 | WS_Teplá vnitřní 22,WS_Studená vnitřní 18 | ZT09.05.0026 | Umyvadlo | 0026 | WS_Teplá vnitřní 22; WS_Studená vnitřní 18
12872858 | -1.PP_SO-101 | -1.PP_SO-101 | 93.3325 | WS_Teplá vnitřní 11,WS_Studená vnitřní 4 | ZT09.05.0029 | Umyvadlo | 0029 | WS_Teplá vnitřní 11; WS_Studená vnitřní 4
12873238 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 24,WS_Studená vnitřní 20 | ZT09.05.0032 | Umyvadlo | 0032 | WS_Teplá vnitřní 24; WS_Studená vnitřní 20
12873272 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 13,WS_Studená vnitřní 9 | ZT09.05.0035 | Umyvadlo | 0035 | WS_Teplá vnitřní 13; WS_Studená vnitřní 9
12905770 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 141,WS_Studená vnitřní 137 | ZT09.05.0047 | Umyvadlo | 0047 | WS_Teplá vnitřní 141; WS_Studená vnitřní 137
12906442 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 146,WS_Studená vnitřní 142 | ZT09.05.0060 | Umyvadlo + modul | 0060 | WS_Teplá vnitřní 146; WS_Studená vnitřní 142
12906988 | 2.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 155,WS_Studená vnitřní 151 | ZT09.05.0063 | Umyvadlo | 0063 | WS_Teplá vnitřní 155; WS_Studená vnitřní 151
12907047 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 156,WS_Studená vnitřní 152 | ZT09.05.0067 | Umyvadlo + modul | 0067 | WS_Teplá vnitřní 156; WS_Studená vnitřní 152
12907114 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 157,WS_Studená vnitřní 153 | ZT09.05.0071 | Umyvadlo + modul | 0071 | WS_Teplá vnitřní 157; WS_Studená vnitřní 153
12907138 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 158,WS_Studená vnitřní 154 | ZT09.05.0075 | Umyvadlo + modul | 0075 | WS_Teplá vnitřní 158; WS_Studená vnitřní 154
12907378 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 160,WS_Studená vnitřní 156 | ZT09.05.0078 | Umyvadlo | 0078 | WS_Teplá vnitřní 160; WS_Studená vnitřní 156
12907450 | 3.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 161,WS_Studená vnitřní 157 | ZT09.05.0081 | Umyvadlo | 0081 | WS_Teplá vnitřní 161; WS_Studená vnitřní 157
12907473 | 3.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 162,WS_Studená vnitřní 158 | ZT09.05.0084 | Umyvadlo | 0084 | WS_Teplá vnitřní 162; WS_Studená vnitřní 158
12907558 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 163,WS_Studená vnitřní 159 | ZT09.05.0088 | Umyvadlo + modul | 0088 | WS_Teplá vnitřní 163; WS_Studená vnitřní 159
12907582 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 164,WS_Studená vnitřní 160 | ZT09.05.0092 | Umyvadlo + modul | 0092 | WS_Teplá vnitřní 164; WS_Studená vnitřní 160
12907720 | 3.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 165,WS_Studená vnitřní 161 | ZT09.05.0098 | Umyvadlo | 0098 | WS_Teplá vnitřní 165; WS_Studená vnitřní 161
12907982 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 167,WS_Studená vnitřní 163 | ZT09.05.0107 | Umyvadlo | 0107 | WS_Teplá vnitřní 167; WS_Studená vnitřní 163
12908041 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 168,WS_Studená vnitřní 164 | ZT09.05.0111 | Umyvadlo + modul | 0111 | WS_Teplá vnitřní 168; WS_Studená vnitřní 164
12908065 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 169,WS_Studená vnitřní 165 | ZT09.05.0115 | Umyvadlo + modul | 0115 | WS_Teplá vnitřní 169; WS_Studená vnitřní 165
12908148 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 170,WS_Studená vnitřní 166 | ZT09.05.0119 | Umyvadlo + modul | 0119 | WS_Teplá vnitřní 170; WS_Studená vnitřní 166
12908172 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 171,WS_Studená vnitřní 167 | ZT09.05.0123 | Umyvadlo + modul | 0123 | WS_Teplá vnitřní 171; WS_Studená vnitřní 167
12908267 | 2.NP_SO-101 | 3.NP_SO-101 | 843.333 | WS_Teplá vnitřní 172,WS_Studená vnitřní 168 | ZT09.05.0127 | Umyvadlo + modul | 0127 | WS_Teplá vnitřní 172; WS_Studená vnitřní 168
12908337 | -1.PP_SO-101 | 4.NP_SO-101 | 1543.33 | WS_Teplá vnitřní 173,WS_Studená vnitřní 169 | ZT09.05.0131 | Umyvadlo + modul | 0131 | WS_Teplá vnitřní 173; WS_Studená vnitřní 169
12908459 | -1.PP_SO-101 | 4.NP_SO-101 | 1543.33 | WS_Teplá vnitřní 174,WS_Studená vnitřní 170 | ZT09.05.0135 | Umyvadlo + modul | 0135 | WS_Teplá vnitřní 174; WS_Studená vnitřní 170
12908593 | 3.NP_SO-101 | 4.NP_SO-101 | 843.333 | WS_Teplá vnitřní 176,WS_Studená vnitřní 172 | ZT09.05.0139 | Umyvadlo + modul | 0139 | WS_Teplá vnitřní 176; WS_Studená vnitřní 172
12908784 | 3.NP_SO-101 | 4.NP_SO-101 | 843.333 | WS_Teplá vnitřní 175,WS_Studená vnitřní 171 | ZT09.05.0151 | Umyvadlo | 0151 | WS_Teplá vnitřní 175; WS_Studená vnitřní 171
12944903 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 90,WS_Studená vnitřní 89 | ZT09.05.0176 | Umyvadlo + modul | 0176 | WS_Teplá vnitřní 90; WS_Studená vnitřní 89
12944927 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 92,WS_Studená vnitřní 91 | ZT09.05.0180 | Umyvadlo + modul | 0180 | WS_Teplá vnitřní 92; WS_Studená vnitřní 91
13136478 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 155,WS_Studená vnitřní 151 | ZT09.05.0183 | Umyvadlo | 0183 | WS_Teplá vnitřní 155; WS_Studená vnitřní 151
13218076 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 20,WS_Studená vnitřní 25 | ZT09.05.0225 | Umyvadlo | 0225 | WS_Teplá vnitřní 20; WS_Studená vnitřní 25
13218424 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 18,WS_Studená vnitřní 14 | ZT09.05.0235 | Umyvadlo + modul | 0235 | WS_Teplá vnitřní 18; WS_Studená vnitřní 14
13218520 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 23,WS_Studená vnitřní 19 | ZT09.05.0239 | Umyvadlo + modul | 0239 | WS_Teplá vnitřní 23; WS_Studená vnitřní 19
13218687 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 17,WS_Studená vnitřní 13 | ZT09.05.0243 | Umyvadlo + modul | 0243 | WS_Teplá vnitřní 17; WS_Studená vnitřní 13
13279632 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 2,WS_Studená vnitřní 5 | ZT09.05.0247 | Umyvadlo + modul | 0247 | WS_Teplá vnitřní 2; WS_Studená vnitřní 5
13279976 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 26,WS_Studená vnitřní 21 | ZT09.05.0251 | Umyvadlo + modul | 0251 | WS_Teplá vnitřní 26; WS_Studená vnitřní 21
13281690 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 27,WS_Studená vnitřní 23 | ZT09.05.0255 | Umyvadlo + modul | 0255 | WS_Teplá vnitřní 27; WS_Studená vnitřní 23
13281836 | 1.NP_SO-101 | 2.NP_SO-101 | 843.333 | WS_Teplá vnitřní 28,WS_Studená vnitřní 24 | ZT09.05.0259 | Umyvadlo + modul | 0259 | WS_Teplá vnitřní 28; WS_Studená vnitřní 24
13413838 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 29,WS_Studená vnitřní 26 | ZT09.05.0282 | Myčka 6 | 0282 | WS_Teplá vnitřní 29; WS_Studená vnitřní 26
13413877 | -1.PP_SO-101 | -1.PP_SO-101 | 843.333 | WS_Teplá vnitřní 12,WS_Studená vnitřní 16 | ZT09.05.0285 | Myčka 6 | 0285 | WS_Teplá vnitřní 12; WS_Studená vnitřní 16
13414479 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 21,WS_Studená vnitřní 17 | ZT09.05.0289 | Myčka 7 | 0289 | WS_Teplá vnitřní 21; WS_Studená vnitřní 17
13414535 | -1.PP_SO-101 | 1.NP_SO-101 | 843.333 | WS_Teplá vnitřní 31,WS_Studená vnitřní 36 | ZT09.05.0293 | Myčka 7 | 0293 | WS_Teplá vnitřní 31; WS_Studená vnitřní 36
13428037 | 2.NP_SO-101 |  | 0 | WS_Teplá vnitřní 6,WS_Studená vnitřní 15 | ZT09.05.0313 | Umyvadlo + modul | 0313 | WS_Teplá vnitřní 6; WS_Studená vnitřní 15
13437384 | 1.NP_SO-101 |  | 0 | WS_Teplá vnitřní 32,WS_Studená vnitřní 34 | ZT09.05.0316 | Umyvadlo | 0316 | WS_Teplá vnitřní 32; WS_Studená vnitřní 34
13437490 | 1.NP_SO-101 |  | 0 | WS_Teplá vnitřní 33,WS_Studená vnitřní 37 | ZT09.05.0319 | Umyvadlo | 0319 | WS_Teplá vnitřní 33; WS_Studená vnitřní 37
13437537 | 1.NP_SO-101 |  | 0 | WS_Teplá vnitřní 3,WS_Studená vnitřní 12 | ZT09.05.0323 | Umyvadlo + modul | 0323 | WS_Teplá vnitřní 3; WS_Studená vnitřní 12

# IfcFlowTerminal: Baterie umyvadlová stojánková_invalida:Baterie umyvadlová stojánková_invalida (3)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BSi; Kód sestavy: ZT09; Komentáře k typům: Baterie stojánková, invalida; Název typu: Baterie umyvadlová stojánková_invalida; Označení typu: 20; Popis: Baterie stojánková invalida; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie umyvadlová stojánková_invalida
Classification: ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: -45.8135 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 800 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.000582104 m3
Jiné - Id typu: 13139489; JM: 12.5 mm; Rodina: Baterie umyvadlová stojánková_invalida; Rodina a typ: Baterie umyvadlová stojánková_invalida: Baterie umyvadlová stojánková_invalida; Typ: Baterie umyvadlová stojánková_invalida
Name (Baterie umyvadlová stojánková_invalida:Baterie umyvadlová stojánková_invalida:...) | In | Podlaží = Vztažné podlaží | Název systému | Kód prvku | Název sestavy | Označení | Group
13142707 | -1.PP_SO-101 | 1.NP_SO-101 | WS_Teplá vnitřní 4,WS_Studená vnitřní 6 | ZT09.20.0191 | Umyvadlo + modul_invalida | 0191 | WS_Teplá vnitřní 4; WS_Studená vnitřní 6
13315245 | 2.NP_SO-101 | 3.NP_SO-101 | WS_Teplá vnitřní 16,WS_Studená vnitřní 22 | ZT09.20.0266 | Umyvadlo invalida s předstěnou | 0266 | WS_Teplá vnitřní 16; WS_Studená vnitřní 22
13315649 | 3.NP_SO-101 | 4.NP_SO-101 | WS_Teplá vnitřní 30,WS_Studená vnitřní 27 | ZT09.20.0273 | Myčka 5 | 0273 | WS_Teplá vnitřní 30; WS_Studená vnitřní 27

# IfcFlowTerminal: Baterie výlevková nástěnná:Baterie výlevková nástěnná, Baterie výlevková nástěnná:Baterie výlevková nástěnná:12908851
In: -1.PP_SO-101
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 1150 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BNi; Kód sestavy: ZT09; Komentáře k typům: dřezová, nástěnná páková, rozteč 150 mm, invalida; Název typu: Baterie výlevková nástěnná; Označení typu: 12; Popis: Baterie nástěnná invalida; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie výlevková nástěnná
Classification: ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Podlaží: 4.NP_SO-101; Vztažné podlaží: 4.NP_SO-101; Odsazení od hostitele: 1100 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 1100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.000614887 m3; Rozteč: 150 mm
Identifikační data - Kód prvku: ZT09.12.0155; Název sestavy: Výlevka + modul; Označení: 0155
Jiné - Id typu: 12825708; Rodina: Baterie výlevková nástěnná; Rodina a typ: Baterie výlevková nástěnná: Baterie výlevková nástěnná; Typ: Baterie výlevková nástěnná

# IfcFlowTerminal: Dřez_centrovaný.CC:Dřez_centrovaný.CC (7)
Type - Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Délka: 500 mm; JMENOVITÝ PRŮMĚR: 50 mm; Šířka: 400 mm; Výška: 200 mm; Výška od podlahy: 850 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: D; Kód sestavy: ZT06; Komentáře k typům: Dřez bez odkapávače; Název typu: Dřez_centrovaný.CC; Označení typu: 21; Popis: Dřez; Popis sestavy: Dřez; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Dřez_centrovaný.CC
Classification: ZT06 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JD
Vazby - Odsazení od hostitele: 14.5719 mm; Výška od podlaží: 14.5719 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.017099 m3
Jiné - Id typu: 13143005; Rodina: Dřez_centrovaný.CC; Rodina a typ: Dřez_centrovaný.CC: Dřez_centrovaný.CC; Typ: Dřez_centrovaný.CC
Name (Dřez_centrovaný.CC:Dřez_centrovaný.CC:...) | In | Podlaží | Hostitel | Kód prvku | Název sestavy | Označení
13144907 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | ZT06.21.0192 | Dřez | 0192
13192353 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0205 | Výlevka nástěnní | 0205
13192376 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0208 | Výlevka nástěnní | 0208
13192402 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0211 | Výlevka nástěnní | 0211
13192428 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0214 | Výlevka nástěnní | 0214
13192454 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0217 | Výlevka nástěnní | 0217
13192538 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | ZT06.21.0220 | Výlevka nástěnnî | 0220

# IfcFlowTerminal: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH:800×800, RAL3000 (5)
Type - Material: pictogram_color_red, pictogram_color_white, 032-175-175, Wartość domyślna Nowy materiał, Szkło, DC01, RAL3000
Type - Mechanické – tok - K Factor: 42
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: DC01, RAL3000
Type - Kóty - D1: 90 mm; D2: 90 mm; Délka: 800 mm; H1: 90 mm; Jmenovitá velikost vstupu: 25 mm; Šířka: 220 mm; Výška: 800 mm; W1: 90 mm; W2: 90 mm
Type - Identifikační data - Kód sestavy: HY00; Model: HW-25NW-20/30 HS (N), RAL3000; Název typu: 800×800, RAL3000; Označení typu: 26; Popis: http://gras.pl/en/hw-25-n-20-30-hs/; URL: http://www.gras.pl/; Výrobce: GRAS PPPH
Type - Jiné - Kategorie: Instalační zařizovací předměty; Délka hadice: 0 mm; Název rodiny: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH; Průtok hasiva: 0.06 m3/s
Classification: HY00 Uniformat (Uniformat); Group: WS_Požární zavodněný 1
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Hostitel: <nepřiřazeno>
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární zavodněný; Klasifikace systému: Požární ochrana – vodní prostředky; Název systému: WS_Požární zavodněný 1
Stavba - Door_Right - Door_Left: no
Kóty - Objem: 0.1408 m3; Plocha: 1.40071 m2
Identifikační data - ID pozice: Hydrant
Jiné - Páteřní trasa: yes; Id typu: 13156349; Rodina: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH; Rodina a typ: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH: 800×800, RAL3000; Typ: 800×800, RAL3000
Name (Hydrant D25 s tvarově stálou hadicí_nástěnný.LH:800×800, RAL3000:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13156518 | -1.PP_SO-101 | -1.PP_SO-101 | 1150 | HY00.26.0197 | 0197
13156994 | 1.NP_SO-101 | 1.NP_SO-101 | 800 | HY00.26.0198 | 0198
13162180 | 2.NP_SO-101 | 2.NP_SO-101 | 800 | HY00.26.0199 | 0199
13163107 | 3.NP_SO-101 | 3.NP_SO-101 | 800 | HY00.26.0200 | 0200
13163838 | 4.NP_SO-101 | 4.NP_SO-101 | 800 | HY00.26.0201 | 0201

# IfcFlowTerminal: Komponent 4000.0:Komponent 4000.0 (3)
Type - Material: Plactic - Black
Type - Vazby - Výchozí výška: 600 mm
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm
