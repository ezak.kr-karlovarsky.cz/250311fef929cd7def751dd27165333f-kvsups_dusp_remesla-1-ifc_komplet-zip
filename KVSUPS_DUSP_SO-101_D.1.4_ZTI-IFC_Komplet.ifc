Properties of the parts of a building model (IFC4), part 23 of 26

# IfcPipeSegment: Typy trubek:PP-RCT (581)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Reynoldsovo číslo = Třecí faktor = Tření = Doplňkový průtok (m3/s) = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Relativní drsnost | CCI Funkční systém | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13190002 | 1.NP_SO-101 | 107.704 | 0.00950189 | 0.0372198 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | 1.NP_SO-101 | -159.747 | -267.45 | -159.747 | -267.45 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 10 | -267.45 | PP–RCT S4 | 110 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 107.704 | ø110 | 85.4 | TR10.02.0566 | 0566 | yes | SW_Splašky vnitřní gravitační 10
13190583 | -1.PP_SO-101 | 6780.46 | 0.0004908 | 0.532536 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 178 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6780.46 | ø25 | 19.4 | TR10.02.0572 | 0572 | no | WS_Teplá vnitřní 155 | 0 | Identifikační data - Komentáře: 2xbrus ( voda+odpad)
13190673 | -1.PP_SO-101 | 1396.17 | 0.0004908 | 0.109655 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -859.7 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1396.17 | ø25 | 19.4 | TR10.02.0573 | 0573 | no | WS_Teplá vnitřní 155 | 0
13190675 | -1.PP_SO-101 | 939.206 | 0.000314112 | 0.0590121 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -857.7 | PP–RCT S4 | 20 | 71 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 939.206 | ø20 | 15.4 | TR10.02.0574 | 0574 | no | WS_Teplá vnitřní 155 | 0
13190702 | -1.PP_SO-101 | 1065.87 | 0.000314112 | 0.0669705 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2310 | 2300 | 2300 | 2290 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -857.7 | PP–RCT S4 | 20 | 367 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1065.87 | ø20 | 15.4 | TR10.02.0575 | 0575 | no | WS_Studená vnitřní 151 | 0
13190704 | -1.PP_SO-101 | 1359.91 | 0.0004908 | 0.106807 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2312.5 | 2300 | 2300 | 2287.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -859.7 | PP–RCT S4 | 25 | 375 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1359.91 | ø25 | 19.4 | TR10.02.0576 | 0576 | no | WS_Studená vnitřní 151 | 0
13191502 | 2.NP_SO-101 | 3265.07 | 0.000314112 | 0.205151 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3332.54 | 67.4625 | 3332.54 | 67.4625 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4067.46 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3265.07 | ø20 | 15.4 | TR10.02.0577 | 0577 | no | WS_Studená vnitřní 151
13191607 | 2.NP_SO-101 | 3265.07 | 0.000314112 | 0.205151 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3332.54 | 67.4625 | 3332.54 | 67.4625 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4067.46 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3265.07 | ø20 | 15.4 | TR10.02.0578 | 0578 | no | WS_Teplá vnitřní 155
13191719 | 2.NP_SO-101 | 536.188 | 0.000314112 | 0.0336897 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 125 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 536.188 | ø20 | 15.4 | TR10.02.0579 | 0579 | no | WS_Studená vnitřní 151 | 0
13191729 | 2.NP_SO-101 | 916.187 | 0.000314112 | 0.0575658 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 126 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 916.187 | ø20 | 15.4 | TR10.02.0580 | 0580 | no | WS_Studená vnitřní 151 | 0 | Identifikační data - Komentáře: laboratorní stoly s výlevkami
13191746 | 2.NP_SO-101 | 636.719 | 0.000314112 | 0.0400063 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 130 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 636.719 | ø20 | 15.4 | TR10.02.0581 | 0581 | no | WS_Teplá vnitřní 155 | 0
13191754 | 2.NP_SO-101 | 815.656 | 0.000314112 | 0.0512492 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 815.656 | ø20 | 15.4 | TR10.02.0582 | 0582 | no | WS_Teplá vnitřní 155 | 0
13191767 | 2.NP_SO-101 | 1896.19 | 0.000314112 | 0.119141 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 133 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1896.19 | ø20 | 15.4 | TR10.02.0583 | 0583 | no | WS_Teplá vnitřní 155 | 0
13191906 | 2.NP_SO-101 | 1996.72 | 0.000314112 | 0.125458 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 128 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1996.72 | ø20 | 15.4 | TR10.02.0584 | 0584 | no | WS_Studená vnitřní 151 | 0
13191993 | 2.NP_SO-101 | 1076.19 | 0.000314112 | 0.0676189 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 130 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1076.19 | ø20 | 15.4 | TR10.02.0585 | 0585 | no | WS_Studená vnitřní 151 | 0
13192002 | 2.NP_SO-101 | 4869.96 | 0.000314112 | 0.305989 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 127 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4869.96 | ø20 | 15.4 | TR10.02.0586 | 0586 | no | WS_Studená vnitřní 151 | 0
13192064 | 2.NP_SO-101 | 3119.22 | 0.000314112 | 0.195986 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 129 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3119.22 | ø20 | 15.4 | TR10.02.0587 | 0587 | no | WS_Studená vnitřní 151 | 0
13192066 | 2.NP_SO-101 | 476.188 | 0.000314112 | 0.0299197 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 476.188 | ø20 | 15.4 | TR10.02.0588 | 0588 | no | WS_Studená vnitřní 151 | 0
13192072 | 2.NP_SO-101 | 975.656 | 0.000314112 | 0.0613023 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 135 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 975.656 | ø20 | 15.4 | TR10.02.0589 | 0589 | no | WS_Teplá vnitřní 155 | 0
13192081 | 2.NP_SO-101 | 4902 | 0.000314112 | 0.308002 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4902 | ø20 | 15.4 | TR10.02.0590 | 0590 | no | WS_Teplá vnitřní 155 | 0
13192156 | 2.NP_SO-101 | 3140.3 | 0.000314112 | 0.197311 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3140.3 | ø20 | 15.4 | TR10.02.0591 | 0591 | no | WS_Teplá vnitřní 155 | 0
13192158 | 2.NP_SO-101 | 576.719 | 0.000314112 | 0.0362363 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 576.719 | ø20 | 15.4 | TR10.02.0592 | 0592 | no | WS_Teplá vnitřní 155 | 0
13192163 | 2.NP_SO-101 | 1756.19 | 0.000314112 | 0.110345 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 138 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1756.19 | ø20 | 15.4 | TR10.02.0593 | 0593 | no | WS_Teplá vnitřní 155 | 0
13192172 | 2.NP_SO-101 | 3172.83 | 0.000314112 | 0.199355 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3172.83 | ø20 | 15.4 | TR10.02.0594 | 0594 | no | WS_Teplá vnitřní 155 | 0
13192202 | 2.NP_SO-101 | 1856.72 | 0.000314112 | 0.116661 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 133 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1856.72 | ø20 | 15.4 | TR10.02.0595 | 0595 | no | WS_Studená vnitřní 151 | 0
13192211 | 2.NP_SO-101 | 2947.92 | 0.000314112 | 0.185223 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2947.92 | ø20 | 15.4 | TR10.02.0596 | 0596 | no | WS_Studená vnitřní 151 | 0
13192261 | 2.NP_SO-101 | 856.187 | 0.000314112 | 0.0537958 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3360 | 3350 | 3350 | 3340 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7342.3 | PP–RCT S4 | 20 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 856.187 | ø20 | 15.4 | TR10.02.0597 | 0597 | no | WS_Studená vnitřní 151 | 0
13192273 | 2.NP_SO-101 | 16083.6 | 0.000314112 | 1.01056 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 16083.6 | ø20 | 15.4 | TR10.02.0598 | 0598 | yes | WS_Studená vnitřní 151 | 0
13192629 | 2.NP_SO-101 | 1380.72 | 0.000314112 | 0.086753 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 4042.3 | PP–RCT S4 | 20 | 129 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1380.72 | ø20 | 15.4 | TR10.02.0599 | 0599 | no | WS_Teplá vnitřní 155 | 0
13192650 | 2.NP_SO-101 | 1398.75 | 0.000314112 | 0.0878861 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 60 | 50 | 50 | 40 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 4042.3 | PP–RCT S4 | 20 | 124 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1398.75 | ø20 | 15.4 | TR10.02.0600 | 0600 | no | WS_Studená vnitřní 151 | 0
13198877 | 1.NP_SO-101 | 30.2644 | 0.000314112 | 0.00190157 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3365.87 | 3335.6 | 3365.87 | 3335.6 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3335.6 | PP–RCT S4 | 20 | 148 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 30.2644 | ø20 | 15.4 | TR10.02.0601 | 0601 | no | WS_Studená vnitřní 151
13198941 | 1.NP_SO-101 | 1393.23 | 0.0004908 | 0.109424 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1393.23 | ø25 | 19.4 | TR10.02.0602 | 0602 | yes | WS_Studená vnitřní 151 | 0
13198966 | 1.NP_SO-101 | 5746.29 | 0.0004908 | 0.451313 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3390.3 | PP–RCT S4 | 25 | 98 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5746.29 | ø25 | 19.4 | TR10.02.0603 | 0603 | yes | WS_Studená vnitřní 151 | 0
13198977 | 1.NP_SO-101 | 807.627 | 0.000314112 | 0.0507447 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3328.14 | 3318.14 | 3318.14 | 3308.14 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3310.44 | PP–RCT S4 | 20 | 148 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 807.627 | ø20 | 15.4 | TR10.02.0604 | 0604 | no | WS_Studená vnitřní 151 | 0
13199068 | 1.NP_SO-101 | 647.627 | 0.000314112 | 0.0406916 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3328.14 | 3318.14 | 3318.14 | 3308.14 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3310.44 | PP–RCT S4 | 20 | 141 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 647.627 | ø20 | 15.4 | TR10.02.0605 | 0605 | no | WS_Teplá vnitřní 155 | 0
13199077 | 1.NP_SO-101 | 30.2644 | 0.000314112 | 0.00190157 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3365.87 | 3335.6 | 3365.87 | 3335.6 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3335.6 | PP–RCT S4 | 20 | 141 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 30.2644 | ø20 | 15.4 | TR10.02.0606 | 0606 | no | WS_Teplá vnitřní 155
13199080 | 1.NP_SO-101 | 5827.32 | 0.0004908 | 0.457677 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3412.5 | 3400 | 3400 | 3387.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3390.3 | PP–RCT S4 | 25 | 93 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5827.32 | ø25 | 19.4 | TR10.02.0607 | 0607 | yes | WS_Teplá vnitřní 155 | 0
13199347 | 1.NP_SO-101 | 19.8435 | 0.000314112 | 0.00124681 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 590 | 580 | 580 | 570 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 572.3 | PP–RCT S4 | 20 | 148 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19.8435 | ø20 | 15.4 | TR10.02.0608 | 0608 | no | WS_Studená vnitřní 151 | 0
13199348 | 1.NP_SO-101 | 2703.22 | 0.000314112 | 0.169848 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3300.68 | 3300.68 | 597.462 | 597.462 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 597.462 | PP–RCT S4 | 20 | 148 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2703.22 | ø20 | 15.4 | TR10.02.0609 | 0609 | no | WS_Studená vnitřní 151
13199475 | 1.NP_SO-101 | 19.8435 | 0.000314112 | 0.00124681 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 590 | 580 | 580 | 570 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 572.3 | PP–RCT S4 | 20 | 141 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19.8435 | ø20 | 15.4 | TR10.02.0610 | 0610 | no | WS_Teplá vnitřní 155 | 0
13199476 | 1.NP_SO-101 | 2703.22 | 0.000314112 | 0.169848 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3300.68 | 3300.68 | 597.462 | 597.462 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 597.462 | PP–RCT S4 | 20 | 141 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2703.22 | ø20 | 15.4 | TR10.02.0611 | 0611 | no | WS_Teplá vnitřní 155
13199626 | -1.PP_SO-101 | 3866.3 | 0.000314112 | 0.242927 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2510 | 2500 | 2500 | 2490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -657.7 | PP–RCT S4 | 20 | 318 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3866.3 | ø20 | 15.4 | TR10.02.0612 | 0612 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13199665 | -1.PP_SO-101 | 25.3999 | 0.0004908 | 0.0019949 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 812.5 | 800 | 800 | 787.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -2359.7 | PP–RCT S4 | 25 | 323 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 25.3999 | ø25 | 19.4 | TR10.02.0613 | 0613 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13199666 | -1.PP_SO-101 | 1654.76 | 0.000314112 | 0.103971 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | -1.PP_SO-101 | 2482.54 | 2482.54 | 827.781 | 827.781 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -2322.22 | PP–RCT S4 | 20 | 318 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1654.76 | ø20 | 15.4 | TR10.02.0614 | 0614 | no | WS_"Jiný typ" studená vnitřní 1
13199712 | 1.NP_SO-101 | 2465.08 | 0.000314112 | 0.154885 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3482.54 | 1017.46 | 3482.54 | 1017.46 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1017.46 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2465.08 | ø20 | 15.4 | TR10.02.0615 | 0615 | no | WS_"Jiný typ" studená vnitřní 1
13199751 | 1.NP_SO-101 | 10.6361 | 0.000314112 | 0.000668287 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 1010 | 1000 | 1000 | 990 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 992.3 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10.6361 | ø20 | 15.4 | TR10.02.0616 | 0616 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13199848 | -1.PP_SO-101 | 5055.53 | 0.0004908 | 0.397061 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | -1.PP_SO-101 | 2512.5 | 2500 | 2500 | 2487.5 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -659.7 | PP–RCT S4 | 25 | 317 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5055.53 | ø25 | 19.4 | TR10.02.0617 | 0617 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13199928 | -1.PP_SO-101 | 601.82 | 0.00950189 | 0.207974 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | 352.062 | 352.062 | -249.758 | -249.758 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 4 | -3399.76 | PP–RCT S4 | 110 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 601.82 | ø110 | 85.4 | TR10.02.0618 | 0618 | yes | SW_Splašky vnitřní gravitační 4
13200209 | -1.PP_SO-101 | 579.279 | 0.00950189 | 0.200184 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | 352.062 | 352.062 | -227.216 | -227.216 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 4 | -3377.22 | PP–RCT S4 | 110 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 579.279 | ø110 | 85.4 | TR10.02.0619 | 0619 | yes | SW_Splašky vnitřní gravitační 4
13216850 | -1.PP_SO-101 | 64.9333 | 0.00950189 | 0.0224393 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | 2876.94 | 2838.05 | 2792.13 | 2753.24 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 10 | -388.062 | PP–RCT S4 | 110 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 64.9333 | ø110 | 85.4 | TR10.02.0652 | 0652 | yes | SW_Splašky vnitřní gravitační 10 | 100
13229444 | 1.NP_SO-101 | 288.473 | 0.000314112 | 0.0181253 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3392.3 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 288.473 | ø20 | 15.4 | TR10.02.0679 | 0679 | no | WS_Studená vnitřní 151 | 0
13229492 | 1.NP_SO-101 | 268.406 | 0.000314112 | 0.0168645 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3410 | 3400 | 3400 | 3390 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3392.3 | PP–RCT S4 | 20 | 102 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 268.406 | ø20 | 15.4 | TR10.02.0680 | 0680 | no | WS_Teplá vnitřní 155 | 0
13231690 | -1.PP_SO-101 | 77.1874 | 0.0019632 | 0.0121246 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2417.09 | 2339.69 | 2416.87 | 2339.46 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -810.486 | PP–RCT S4 | 50 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 77.1874 | ø50 | 38.8 | TR10.02.0681 | 0681 | yes | WS_Teplá vnitřní 155 | 11259.5
13242393 | -1.PP_SO-101 | 78.3469 | 0.0019632 | 0.0123067 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -869.4 | PP–RCT S4 | 50 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.3469 | ø50 | 38.8 | TR10.02.0720 | 0720 | yes | WS_Teplá vnitřní 155 | 0
13242399 | -1.PP_SO-101 | 21248.6 | 0.0019632 | 3.33772 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -869.4 | PP–RCT S4 | 50 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21248.6 | ø50 | 38.8 | TR10.02.0721 | 0721 | yes | WS_Teplá vnitřní 155 | 0
13262368 | -1.PP_SO-101 | 76.9743 | 0.0019632 | 0.0120911 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2416.66 | 2416.66 | 2339.69 | 2339.69 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -810.312 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 76.9743 | ø50 | 38.8 | TR10.02.0726 | 0726 | yes | WS_Studená vnitřní 151
13262371 | -1.PP_SO-101 | 1404.12 | 0.0019632 | 0.220558 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2325 | 2300 | 2300 | 2275 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -869.4 | PP–RCT S4 | 50 | 275 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1404.12 | ø50 | 38.8 | TR10.02.0727 | 0727 | yes | WS_Studená vnitřní 151 | 0
13262760 | -1.PP_SO-101 | 46.025 | 0.000804127 | 0.00462694 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2376.19 | 2376.19 | 2330.16 | 2330.16 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -819.838 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 46.025 | ø32 | 24.8 | TR10.02.0728 | 0728 | yes | WS_Cirkulace vnitřní 2
13262763 | -1.PP_SO-101 | 21197.7 | 0.000804127 | 2.13103 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -862.4 | PP–RCT S4 | 32 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21197.7 | ø32 | 24.8 | TR10.02.0729 | 0729 | yes | WS_Cirkulace vnitřní 2 | 0
13264346 | 2.NP_SO-101 | 2764.68 | 0.000314112 | 0.17371 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2764.68 | ø20 | 15.4 | TR10.02.0730 | 0730 | yes | WS_Studená vnitřní 151 | 0
13264659 | 3.NP_SO-101 | 89.8953 | 0.0004908 | 0.00706036 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.08 | 3449.59 | 3447.79 | 3435.29 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11438.1 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 89.8953 | ø25 | 19.4 | TR10.02.0731 | 0731 | yes | WS_Cirkulace vnitřní 2 | 2
13264670 | 3.NP_SO-101 | 6936.97 | 0.0004908 | 0.544829 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3462.5 | 3450 | 3450 | 3437.5 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11440.3 | PP–RCT S4 | 25 | 153 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6936.97 | ø25 | 19.4 | TR10.02.0732 | 0732 | yes | WS_Teplá vnitřní 155 | 0
13264944 | -1.PP_SO-101 | 2556.83 | 0.000804127 | 0.257041 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.4 | PP–RCT S4 | 32 | 374 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2556.83 | ø32 | 24.8 | TR10.02.0733 | 0733 | yes | WS_Studená vnitřní 151 | 0
13264956 | -1.PP_SO-101 | 6934.45 | 0.000804127 | 0.697127 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2316 | 2300 | 2300 | 2284 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -862.4 | PP–RCT S4 | 32 | 268 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6934.45 | ø32 | 24.8 | TR10.02.0734 | 0734 | yes | WS_Studená vnitřní 151 | 0
13265368 | 2.NP_SO-101 | 125.437 | 0.000314112 | 0.00788142 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7341.47 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.437 | ø20 | 15.4 | TR10.02.0735 | 0735 | no | WS_Teplá vnitřní 155 | 0
13265386 | 2.NP_SO-101 | 49.6404 | 0.000314112 | 0.003119 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 2.NP_SO-101 | 3359.17 | 3349.17 | 3349.17 | 3339.17 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7341.47 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 49.6404 | ø20 | 15.4 | TR10.02.0736 | 0736 | no | WS_Studená vnitřní 151 | 0
13287014 | -1.PP_SO-101 | 1451.5 | 0.00950189 | 0.501601 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | -1636.57 | -1691.56 | -1721.25 | -1776.24 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 8 | -4913.94 | PP–RCT S4 | 110 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1451.5 | ø110 | 85.4 | TR10.02.0789 | 0789 | yes | SW_Splašky vnitřní gravitační 8 | 2.04616
13287508 | -1.PP_SO-101 | 235.827 | 0.00950189 | 0.0814959 | ø110 mm | 0 |  |  | 0.000117096 | G | JD | -1.PP_SO-101 | -1467.49 | -1673.13 | -1506.38 | -1712.03 | SW_Splašky vnitřní gravitační | 0.01 | Sanitární | Trubka Evo, S4 | SW_Splašky vnitřní gravitační 8 | -4853.33 | PP–RCT S4 | 110 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 235.827 | ø110 | 85.4 | TR10.02.0792 | 0792 | yes | SW_Splašky vnitřní gravitační 8 | 100
13309381 | 4.NP_SO-101 | 825.931 | 0.0004908 | 0.0648685 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 4.NP_SO-101 | 2919.16 | 2906.66 | 2906.66 | 2894.16 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 14897 | PP–RCT S4 | 25 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 825.931 | ø25 | 19.4 | TR10.02.0812 | 0812 | no | WS_Studená vnitřní 151 | 0
13373783 | 2.NP_SO-101 | 651.955 | 0.00125645 | 0.0819271 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 2.NP_SO-101 | 3240 | 3220 | 3220 | 3200 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7204.5 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 651.955 | ø40 | 31 | TR10.02.0813 | 0813 | yes | WS_Teplá vnitřní 155 | 0
13374592 | 2.NP_SO-101 | 99.8312 | 0.0019632 | 0.0156815 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3360.31 | 3260.48 | 3360.31 | 3260.48 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7260.48 | PP–RCT S4 | 50 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 99.8312 | ø50 | 38.8 | TR10.02.0816 | 0816 | yes | WS_Teplá vnitřní 155
13374614 | 2.NP_SO-101 | 130.025 | 0.000804127 | 0.0130715 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3369.84 | 3239.81 | 3369.84 | 3239.81 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7239.81 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 130.025 | ø32 | 24.8 | TR10.02.0817 | 0817 | yes | WS_Cirkulace vnitřní 2
13374618 | 2.NP_SO-101 | 558.305 | 0.000804127 | 0.0561269 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3232 | 3216 | 3216 | 3200 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7203.6 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 558.305 | ø32 | 24.8 | TR10.02.0818 | 0818 | yes | WS_Cirkulace vnitřní 2 | 0
13374673 | 2.NP_SO-101 | 296.029 | 0.000804127 | 0.0297601 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3369.84 | 3073.81 | 3369.84 | 3073.81 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7073.81 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 296.029 | ø32 | 24.8 | TR10.02.0819 | 0819 | yes | WS_"Jiný typ" studená vnitřní 1
13374675 | 2.NP_SO-101 | 358.305 | 0.000804127 | 0.0360207 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3066 | 3050 | 3050 | 3034 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7037.6 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 358.305 | ø32 | 24.8 | TR10.02.0820 | 0820 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13375549 | 2.NP_SO-101 | 140.101 | 0.0019632 | 0.022007 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3360.31 | 3220.21 | 3360.31 | 3220.21 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7220.21 | PP–RCT S4 | 50 | 382 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 140.101 | ø50 | 38.8 | TR10.02.0823 | 0823 | yes | WS_Studená vnitřní 151
13377103 | 2.NP_SO-101 | 9.94013 | 0.0004908 | 0.000780696 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3379.36 | 3379.36 | 3369.42 | 3369.42 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 7369.42 | PP–RCT S4 | 25 | 331 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9.94013 | ø25 | 19.4 | TR10.02.0825 | 0825 | yes | WS_"Jiný typ" studená vnitřní 1
13377118 | 2.NP_SO-101 | 3.20386 | 0.000804127 | 0.000322088 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3376.19 | 3376.19 | 3372.98 | 3372.98 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7372.98 | PP–RCT S4 | 32 | 85 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3.20386 | ø32 | 24.8 | TR10.02.0826 | 0826 | yes | WS_Studená vnitřní 151
13377133 | 2.NP_SO-101 | 9.55386 | 0.0004908 | 0.000750359 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 2.NP_SO-101 | 3379.36 | 3379.36 | 3369.81 | 3369.81 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 7369.81 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9.55386 | ø25 | 19.4 | TR10.02.0827 | 0827 | yes | WS_Cirkulace vnitřní 2
13377144 | 2.NP_SO-101 | 3.20386 | 0.000804127 | 0.000322088 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3376.19 | 3376.19 | 3372.98 | 3372.98 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 7372.98 | PP–RCT S4 | 32 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3.20386 | ø32 | 24.8 | TR10.02.0828 | 0828 | yes | WS_Teplá vnitřní 155
13378051 | -1.PP_SO-101 | 336.064 | 0.0019632 | 0.0527889 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2698.75 | 2673.75 | 2673.75 | 2648.75 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -495.654 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.064 | ø50 | 38.8 | TR10.02.0829 | 0829 | yes | WS_Teplá vnitřní 155 | 0
13378079 | -1.PP_SO-101 | 355.131 | 0.000804127 | 0.0357017 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2628.55 | 2612.55 | 2612.55 | 2596.55 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -549.846 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 355.131 | ø32 | 24.8 | TR10.02.0830 | 0830 | yes | WS_Cirkulace vnitřní 2 | 0
13378108 | -1.PP_SO-101 | 336.082 | 0.0019632 | 0.0527916 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2585 | 2560 | 2560 | 2535 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -609.4 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.082 | ø50 | 38.8 | TR10.02.0831 | 0831 | yes | WS_Studená vnitřní 151 | 0
13378138 | -1.PP_SO-101 | 348.782 | 0.00125645 | 0.0438292 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | -1.PP_SO-101 | 2520 | 2500 | 2500 | 2480 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -665.5 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 348.782 | ø40 | 31 | TR10.02.0832 | 0832 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13378845 | 2.NP_SO-101 | 183.472 | 0.00125645 | 0.0230558 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 2.NP_SO-101 | 3201.78 | 3057.9 | 3187.63 | 3043.76 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 7046.94 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 183.472 | ø40 | 31 | TR10.02.0833 | 0833 | yes | WS_Studená vnitřní 151 | 100
13380145 | 1.NP_SO-101 | 452.185 | 0.0019632 | 0.071029 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | -104.478 | -556.663 | -104.478 | -556.663 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -556.663 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 452.185 | ø50 | 38.8 | TR10.02.0834 | 0834 | yes | WS_Studená vnitřní 151 | Identifikační data - Komentáře: V1
13380735 | 1.NP_SO-101 | 1117.88 | 0.000804127 | 0.112382 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3416 | 3400 | 3400 | 3384 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3387.6 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1117.88 | ø32 | 24.8 | TR10.02.0835 | 0835 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13380888 | 1.NP_SO-101 | 309.276 | 0.000804127 | 0.0310918 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3376.19 | 3376.19 | 3066.91 | 3066.91 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3066.91 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 309.276 | ø32 | 24.8 | TR10.02.0836 | 0836 | yes | WS_"Jiný typ" studená vnitřní 1
13380962 | 1.NP_SO-101 | 227.926 | 0.00125645 | 0.028642 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3373.01 | 3373.01 | 3145.09 | 3145.09 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3145.09 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 227.926 | ø40 | 31 | TR10.02.0837 | 0837 | yes | WS_Studená vnitřní 151
13381005 | 1.NP_SO-101 | 165.626 | 0.0004908 | 0.0130082 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3379.36 | 3379.36 | 3213.74 | 3213.74 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3213.74 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 165.626 | ø25 | 19.4 | TR10.02.0838 | 0838 | yes | WS_Cirkulace vnitřní 2
13381039 | 1.NP_SO-101 | 77.9255 | 0.00125645 | 0.00979241 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3373.01 | 3373.01 | 3295.09 | 3295.09 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3295.09 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 77.9255 | ø40 | 31 | TR10.02.0839 | 0839 | yes | WS_Teplá vnitřní 155
13381684 | -1.PP_SO-101 | 116.098 | 0.0019632 | 0.0182367 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2698.75 | 2673.75 | 2673.75 | 2648.75 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -495.654 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 116.098 | ø50 | 38.8 | TR10.02.0843 | 0843 | yes | WS_Teplá vnitřní 155 | 0
13381724 | -1.PP_SO-101 | 197.657 | 0.000804127 | 0.0198706 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2628.62 | 2612.62 | 2612.62 | 2596.62 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -549.781 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 197.657 | ø32 | 24.8 | TR10.02.0844 | 0844 | yes | WS_Cirkulace vnitřní 2 | 0
13381767 | -1.PP_SO-101 | 266.554 | 0.0019632 | 0.0418702 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2585 | 2560 | 2560 | 2535 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -609.4 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 266.554 | ø50 | 38.8 | TR10.02.0845 | 0845 | yes | WS_Studená vnitřní 151 | 0
13381805 | -1.PP_SO-101 | 354.742 | 0.00125645 | 0.0445781 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | -1.PP_SO-101 | 2520 | 2500 | 2500 | 2480 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -665.5 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 354.742 | ø40 | 31 | TR10.02.0846 | 0846 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13381910 | -1.PP_SO-101 | 157.071 | 0.0019632 | 0.0246727 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2640.41 | 2483.34 | 2640.41 | 2483.34 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -666.663 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 157.071 | ø50 | 38.8 | TR10.02.0848 | 0848 | yes | WS_Teplá vnitřní 155
13381919 | -1.PP_SO-101 | 164.994 | 0.000804127 | 0.016587 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | -1.PP_SO-101 | 2588.81 | 2423.81 | 2588.81 | 2423.81 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -726.188 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 164.994 | ø32 | 24.8 | TR10.02.0849 | 0849 | yes | WS_Cirkulace vnitřní 2
13381928 | -1.PP_SO-101 | 43.325 | 0.0019632 | 0.00680548 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | -1.PP_SO-101 | 2526.66 | 2483.34 | 2526.66 | 2483.34 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -666.662 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 43.325 | ø50 | 38.8 | TR10.02.0850 | 0850 | yes | WS_Studená vnitřní 151
13382779 | 1.NP_SO-101 | 521.64 | 0.00125645 | 0.0655512 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | -101.372 | -623.013 | -101.372 | -623.013 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -623.013 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 521.64 | ø40 | 31 | TR10.02.0852 | 0852 | yes | WS_"Jiný typ" studená vnitřní 1
13382869 | 1.NP_SO-101 | 48.3535 | 0.00125645 | 0.00607628 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | -33.9561 | -82.2893 | -48.0982 | -96.4314 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -93.2494 | PP–RCT S4 | 40 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 48.3535 | ø40 | 31 | TR10.02.0853 | 0853 | yes | WS_"Jiný typ" studená vnitřní 1 | 100
13382908 | 1.NP_SO-101 | 43.093 | 0.0019632 | 0.00676903 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | -32.7554 | -50.4331 | -80.9044 | -98.5821 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -94.6223 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 43.093 | ø50 | 38.8 | TR10.02.0854 | 0854 | yes | WS_Studená vnitřní 151 | 100
13382937 | 1.NP_SO-101 | 50.9838 | 0.000804127 | 0.00512545 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | -48.2944 | -59.6081 | -95.659 | -106.973 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | -104.427 | PP–RCT S4 | 32 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 50.9838 | ø32 | 24.8 | TR10.02.0855 | 0855 | yes | WS_Cirkulace vnitřní 2 | 100
13382964 | 1.NP_SO-101 | 43.093 | 0.0019632 | 0.00676903 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | -36.8738 | -54.5515 | -85.0228 | -102.7 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -98.7407 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 43.093 | ø50 | 38.8 | TR10.02.0856 | 0856 | yes | WS_Teplá vnitřní 155 | 100
13383248 | 1.NP_SO-101 | 2.68959 | 0.00125645 | 0.000337984 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3370 | 3350 | 3350 | 3330 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3334.5 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2.68959 | ø40 | 31 | TR10.02.0862 | 0862 | yes | WS_Teplá vnitřní 155 | 0
13383257 | 1.NP_SO-101 | 3341.29 | 0.0019632 | 0.524849 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3310.31 | -30.9783 | 3310.31 | -30.9783 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | -30.9783 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3341.29 | ø50 | 38.8 | TR10.02.0863 | 0863 | yes | WS_Teplá vnitřní 155
13383352 | 2.NP_SO-101 | 3976.97 | 0.0019632 | 0.624702 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3366.66 | -610.312 | 3366.66 | -610.312 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3389.69 | PP–RCT S4 | 50 | 147 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3976.97 | ø50 | 38.8 | TR10.02.0864 | 0864 | yes | WS_Teplá vnitřní 155
13383369 | 1.NP_SO-101 | 27.9255 | 0.00125645 | 0.00350923 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3323.01 | 3295.09 | 3323.01 | 3295.09 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3295.09 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 27.9255 | ø40 | 31 | TR10.02.0865 | 0865 | yes | WS_Teplá vnitřní 155
13383418 | 1.NP_SO-101 | 23.3271 | 0.0004908 | 0.00183211 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3287.5 | 3275 | 3275 | 3262.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3265.3 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 23.3271 | ø25 | 19.4 | TR10.02.0866 | 0866 | yes | WS_Cirkulace vnitřní 2 | 0
13383427 | 2.NP_SO-101 | 4071.02 | 0.000804127 | 0.409264 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 2.NP_SO-101 | 3376.19 | -694.837 | 3376.19 | -694.837 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3305.16 | PP–RCT S4 | 32 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4071.02 | ø32 | 24.8 | TR10.02.0867 | 0867 | yes | WS_Cirkulace vnitřní 2
13383507 | 1.NP_SO-101 | 40.6255 | 0.0004908 | 0.00319072 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3254.36 | 3213.74 | 3254.36 | 3213.74 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3213.74 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 40.6255 | ø25 | 19.4 | TR10.02.0868 | 0868 | yes | WS_Cirkulace vnitřní 2
13383537 | 1.NP_SO-101 | 2.53334 | 0.00125645 | 0.000318349 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3220 | 3200 | 3200 | 3180 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3184.5 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2.53334 | ø40 | 31 | TR10.02.0869 | 0869 | yes | WS_Studená vnitřní 151 | 0
13383623 | 1.NP_SO-101 | 27.9255 | 0.00125645 | 0.00350923 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3173.01 | 3145.09 | 3173.01 | 3145.09 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3145.09 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 27.9255 | ø40 | 31 | TR10.02.0870 | 0870 | yes | WS_Studená vnitřní 151
13383650 | 1.NP_SO-101 | 23.4708 | 0.000804127 | 0.00235955 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3141 | 3125 | 3125 | 3109 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3112.6 | PP–RCT S4 | 32 | 345 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 23.4708 | ø32 | 24.8 | TR10.02.0871 | 0871 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13383722 | 1.NP_SO-101 | 27.9255 | 0.000804127 | 0.00280738 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3094.84 | 3066.91 | 3094.84 | 3066.91 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3066.91 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 27.9255 | ø32 | 24.8 | TR10.02.0872 | 0872 | yes | WS_"Jiný typ" studená vnitřní 1
13384275 | 1.NP_SO-101 | 3187.17 | 0.0019632 | 0.50064 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 1.NP_SO-101 | 3160.31 | -26.8599 | 3160.31 | -26.8599 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | -26.8599 | PP–RCT S4 | 50 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3187.17 | ø50 | 38.8 | TR10.02.0873 | 0873 | yes | WS_Studená vnitřní 151 | Identifikační data - Komentáře: V1
13384289 | 2.NP_SO-101 | 4126.97 | 0.0019632 | 0.648264 | ø50 mm | 0 | 0 | Laminární | 0.000257732 | F | JB | 2.NP_SO-101 | 3366.66 | -760.312 | 3366.66 | -760.312 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3239.69 | PP–RCT S4 | 50 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4126.97 | ø50 | 38.8 | TR10.02.0874 | 0874 | yes | WS_Studená vnitřní 151 | Identifikační data - Komentáře: V1
13384975 | 1.NP_SO-101 | 340.517 | 0.00125645 | 0.0427907 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3288.1 | 3268.1 | 3268.1 | 3248.1 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3252.6 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 340.517 | ø40 | 31 | TR10.02.0875 | 0875 | yes | WS_Teplá vnitřní 155 | 0
13384977 | 1.NP_SO-101 | 6.025 | 0.00125645 | 0.000757124 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3288.1 | 3268.1 | 3268.1 | 3248.1 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 3252.6 | PP–RCT S4 | 40 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6.025 | ø40 | 31 | TR10.02.0876 | 0876 | yes | WS_Teplá vnitřní 155 | 0
13385037 | 1.NP_SO-101 | 428.217 | 0.0004908 | 0.0336321 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3205.6 | 3193.1 | 3193.1 | 3180.6 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3183.4 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 428.217 | ø25 | 19.4 | TR10.02.0877 | 0877 | yes | WS_Cirkulace vnitřní 2 | 0
13385041 | 1.NP_SO-101 | 98.725 | 0.0004908 | 0.00775384 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 1.NP_SO-101 | 3205.6 | 3193.1 | 3193.1 | 3180.6 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 3183.4 | PP–RCT S4 | 25 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 98.725 | ø25 | 19.4 | TR10.02.0878 | 0878 | yes | WS_Cirkulace vnitřní 2 | 0
13385070 | 1.NP_SO-101 | 490.517 | 0.00125645 | 0.0616402 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3138.1 | 3118.1 | 3118.1 | 3098.1 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3102.6 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 490.517 | ø40 | 31 | TR10.02.0879 | 0879 | yes | WS_Studená vnitřní 151 | 0
13385072 | 1.NP_SO-101 | 186.025 | 0.00125645 | 0.0233766 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 1.NP_SO-101 | 3138.1 | 3118.1 | 3118.1 | 3098.1 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 3102.6 | PP–RCT S4 | 40 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 186.025 | ø40 | 31 | TR10.02.0880 | 0880 | yes | WS_Studená vnitřní 151 | 0
13385106 | 1.NP_SO-101 | 571.867 | 0.000804127 | 0.0574904 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3059.1 | 3043.1 | 3043.1 | 3027.1 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3030.7 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 571.867 | ø32 | 24.8 | TR10.02.0881 | 0881 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13385108 | 1.NP_SO-101 | 251.437 | 0.000804127 | 0.0252773 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 1.NP_SO-101 | 3059.1 | 3043.1 | 3043.1 | 3027.1 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3030.7 | PP–RCT S4 | 32 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 251.437 | ø32 | 24.8 | TR10.02.0882 | 0882 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13385268 | 1.NP_SO-101 | 5893.34 | 0.000314112 | 0.370289 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3510 | 3500 | 3500 | 3490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3492.3 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5893.34 | ø20 | 15.4 | TR10.02.0883 | 0883 |  | WS_"Jiný typ" studená vnitřní 1 | 0
13385379 | 1.NP_SO-101 | 318.644 | 0.000314112 | 0.020021 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3482.54 | 3482.54 | 3163.89 | 3163.89 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3163.89 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 318.644 | ø20 | 15.4 | TR10.02.0884 | 0884 |  | WS_"Jiný typ" studená vnitřní 1
13385381 | 1.NP_SO-101 | 83.1598 | 0.000314112 | 0.00522508 | ø20 mm | 0 | 0 | Laminární | 0.000649351 | F | JB | 1.NP_SO-101 | 3510 | 3500 | 3500 | 3490 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3492.3 | PP–RCT S4 | 20 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 83.1598 | ø20 | 15.4 | TR10.02.0885 | 0885 |  | WS_"Jiný typ" studená vnitřní 1 | 0
13425322 | 3.NP_SO-101 | 1255.52 | 0.00125645 | 0.157773 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11651.2 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1255.52 | ø40 | 31 | TR10.02.0886 | 0886 | yes | WS_Teplá vnitřní 155 | 0
13425329 | 3.NP_SO-101 | 1367.11 | 0.000804127 | 0.137437 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11654.3 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1367.11 | ø32 | 24.8 | TR10.02.0887 | 0887 | yes | WS_Cirkulace vnitřní 2 | 0
13425447 | 3.NP_SO-101 | 1449.59 | 0.00125645 | 0.182161 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3686.66 | 3666.66 | 3666.66 | 3646.66 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11651.2 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1449.59 | ø40 | 31 | TR10.02.0888 | 0888 | yes | WS_Studená vnitřní 151 | 0
13425477 | 3.NP_SO-101 | 1562.34 | 0.000804127 | 0.157064 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3682.66 | 3666.66 | 3666.66 | 3650.66 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11654.3 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1562.34 | ø32 | 24.8 | TR10.02.0889 | 0889 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13428364 | 3.NP_SO-101 | 162.688 | 0.00125645 | 0.0204439 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3639.68 | 3639.68 | 3476.99 | 3476.99 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11477 | PP–RCT S4 | 40 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 162.688 | ø40 | 31 | TR10.02.0891 | 0891 | yes | WS_Teplá vnitřní 155
13428401 | 3.NP_SO-101 | 169.038 | 0.000804127 | 0.0169935 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3642.85 | 3642.85 | 3473.81 | 3473.81 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11473.8 | PP–RCT S4 | 32 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 169.038 | ø32 | 24.8 | TR10.02.0892 | 0892 | yes | WS_Cirkulace vnitřní 2
13428434 | 3.NP_SO-101 | 162.688 | 0.00125645 | 0.0204439 | ø40 mm | 0 | 0 | Laminární | 0.000322581 | F | JB | 3.NP_SO-101 | 3639.68 | 3639.68 | 3476.99 | 3476.99 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11477 | PP–RCT S4 | 40 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 162.688 | ø40 | 31 | TR10.02.0893 | 0893 | yes | WS_Studená vnitřní 151
13428467 | 3.NP_SO-101 | 169.038 | 0.000804127 | 0.0169935 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3642.85 | 3642.85 | 3473.81 | 3473.81 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11473.8 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 169.038 | ø32 | 24.8 | TR10.02.0894 | 0894 | yes | WS_"Jiný typ" studená vnitřní 1
13428607 | 3.NP_SO-101 | 446.129 | 0.000804127 | 0.0448498 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3666 | 3650 | 3650 | 3634 | WS_"ŠEDÁ" studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11637.6 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 446.129 | ø32 | 24.8 | TR10.02.0896 | 0896 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13428645 | 3.NP_SO-101 | 456.245 | 0.000804127 | 0.0458668 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3666 | 3650 | 3650 | 3634 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11637.6 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 456.245 | ø32 | 24.8 | TR10.02.0897 | 0897 | yes | WS_Studená vnitřní 151 | 0
13428669 | 3.NP_SO-101 | 462.852 | 0.0004908 | 0.0363523 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3662.5 | 3650 | 3650 | 3637.5 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11640.3 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 462.852 | ø25 | 19.4 | TR10.02.0898 | 0898 | yes | WS_Cirkulace vnitřní 2 | 0
13428779 | 3.NP_SO-101 | 476.06 | 0.000804127 | 0.0478588 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3666 | 3650 | 3650 | 3634 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11637.6 | PP–RCT S4 | 32 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 476.06 | ø32 | 24.8 | TR10.02.0899 | 0899 | yes | WS_Teplá vnitřní 155 | 0
13428912 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3626.19 | 3626.19 | 3473.81 | 3473.81 | WS_Teplá vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 155 | 11473.8 | PP–RCT S4 | 32 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0902 | 0902 | yes | WS_Teplá vnitřní 155
13428951 | 3.NP_SO-101 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | 0 | Laminární | 0.000515464 | F | JB | 3.NP_SO-101 | 3629.36 | 3629.36 | 3470.64 | 3470.64 | WS_Cirkulace vnitřní | 0.01 | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 2 | 11470.6 | PP–RCT S4 | 25 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.02.0903 | 0903 | yes | WS_Cirkulace vnitřní 2
13428986 | 3.NP_SO-101 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | 0 | Laminární | 0.000403226 | F | JB | 3.NP_SO-101 | 3626.19 | 3626.19 | 3473.81 | 3473.81 | WS_Studená vnitřní | 0.01 | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 151 | 11473.8 | PP–RCT S4 | 32 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.02.0904 | 0904 | yes | WS_Studená vnitřní 151
