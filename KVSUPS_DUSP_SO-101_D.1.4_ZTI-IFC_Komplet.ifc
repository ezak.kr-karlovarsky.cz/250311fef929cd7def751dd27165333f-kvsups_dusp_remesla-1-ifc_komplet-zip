Properties of the parts of a building model (IFC4), part 14 of 26

# IfcPipeFitting: M_Koleno, obecné:Standardní (577)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | CCI Funkční systém | CCI Komponenta | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13053264 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0044 | 0044 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13053276 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0045 | 0045 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13053449 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0047 | 0047 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13053472 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0048 | 0048 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13053480 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0049 | 0049 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13053492 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0050 | 0050 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13053627 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0053 | 0053 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13053637 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0054 | 0054 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13053645 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0055 | 0055 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13054094 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0057 | 0057 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13054104 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0058 | 0058 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13054193 | 4.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0059 | 0059 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13054217 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0060 | 0060 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13054265 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0062 | 0062 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13054277 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0063 | 0063 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13054389 | 4.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0065 | 0065 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13054465 | 4.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0067 | 0067 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13054469 | 4.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 4.NP_SO-101 | 2906.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0068 | 0068 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13054826 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0077 | 0077 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13055320 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0078 | 0078 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13055408 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0079 | 0079 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13055418 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0080 | 0080 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13055545 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0081 | 0081 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13055555 | 3.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 3.NP_SO-101 | 3666.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0082 | 0082 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13055702 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0083 | 0083 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13056098 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0085 | 0085 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13056276 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0088 | 0088 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13056284 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0089 | 0089 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13056360 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0090 | 0090 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13056415 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0091 | 0091 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13056479 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0092 | 0092 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13056504 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0094 | 0094 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13056512 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0095 | 0095 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13056569 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0096 | 0096 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13056577 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0097 | 0097 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13056601 | 3.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0098 | 0098 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13056917 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0103 | 0103 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13056943 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0104 | 0104 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13057121 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0106 | 0106 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13057246 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0109 | 0109 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13057307 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0110 | 0110 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13057437 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0112 | 0112 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13057489 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0114 | 0114 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13057515 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0115 | 0115 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13058046 | 3.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0125 | 0125 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13058127 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0133 | 0133 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13058976 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 2.NP_SO-101 | 3348.92 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0140 | 0140 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13058986 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 2.NP_SO-101 | 3348.92 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0141 | 0141 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13059053 | 2.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 2.NP_SO-101 | 3348.92 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0142 | 0142 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13059177 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0144 | 0144 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13059203 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0145 | 0145 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059419 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0149 | 0149 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059498 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0151 | 0151 | yes | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059535 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0152 | 0152 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059570 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0153 | 0153 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059625 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0154 | 0154 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059659 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0156 | 0156 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059700 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0157 | 0157 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059792 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0159 | 0159 | yes | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059804 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0160 | 0160 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059812 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0161 | 0161 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059824 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0162 | 0162 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13059924 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0163 | 0163 | yes | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059934 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0164 | 0164 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059942 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0165 | 0165 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059954 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0166 | 0166 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13059978 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0167 | 0167 | yes | 17.4625 | 11.1125 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060010 | 2.NP_SO-101 | ø15 mm-ø15 mm | F | WPA | JB | 2.NP_SO-101 | 580 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.02.0169 | 0169 | no | 14.2875 | 7.9375 | WS_Studená vnitřní 151 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060066 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0171 | 0171 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060093 | 2.NP_SO-101 | ø15 mm-ø15 mm | F | WPA | JB | 2.NP_SO-101 | 580 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.02.0173 | 0173 | no | 14.2875 | 7.9375 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060136 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0175 | 0175 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060375 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0188 | 0188 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13060439 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0190 | 0190 | yes | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13060447 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0191 | 0191 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13060457 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0192 | 0192 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13060465 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0193 | 0193 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13060647 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0195 | 0195 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13060657 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0196 | 0196 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13060665 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0197 | 0197 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13060689 | 2.NP_SO-101 | ø16 mm-ø16 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.02.0198 | 0198 | yes | 15.9375 | 9.5875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13060801 | 2.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 2.NP_SO-101 | 3349.17 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0201 | 0201 | yes | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13061453 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0212 | 0212 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 155
13061478 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0214 | 0214 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13061486 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0215 | 0215 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13061606 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0217 | 0217 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061616 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0218 | 0218 | yes | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061628 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0219 | 0219 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061693 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0220 | 0220 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 155
13061768 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0222 | 0222 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13061776 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0223 | 0223 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13061851 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0224 | 0224 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13061928 | 1.NP_SO-101 | ø40 mm-ø40 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0225 | 0225 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 151
13061953 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0227 | 0227 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13061961 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0228 | 0228 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 151
13062090 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0231 | 0231 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13062100 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0232 | 0232 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13062108 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0233 | 0233 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13062118 | 1.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0234 | 0234 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13062208 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0235 | 0235 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13062291 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0237 | 0237 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13062327 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0239 | 0239 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13062446 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0240 | 0240 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13062561 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0241 | 0241 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13062571 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0242 | 0242 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13062622 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0243 | 0243 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13062632 | 1.NP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0244 | 0244 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13062721 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0247 | 0247 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13062796 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0248 | 0248 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13062834 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0250 | 0250 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13062893 | 1.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0251 | 0251 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13064061 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0272 | 0272 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13064136 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0273 | 0273 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 151
13064178 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0276 | 0276 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13064245 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0277 | 0277 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 155
13064769 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0286 | 0286 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13072292 | 4.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 4.NP_SO-101 | 2848.34 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0302 | 0302 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13072910 | 3.NP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | 3.NP_SO-101 | 3450 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0305 | 0305 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13094102 | 4.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 4.NP_SO-101 | 2973.69 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0306 | 0306 | no | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13101711 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1686.21 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0308 | 0308 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13101755 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1768.76 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0310 | 0310 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13101806 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1383.77 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0311 | 0311 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13119437 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1770.88 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.0000942639 | 4.69406 | 8.53077 | ø110-ø110 | 3.37636 | 113.175 | TT01.02.0312 | 0312 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13119614 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1768.38 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.0000816034 | 4.06172 | 7.38501 | ø110-ø110 | 2.92153 | 113.175 | TT01.02.0313 | 0313 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13119669 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1835.88 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000106442 | 5.30321 | 9.6329 | ø110-ø110 | 3.81452 | 113.175 | TT01.02.0314 | 0314 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13119804 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1831.71 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.0000937818 | 4.66996 | 8.48714 | ø110-ø110 | 3.35903 | 113.175 | TT01.02.0315 | 0315 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13120260 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1707.18 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0317 | 0317 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13120264 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1815.93 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0318 | 0318 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13120305 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1365.42 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0319 | 0319 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13120336 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1076.01 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0320 | 0320 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81
13120536 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1835.88 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000115101 | 5.73689 | 10.4165 | ø110-ø110 | 4.12646 | 113.175 | TT01.02.0321 | 0321 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13120772 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1832.66 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.00010244 | 5.10293 | 9.27072 | ø110-ø110 | 3.67046 | 113.175 | TT01.02.0322 | 0322 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125593 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1130 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0323 | 0323 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125638 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1130 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.00049731 | 26.0733 | 45.0057 | ø110-ø110 | 18.7541 | 113.175 | TT01.02.0324 | 0324 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125688 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1130 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0325 | 0325 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125711 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1130 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0326 | 0326 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125715 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1130 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0327 | 0327 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13125797 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1560.62 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0328 | 0328 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13125830 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1598.3 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0330 | 0330 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13126038 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1557.1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0333 | 0333 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13126164 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1685.4 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0334 | 0334 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13126199 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1734.69 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0336 | 0336 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13126209 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1702.27 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 8 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0337 | 0337 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 8
13126335 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1638.73 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.0339 | 0339 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13126423 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1397.45 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0340 | 0340 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13126427 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -1612.35 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 81 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0341 | 0341 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 81 | Mechanické – tok - Tlaková ztráta: 0 Pa
13128400 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1655.24 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0349 | 0349 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13128452 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.00000314086 | 4.12234 | 26.5651 | ø20-ø20 | 2.09864 | 22.225 | TT01.02.0350 | 0350 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13128456 | -1.PP_SO-101 | ø20 mm-ø20 mm | F | WPA | JB | -1.PP_SO-101 | 1730 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.00000314086 | 4.12234 | 26.5651 | ø20-ø20 | 2.09864 | 22.225 | TT01.02.0351 | 0351 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13128460 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0352 | 0352 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13128464 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1730 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0353 | 0353 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13128468 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0354 | 0354 | no | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13128472 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1730 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0355 | 0355 | no | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13128512 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.00000613603 | 4.87185 | 26.5651 | ø25-ø25 | 2.69826 | 28.575 | TT01.02.0356 | 0356 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13129761 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2927.48 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.0357 | 0357 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13129779 | -1.PP_SO-101 | ø135 mm-ø135 mm | G | WPA | JD | -1.PP_SO-101 | 2809.3 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.0358 | 0358 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13131685 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3629.9 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0363 | 0363 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13131689 | 1.NP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | 1.NP_SO-101 | 3490.63 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.0364 | 0364 | no | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13132408 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -496.002 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0365 | 0365 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13132432 | -1.PP_SO-101 | ø110 mm-ø110 mm | G | WPA | JD | -1.PP_SO-101 | -496.002 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0366 | 0366 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13133755 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2387.77 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0368 | 0368 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13133766 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2354.89 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0369 | 0369 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13133780 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2339.8 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0370 | 0370 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13134148 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2380.8 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0375 | 0375 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13134827 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2539.23 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0380 | 0380 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135058 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2801.48 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0383 | 0383 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13135472 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2599.71 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0385 | 0385 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13135498 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2584.94 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0386 | 0386 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13135509 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2576.78 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0387 | 0387 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13135601 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2564.33 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0388 | 0388 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10
13135687 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2707.65 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.0389 | 0389 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135749 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2603.21 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0391 | 0391 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135760 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2582.53 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0392 | 0392 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135777 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2573.9 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0393 | 0393 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135787 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2558.45 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0394 | 0394 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13135797 | -1.PP_SO-101 | ø78 mm-ø78 mm | G | WPA | JD | -1.PP_SO-101 | 2551.15 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 10 | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.0395 | 0395 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148636 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0399 | 0399 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 151
13148673 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0402 | 0402 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 155
13148920 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0405 | 0405 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13156689 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0406 | 0406 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 1
13156694 | -1.PP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0407 | 0407 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13157941 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0410 | 0410 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13157988 | 2.NP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 151 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0411 | 0411 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 151
13158102 | 2.NP_SO-101 | ø50 mm-ø50 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 155 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0412 | 0412 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 155
13158213 | 2.NP_SO-101 | ø32 mm-ø32 mm | F | WPA | JB | 2.NP_SO-101 | 3400 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0413 | 0413 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13158792 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | -1.PP_SO-101 | 2500 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000228662 | 10.5366 | 45 | ø35-ø35 | 6.32504 | 38.175 | TT01.02.0423 | 0423 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13160489 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 1.NP_SO-101 | 3400 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0425 | 0425 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13160491 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 1.NP_SO-101 | 3404.31 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0426 | 0426 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13160550 | -1.PP_SO-101 | ø35 mm-ø35 mm | F | WPA | JB | -1.PP_SO-101 | 2450 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.0000228662 | 10.5366 | 45 | ø35-ø35 | 6.32504 | 38.175 | TT01.02.0427 | 0427 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13161467 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 1.NP_SO-101 | 3404.31 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0430 | 0430 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13161586 | 1.NP_SO-101 | ø28 mm-ø28 mm | F | WPA | JB | 1.NP_SO-101 | 1510 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0431 | 0431 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13161825 | -1.PP_SO-101 | ø25 mm-ø25 mm | F | WPA | JB | -1.PP_SO-101 | 1860 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0432 | 0432 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 1
