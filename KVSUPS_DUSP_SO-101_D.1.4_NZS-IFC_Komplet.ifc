Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: ba96069a-c86b-42a3-bff1-a6077f433c49, NumberOfSaves: 71], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-13T16:52:05
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject
Phase: SpD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: S0 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.11 02:39

# IfcBuilding, Budova E
LongName: Budova E
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: S0 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.11 02:39

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-101
In: Budova E
LongName: 2.NP_SO-101; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-101
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:38
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (4)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:37
1.NP_SO-101 | 1.NP_SO-101 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:37
3.NP_SO-101 | 3.NP_SO-101 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:38
4.NP_SO-101 | 4.NP_SO-101 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:38

# IfcBuildingElementProxy: Mikrofonní pult.CC:Mikrofonní pult.CC (3)
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes
Type - Kóty - Šířka: 100 mm; Výška pultu: 40 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ03; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Sound and Signal Devices; Název typu: Mikrofonní pult.CC; Označení typu: 02; Popis: Mikrofonní pult; Popis sestavy: Mikrofonní pult; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; a: 22.2222 mm; b: 35 mm; c: 25 mm; Název rodiny: Mikrofonní pult.CC
Classification: NZ03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0903264 m2; NetVolume: 0.000664421 m3
Text - CCI Funkční systém: P; CCI Komponenta: BXA; CCI Technický systém: MA
Vazby - Podlaží: 3.NP_SO-101; Hostitel: Podlaží : 3.NP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000664421 m3
Jiné - Id typu: 667903; Rodina: Mikrofonní pult.CC; Rodina a typ: Mikrofonní pult.CC: Mikrofonní pult.CC; Typ: Mikrofonní pult.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:43
Name (Mikrofonní pult.CC:Mikrofonní pult.CC:...) | Kód prvku | Označení
667919 | NZ03.02.0081 | 0081
667927 | NZ03.02.0082 | 0082
667931 | NZ03.02.0083 | 0083

# IfcBuildingElementProxy: Reproduktory.CC:Nástěnný reproduktor hranatý (106)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor nástěnný.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: nástěnný, hranatý; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Nástěnný reproduktor hranatý; Označení typu: 01; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_nástěnný_hranatý.CC : Nástěnný reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.1076 m2; NetVolume: 0.0021655 m3
Text - CCI Funkční systém: P; CCI Komponenta: PJA; CCI Technický systém: MA
Vazby - Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 100 mm; Objem: 0.0021655 m3; Průměr reproduktoru: 150 mm
Jiné - a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 40 mm; g: 10 mm; h: 5 mm; Id typu: 665585; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina: Reproduktory.CC; Rodina a typ: Reproduktory.CC: Nástěnný reproduktor hranatý; Typ: Nástěnný reproduktor hranatý; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:43
Name (Reproduktory.CC:Nástěnný reproduktor hranatý:...) | In | Hostitel | Podlaží | Kód prvku | Označení
665609 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0001 | 0001
665613 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0002 | 0002
665661 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0003 | 0003
665665 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0004 | 0004
665669 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0005 | 0005
665673 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0006 | 0006
665677 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0007 | 0007
665681 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0008 | 0008
665685 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0009 | 0009
665689 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0010 | 0010
665693 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0011 | 0011
665697 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0012 | 0012
665725 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0013 | 0013
665729 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0014 | 0014
665737 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0015 | 0015
665741 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0016 | 0016
666302 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0017 | 0017
666306 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0018 | 0018
666310 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0019 | 0019
666328 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0020 | 0020
666332 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0021 | 0021
666336 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0022 | 0022
666340 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0023 | 0023
666419 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0024 | 0024
666423 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0025 | 0025
666427 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0026 | 0026
666431 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0027 | 0027
666435 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0028 | 0028
666439 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0029 | 0029
666443 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0030 | 0030
666447 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0031 | 0031
666451 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0032 | 0032
666455 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0033 | 0033
666462 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0034 | 0034
666466 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0035 | 0035
666470 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0036 | 0036
666474 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0037 | 0037
666478 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0038 | 0038
666482 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0039 | 0039
666486 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0040 | 0040
666490 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0041 | 0041
666497 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0042 | 0042
666501 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0043 | 0043
666505 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0044 | 0044
666509 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0045 | 0045
666513 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0046 | 0046
666517 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0047 | 0047
666521 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0048 | 0048
666525 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0049 | 0049
666529 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0050 | 0050
666533 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0051 | 0051
666537 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0052 | 0052
666541 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0053 | 0053
666545 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0054 | 0054
666549 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0055 | 0055
666553 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0056 | 0056
666557 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0057 | 0057
666561 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | NZ04.01.0058 | 0058
666568 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0059 | 0059
666572 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0060 | 0060
666576 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0061 | 0061
666580 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0062 | 0062
666584 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0063 | 0063
666588 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0064 | 0064
666592 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0065 | 0065
666596 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0066 | 0066
666600 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0067 | 0067
666604 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0068 | 0068
666608 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0069 | 0069
666612 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0070 | 0070
666616 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0071 | 0071
666620 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0072 | 0072
666624 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0073 | 0073
666628 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0074 | 0074
666632 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0075 | 0075
666636 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0076 | 0076
666640 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0077 | 0077
666644 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0078 | 0078
666648 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0079 | 0079
666652 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0080 | 0080
667941 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0084 | 0084
667945 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0085 | 0085
667949 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0086 | 0086
667953 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0087 | 0087
667957 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0088 | 0088
667961 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0089 | 0089
667965 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0090 | 0090
667969 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0091 | 0091
667973 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0092 | 0092
667977 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0093 | 0093
667981 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0094 | 0094
667985 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0095 | 0095
667989 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0096 | 0096
667998 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | NZ04.01.0097 | 0097
668011 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0098 | 0098
668015 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0099 | 0099
668019 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0100 | 0100
668023 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0101 | 0101
668031 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0102 | 0102
668045 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0104 | 0104
668052 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0105 | 0105
668070 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | NZ04.01.0106 | 0106
668197 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0107 | 0107
668215 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1.NP_SO-101 | NZ04.01.0108 | 0108
668222 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0109 | 0109
668226 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | NZ04.01.0110 | 0110

# IfcBuildingElementProxy: Reproduktory.CC:Nástěnný reproduktor kulatý, Reproduktory.CC:Nástěnný reproduktor kulatý:668038
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor nástěnný.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: nástěnný, kulatý; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Nástěnný reproduktor kulatý; Označení typu: 03; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_nástěnný_kulatý.CC : Nástěnný reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0844863 m2; NetVolume: 0.00170042 m3
Text - CCI Funkční systém: P; CCI Komponenta: PJA; CCI Technický systém: MA
Vazby - Podlaží: -1.PP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 100 mm; Objem: 0.00170042 m3; Průměr reproduktoru: 150 mm
Identifikační data - Kód prvku: NZ04.03.0103; Označení: 0103
Jiné - Rodina: Reproduktory.CC; a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 40 mm; g: 10 mm; h: 5 mm; Id typu: 665575; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina a typ: Reproduktory.CC: Nástěnný reproduktor kulatý; Typ: Nástěnný reproduktor kulatý; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:44

# IfcDistributionPort (110)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: VENTILATION
Name
Port_665609_1
Port_665613_1
Port_665661_1
Port_665665_1
Port_665669_1
Port_665673_1
Port_665677_1
Port_665681_1
Port_665685_1
Port_665689_1
Port_665693_1
Port_665697_1
Port_665725_1
Port_665729_1
Port_665737_1
Port_665741_1
Port_666302_1
Port_666306_1
Port_666310_1
Port_666328_1
Port_666332_1
Port_666336_1
Port_666340_1
Port_666419_1
Port_666423_1
Port_666427_1
Port_666431_1
Port_666435_1
Port_666439_1
Port_666443_1
Port_666447_1
Port_666451_1
Port_666455_1
Port_666462_1
Port_666466_1
Port_666470_1
Port_666474_1
Port_666478_1
Port_666482_1
Port_666486_1
Port_666490_1
Port_666497_1
Port_666501_1
Port_666505_1
Port_666509_1
Port_666513_1
Port_666517_1
Port_666521_1
Port_666525_1
Port_666529_1
Port_666533_1
Port_666537_1
Port_666541_1
Port_666545_1
Port_666549_1
Port_666553_1
Port_666557_1
Port_666561_1
Port_666568_1
Port_666572_1
Port_666576_1
Port_666580_1
Port_666584_1
Port_666588_1
Port_666592_1
Port_666596_1
Port_666600_1
Port_666604_1
Port_666608_1
Port_666612_1
Port_666616_1
Port_666620_1
Port_666624_1
Port_666628_1
Port_666632_1
Port_666636_1
Port_666640_1
Port_666644_1
Port_666648_1
Port_666652_1
Port_667919_1
Port_667927_1
Port_667931_1
Port_667941_1
Port_667945_1
Port_667949_1
Port_667953_1
Port_667957_1
Port_667961_1
Port_667965_1
Port_667969_1
Port_667973_1
Port_667977_1
Port_667981_1
Port_667985_1
Port_667989_1
Port_667998_1
Port_668011_1
Port_668015_1
Port_668019_1
Port_668023_1
Port_668031_1
Port_668038_1
Port_668045_1
Port_668052_1
Port_668070_1
Port_668197_1
Port_668215_1
Port_668222_1
Port_668226_1
