Properties of the parts of a building model (IFC4), part 2 of 5

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.1:662493
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.3A.1; Označení typu: 10; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: 3.NP_SO-101; Hostitel: Podlaží : 3.NP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.10.0010; Označení: 0010
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662105; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.3A.1; Typ: Rozvaděč NN - RP.3A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.2:662457
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.3A.2; Označení typu: 09; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Hostitel: Podlaží : 3.NP_SO-101; Odsazení od hostitele: 600 mm; Podlaží: 3.NP_SO-101; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.09.0009; Označení: 0009
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662107; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.3A.2; Typ: Rozvaděč NN - RP.3A.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.4A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.4A.1:662555
In: 4.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 600 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.4A.1; Označení typu: 12; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.34 m2; NetVolume: 0.18 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: 4.NP_SO-101; Hostitel: Podlaží : 4.NP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.18 m3; Plocha: 1.17 m2
Identifikační data - Kód prvku: RV00.12.0012; Označení: 0012
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662109; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.4A.1; Typ: Rozvaděč NN - RP.4A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.4A.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.4A.2:662544
In: 4.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 400 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1800 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.4A.2; Označení typu: 11; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.96 m2; NetVolume: 0.576 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 4.NP_SO-101; Podlaží: 4.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.576 m3; Plocha: 2.48 m2
Identifikační data - Kód prvku: RV00.11.0011; Označení: 0011
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662111; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.4A.2; Typ: Rozvaděč NN - RP.4A.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Uzemnění.CC:Uzemnění.CC (20)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Další; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Geometrie: yes
Type - Kóty - HLOUBKA: 100 mm; ŠÍŘKA: 100 mm; VÝŠKA: 100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EJ00; Komentáře k typům: Uzěmňovací bod; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Uzemnění.CC; Označení typu: 18; Popis: Uzemnění; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 0; Název rodiny: Uzemnění.CC; Typ symbolu: Symbol_Uzemnění.CC
Classification: EJ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.06 m2; NetVolume: 0.001 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QCA; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Symbol: yes; Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.001 m3
Jiné - Id typu: 711953; Rodina: Uzemnění.CC; Rodina a typ: Uzemnění.CC: Uzemnění.CC; Typ: Uzemnění.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:15
Name (Uzemnění.CC:Uzemnění.CC:...) | In | Podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Hostitel | Kód prvku | Označení
711979 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | EJ00.18.0582 | 0582
711984 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | EJ00.18.0583 | 0583
711992 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0584 | 0584
711997 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0585 | 0585
712002 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0586 | 0586
712007 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0587 | 0587
712020 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0588 | 0588
712025 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0589 | 0589
712086 | -1.PP_SO-101 | -1.PP_SO-101 | 1200 | Podlaží : -1.PP_SO-101 | EJ00.18.0593 | 0593
712091 | -1.PP_SO-101 | -1.PP_SO-101 | 1200 | Podlaží : -1.PP_SO-101 | EJ00.18.0594 | 0594
734414 | 1.NP_SO-101 | 1.NP_SO-101 | 3500 | Podlaží : 1.NP_SO-101 | EJ00.18.0617 | 0617
735473 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | EJ00.18.0624 | 0624
735478 | 4.NP_SO-101 | 4.NP_SO-101 | 0 | Podlaží : 4.NP_SO-101 | EJ00.18.0625 | 0625
738011 | -1.PP_SO-101 | -1.PP_SO-101 | 1200 | Podlaží : -1.PP_SO-101 | EJ00.18.0654 | 0654
738021 | -1.PP_SO-101 | -1.PP_SO-101 | 1200 | Podlaží : -1.PP_SO-101 | EJ00.18.0655 | 0655
738033 | -1.PP_SO-101 | -1.PP_SO-101 | 1200 | Podlaží : -1.PP_SO-101 | EJ00.18.0656 | 0656
738283 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0669 | 0669
738288 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0670 | 0670
738293 | 1.NP_SO-101 | 1.NP_SO-101 | 0 | Podlaží : 1.NP_SO-101 | EJ00.18.0671 | 0671
739637 | 2.NP_SO-101 | 2.NP_SO-101 | 0 | Podlaží : 2.NP_SO-101 | EJ00.18.0681 | 0681

# IfcBuildingElementProxy: Vypínač_230V.CC:Stmívač pro ovládání DALI předřadníků vč. výkonového prvku (43)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1200 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Stmivac pro ovládání DALI.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, pro ovládání DALI předřadníků vč. výkonového prvku; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Stmívač pro ovládání DALI předřadníků vč. výkonového prvku; Označení typu: 07; Popis: Stmívač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268862; Rodina a typ: Vypínač_230V.CC: Stmívač pro ovládání DALI předřadníků vč. výkonového prvku; Typ: Stmívač pro ovládání DALI předřadníků vč. výkonového prvku; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:00
Name (Vypínač_230V.CC:Stmívač pro ovládání DALI předřadníků vč. výkonového prvku:...) | In | Podlaží | Hostitel | Kód prvku | Označení
681906 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0031 | 0031
681915 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0032 | 0032
681920 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0033 | 0033
681925 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0034 | 0034
681930 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0035 | 0035
681935 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0036 | 0036
681944 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0037 | 0037
681949 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0038 | 0038
681954 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.07.0039 | 0039
681993 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0042 | 0042
681998 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0043 | 0043
682003 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0044 | 0044
682008 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0045 | 0045
682013 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0046 | 0046
682018 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0047 | 0047
682023 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0048 | 0048
682028 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.07.0049 | 0049
704392 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0091 | 0091
704397 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0092 | 0092
704402 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0093 | 0093
704407 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0094 | 0094
704412 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0095 | 0095
704417 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0096 | 0096
704422 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0097 | 0097
704427 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0098 | 0098
704432 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0099 | 0099
704437 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0100 | 0100
704442 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0101 | 0101
704447 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0102 | 0102
704452 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.07.0103 | 0103
707618 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.07.0121 | 0121
707623 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.07.0122 | 0122
707628 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.07.0123 | 0123
707633 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.07.0124 | 0124
707638 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.07.0125 | 0125
716578 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0159 | 0159
716583 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0160 | 0160
716588 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0161 | 0161
716593 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0162 | 0162
716598 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0163 | 0163
716603 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0164 | 0164
735709 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0175 | 0175
735736 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | VY01.07.0176 | 0176

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.1 IP44 (19)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač 230V řaz.1, IP44.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.1, IP44; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.1 IP44; Označení typu: 08; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268836; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.1 IP44; Typ: Vypínač řaz.1 IP44; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:00
Name (Vypínač_230V.CC:Vypínač řaz.1 IP44:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
716244 | 1200 | VY01.08.0129 | 0129
716249 | 1200 | VY01.08.0130 | 0130
716288 | 0 | VY01.08.0135 | 0135
716293 | 0 | VY01.08.0136 | 0136
716475 | 0 | VY01.08.0149 | 0149
716480 | 0 | VY01.08.0150 | 0150
716490 | 0 | VY01.08.0151 | 0151
716495 | 0 | VY01.08.0152 | 0152
716541 | 0 | VY01.08.0154 | 0154
716546 | 0 | VY01.08.0155 | 0155
716551 | 0 | VY01.08.0156 | 0156
716556 | 0 | VY01.08.0157 | 0157
735766 | 0 | VY01.08.0177 | 0177
738074 | 1200 | VY01.08.0179 | 0179
738079 | 0 | VY01.08.0180 | 0180
738084 | 1200 | VY01.08.0181 | 0181
738089 | 1200 | VY01.08.0182 | 0182
738104 | 0 | VY01.08.0183 | 0183
738109 | 0 | VY01.08.0184 | 0184

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.1, IP20 (14)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1200 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač 230V řaz.1, IP20.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.1, IP20; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.1, IP20; Označení typu: 04; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268834; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.1, IP20; Typ: Vypínač řaz.1, IP20; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:00
Name (Vypínač_230V.CC:Vypínač řaz.1, IP20:...) | In | Podlaží | Hostitel | Kód prvku | Označení
681872 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.04.0026 | 0026
681877 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.04.0027 | 0027
681962 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.04.0040 | 0040
681975 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.04.0041 | 0041
682056 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.04.0050 | 0050
682061 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.04.0051 | 0051
682070 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.04.0052 | 0052
704460 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.04.0104 | 0104
704465 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.04.0105 | 0105
704470 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | VY01.04.0106 | 0106
707028 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.04.0120 | 0120
707646 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.04.0126 | 0126
707651 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.04.0127 | 0127
707656 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | VY01.04.0128 | 0128

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.1, IP44 na povrch (6)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač 230V řaz.1, IP44 na povrch.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.1, IP44 na povrch; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.1, IP44 na povrch; Označení typu: 09; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268832; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.1, IP44 na povrch; Typ: Vypínač řaz.1, IP44 na povrch; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:01
Name (Vypínač_230V.CC:Vypínač řaz.1, IP44 na povrch:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
716564 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1200 | VY01.09.0158 | 0158
737917 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY01.09.0178 | 0178
738234 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY01.09.0186 | 0186
738239 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY01.09.0187 | 0187
739645 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | VY01.09.0192 | 0192
739725 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | VY01.09.0193 | 0193

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.5, IP44, Vypínač_230V.CC:Vypínač řaz.5, IP44:681898
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač řaz.5, IP44.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.5, IP44; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.5, IP44; Označení typu: 06; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Dvojtlačítko: yes; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Identifikační data - Kód prvku: VY01.06.0030; Označení: 0030
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268844; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.5, IP44; Typ: Vypínač řaz.5, IP44; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:01

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.6, IP20 (6)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1200 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač řaz.6, IP20.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.6, IP20; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.6, IP20; Označení typu: 05; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268842; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.6, IP20; Typ: Vypínač řaz.6, IP20; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:01
Name (Vypínač_230V.CC:Vypínač řaz.6, IP20:...) | In | Podlaží | Hostitel | Kód prvku | Označení
681885 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.05.0028 | 0028
681890 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.05.0029 | 0029
682100 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.05.0053 | 0053
682105 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | VY01.05.0054 | 0054
739221 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.05.0190 | 0190
739226 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | VY01.05.0191 | 0191

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.6, IP44 (4)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač řaz.6, IP44.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.6, IP44; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.6, IP44; Označení typu: 03; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Id typu: 268848; Rodina: Vypínač_230V.CC; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.6, IP44; Typ: Vypínač řaz.6, IP44; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:01
Name (Vypínač_230V.CC:Vypínač řaz.6, IP44:...) | Kód prvku | Označení
681849 | VY01.03.0022 | 0022
681854 | VY01.03.0023 | 0023
681859 | VY01.03.0024 | 0024
681864 | VY01.03.0025 | 0025

# IfcBuildingElementProxy: Vypínač_230V.CC:Vypínač řaz.6, IP44 na povrch (2)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ Smybolu: Vypínač řaz.6, IP44 (na povrch).CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 25 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY01; Komentáře k typům: 230V, řaz.6, IP44 (na povrch); Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: Vypínač řaz.6, IP44 na povrch; Označení typu: 10; Popis: Vypínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlení; dojklapka: no; Dvojtlačítko: no; FAKTOR ÚČINNOSTI: 0; jednoklapka: no; Název rodiny: Vypínač_230V.CC
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03664 m2; NetVolume: 0.0002633 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QAB; CCI Technický systém: HH
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0002633 m3
Jiné - Rodina: Vypínač_230V.CC; Id typu: 268850; Rodina a typ: Vypínač_230V.CC: Vypínač řaz.6, IP44 na povrch; Typ: Vypínač řaz.6, IP44 na povrch; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:01
Name (Vypínač_230V.CC:Vypínač řaz.6, IP44 na povrch:...) | Kód prvku | Označení
738362 | VY01.10.0188 | 0188
738367 | VY01.10.0189 | 0189

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 1x (88)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 300 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 1x; Označení typu: 13; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 1; P2: 0 mm; P3: 0 mm; P4: 0 mm; P5: 0 mm; ST: 0 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.01125 m2; NetVolume: 0.000021875 m3
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000021875 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 331379; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 1x; S: 80 mm; Typ: Vícerámečky - 1x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 1x:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
671876 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0142 | 0142
671886 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0143 | 0143
671921 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0144 | 0144
671956 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 300 | MT00.13.0145 | 0145
672004 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0146 | 0146
672016 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0147 | 0147
672119 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 300 | MT00.13.0148 | 0148
672193 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 300 | MT00.13.0149 | 0149
672372 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 300 | MT00.13.0150 | 0150
672466 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0151 | 0151
672491 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0152 | 0152
672533 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0153 | 0153
672552 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0154 | 0154
672619 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0155 | 0155
672768 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0156 | 0156
672813 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0157 | 0157
672918 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0158 | 0158
673027 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0159 | 0159
673095 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0160 | 0160
673136 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0161 | 0161
673187 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0162 | 0162
673234 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0163 | 0163
673330 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 900 | MT00.13.0164 | 0164
673373 | 1.NP_SO-101 | 1.NP_SO-101 | Osamocené | 900 | MT00.13.0165 | 0165
679137 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0189 | 0189
679201 | 1.NP_SO-101 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0191 | 0191
689524 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0335 | 0335
689533 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0336 | 0336
689574 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0337 | 0337
689616 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0338 | 0338
689665 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0339 | 0339
689784 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0340 | 0340
689851 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0341 | 0341
689953 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0342 | 0342
690043 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0343 | 0343
690114 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0344 | 0344
690174 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0345 | 0345
690327 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0346 | 0346
690386 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0347 | 0347
690499 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0348 | 0348
690662 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0349 | 0349
690778 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0350 | 0350
690812 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0351 | 0351
695980 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0383 | 0383
695989 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0384 | 0384
696109 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0385 | 0385
696166 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0386 | 0386
696234 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0387 | 0387
696274 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0388 | 0388
696354 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0389 | 0389
696462 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0390 | 0390
696468 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0391 | 0391
696568 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0392 | 0392
696646 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0393 | 0393
696678 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0394 | 0394
696707 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0395 | 0395
696744 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0396 | 0396
696760 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0397 | 0397
696783 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0398 | 0398
696842 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0399 | 0399
696860 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0400 | 0400
696926 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0401 | 0401
696950 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0402 | 0402
703717 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0487 | 0487
703727 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0488 | 0488
704566 | 3.NP_SO-101 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0501 | 0501
705382 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 300 | MT00.13.0537 | 0537
705398 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0538 | 0538
705520 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0539 | 0539
705637 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0540 | 0540
705684 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0541 | 0541
705778 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0542 | 0542
707045 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0558 | 0558
707059 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0559 | 0559
707153 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0560 | 0560
709311 | -1.PP_SO-101 | -1.PP_SO-101 | Osamocené | 300 | MT00.13.0570 | 0570
709318 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0571 | 0571
709370 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0572 | 0572
709646 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0573 | 0573
709869 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0574 | 0574
709922 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0575 | 0575
709981 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0576 | 0576
710145 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0577 | 0577
710226 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0578 | 0578
710429 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0579 | 0579
712059 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 900 | MT00.13.0590 | 0590
715698 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0604 | 0604
715704 | -1.PP_SO-101 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.13.0605 | 0605

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 3x (2)
In: 3.NP_SO-101
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 3x; Označení typu: 17; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P4: 0 mm; P5: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 3; P2: 71 mm; P3: 142 mm; ST: 71 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.02909 m2; NetVolume: 0.000058425 m3
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Vazby - Podlaží: 3.NP_SO-101; Vztažné podlaží: 3.NP_SO-101; Hostitel: Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt; Výška od podlaží: 1100 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000058425 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 360411; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 3x; S: 222 mm; Typ: Vícerámečky - 3x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 3x:...) | Kód prvku | Označení
697090 | MT00.17.0403 | 0403
697118 | MT00.17.0404 | 0404

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 4x (6)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 300 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 4x; Označení typu: 15; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P5: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 4; P2: 71 mm; P3: 142 mm; P4: 213 mm; ST: 106.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03801 m2; NetVolume: 0.0000767 m3
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000767 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 361876; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 4x; S: 293 mm; Typ: Vícerámečky - 4x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 4x:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
685929 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2536.9 | MT00.15.0291 | 0291
685937 | 2.NP_SO-101 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2556.9 | MT00.15.0292 | 0292
705918 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.15.0543 | 0543
705924 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 300 | MT00.15.0544 | 0544
706161 | 4.NP_SO-101 | 4.NP_SO-101 | Osamocené | 300 | MT00.15.0545 | 0545
744782 | 4.NP_SO-101 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2600 | MT00.15.0759 | 0759

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 5x (3)
In: 1.NP_SO-101
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 5x; Označení typu: 01; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: Vícerámečky, vodovné.CC; P: 5; P2: 71 mm; P3: 142 mm; P4: 213 mm; P5: 284 mm; P6: 0 mm; ST: 142 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.04693 m2; NetVolume: 0.000094975 m3
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000094975 m3
Jiné - Id typu: 362928; Rodina: Vícerámečky, vodovné.CC; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 5x; S: 364 mm; Typ: Vícerámečky - 5x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:17
Name (Vícerámečky, vodovné.CC:Vícerámečky - 5x:...) | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
662850 | Osamocené | 2556.94 | MT00.01.0001 | 0001
665807 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2656.94 | MT00.01.0029 | 0029
670058 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2556.94 | MT00.01.0104 | 0104

# IfcBuildingElementProxy: Vývod.CC:Vývod 230V T3 ukončený v krabici (2)
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 2250 mm
Type - Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 230 V
Type - Grafika - Typ symbolu: Vývod 230V ukončený v krabic T3.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 230V, T3, ukončený v krabici; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod 230V T3 ukončený v krabici; Označení typu: 11; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vývod.CC
Classification: KB00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0114775 m2; NetVolume: 0.0000268875 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Napájení
Text - CCI Funkční systém: K; CCI Komponenta: XDD; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 2250 mm; Výška od podlaží: 2250 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000268875 m3
Jiné - Rodina: Vývod.CC; Id typu: 272098; Rodina a typ: Vývod.CC: Vývod 230V T3 ukončený v krabici; Typ: Vývod 230V T3 ukončený v krabici; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18
Name (Vývod.CC:Vývod 230V T3 ukončený v krabici:...) | In | Podlaží | Hostitel | Kód prvku | Označení
671828 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | KB00.11.0139 | 0139
704625 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | KB00.11.0505 | 0505

# IfcBuildingElementProxy: Vývod.CC:Vývod 230V ukončený v krabici (47)
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 230 V
Type - Grafika - Typ symbolu: Vývod 230V ukončený v krabici.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 230V, ukončený v krabici; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod 230V ukončený v krabici; Označení typu: 03; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vývod.CC
Classification: KB00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0114775 m2; NetVolume: 0.0000268875 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Napájení
Text - CCI Funkční systém: K; CCI Komponenta: XDD; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000268875 m3
Jiné - Id typu: 272096; Rodina: Vývod.CC; Rodina a typ: Vývod.CC: Vývod 230V ukončený v krabici; Typ: Vývod 230V ukončený v krabici; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18
Name (Vývod.CC:Vývod 230V ukončený v krabici:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
665696 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0023 | 0023
665716 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 579.797 | KB00.03.0024 | 0024
665728 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0025 | 0025
665740 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0026 | 0026
665752 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0027 | 0027
665772 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0028 | 0028
666546 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1250 | KB00.03.0035 | 0035
669406 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | KB00.03.0065 | 0065
669414 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | KB00.03.0066 | 0066
669428 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0067 | 0067
669438 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | KB00.03.0068 | 0068
669456 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0069 | 0069
669466 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | KB00.03.0070 | 0070
669476 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0071 | 0071
669484 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0072 | 0072
669492 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0073 | 0073
669500 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0074 | 0074
669508 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0075 | 0075
669516 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0076 | 0076
669532 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0077 | 0077
669548 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0078 | 0078
669556 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0079 | 0079
669564 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0080 | 0080
669572 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 750 | KB00.03.0081 | 0081
671503 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 600 | KB00.03.0127 | 0127
671517 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0128 | 0128
671525 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0129 | 0129
671537 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0130 | 0130
671549 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0131 | 0131
671570 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0132 | 0132
671582 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0133 | 0133
671594 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0134 | 0134
671606 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0135 | 0135
671618 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0136 | 0136
733635 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | KB00.03.0611 | 0611
733643 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | KB00.03.0612 | 0612
733651 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | KB00.03.0613 | 0613
733659 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2650 | KB00.03.0614 | 0614
735608 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2650 | KB00.03.0626 | 0626
738132 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 600 | KB00.03.0658 | 0658
738140 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 600 | KB00.03.0659 | 0659
