Properties of the parts of a building model (IFC4), part 4 of 5

# IfcBuildingElementProxy: Zásuvka 230V_vícerámečky.CC:Zásuvka jednoduchá 230V , IP20 (431)
Name (Zásuvka 230V_vícerámečky.CC:Zásuvka jednoduchá 230V , IP20:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení | UPRAVIL
706252 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0549 | 0549 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706277 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0550 | 0550 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706433 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0551 | 0551 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706467 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0552 | 0552 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706504 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0553 | 0553 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706558 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0554 | 0554 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706778 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0555 | 0555 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706813 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0556 | 0556 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706836 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0557 | 0557 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
707225 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0561 | 0561 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
707234 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0562 | 0562 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
707592 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0563 | 0563 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
707684 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0564 | 0564 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
707694 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0565 | 0565 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
708098 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0566 | 0566 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
708289 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0567 | 0567 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
709195 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0568 | 0568 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
709232 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0569 | 0569 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
712209 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0595 | 0595 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
712223 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0596 | 0596 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
712606 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0597 | 0597 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
712909 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0598 | 0598 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
712955 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0599 | 0599 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
713181 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0600 | 0600 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
713577 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0601 | 0601 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
714002 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0602 | 0602 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
714420 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0603 | 0603 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
715841 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0606 | 0606 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
715858 | -1.PP_SO-101 | -1.PP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0607 | 0607 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
738051 | -1.PP_SO-101 | -1.PP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0657 | 0657 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739871 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0682 | 0682 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739872 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0683 | 0683 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739873 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0684 | 0684 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739874 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0685 | 0685 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739914 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0686 | 0686 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739915 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0687 | 0687 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739916 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0688 | 0688 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
739917 | 3.NP_SO-101 | 3.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0689 | 0689 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740107 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0702 | 0702 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740108 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0703 | 0703 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740109 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0704 | 0704 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740110 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0705 | 0705 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740494 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0706 | 0706 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740495 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0707 | 0707 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740513 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0708 | 0708 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740514 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0709 | 0709 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740515 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0710 | 0710 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740521 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0711 | 0711 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740522 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0712 | 0712 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740523 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0713 | 0713 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740529 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0714 | 0714 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740530 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0715 | 0715 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740531 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0716 | 0716 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740537 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0717 | 0717 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740538 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0718 | 0718 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740539 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0719 | 0719 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740545 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0720 | 0720 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740546 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0721 | 0721 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740547 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0722 | 0722 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740553 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0723 | 0723 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740554 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0724 | 0724 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740555 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0725 | 0725 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740561 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0726 | 0726 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740562 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0727 | 0727 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740563 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0728 | 0728 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740569 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0729 | 0729 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740570 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0730 | 0730 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740571 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0731 | 0731 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:52
740698 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0732 | 0732 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740699 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0733 | 0733 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740700 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0734 | 0734 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740813 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0735 | 0735 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740814 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0736 | 0736 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740815 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0737 | 0737 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740822 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0738 | 0738 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740823 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0739 | 0739 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740824 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0740 | 0740 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740831 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0741 | 0741 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740832 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0742 | 0742 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740833 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0743 | 0743 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740839 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0744 | 0744 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740840 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0745 | 0745 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740841 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0746 | 0746 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740847 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0747 | 0747 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740848 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0748 | 0748 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740849 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0749 | 0749 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740855 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0750 | 0750 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740856 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0751 | 0751 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740857 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0752 | 0752 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740863 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0753 | 0753 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740864 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0754 | 0754 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740865 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0755 | 0755 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740871 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0756 | 0756 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740872 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0757 | 0757 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
740873 | 4.NP_SO-101 | 4.NP_SO-101 | <nepřiřazeno> | 810 | ZZ01.04.0758 | 0758 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
744825 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2600 | ZZ01.04.0760 | 0760 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
744836 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2600 | ZZ01.04.0761 | 0761 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745033 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0764 | 0764 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745034 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0765 | 0765 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745035 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0766 | 0766 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745042 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0767 | 0767 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745043 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0768 | 0768 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745044 | 4.NP_SO-101 | 4.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 810 | ZZ01.04.0769 | 0769 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745071 | 3.NP_SO-101 | 3.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0770 | 0770 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745078 | 3.NP_SO-101 | 3.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0771 | 0771 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745150 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0772 | 0772 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745157 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0773 | 0773 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745164 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0774 | 0774 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745170 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0775 | 0775 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745176 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0776 | 0776 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
745182 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 300 | ZZ01.04.0777 | 0777 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
766250 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 752.5 | ZZ01.04.0779 | 0779 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
766252 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 752.5 | ZZ01.04.0780 | 0780 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51

# IfcBuildingElementProxy: Zásuvka_230V.CC:Zásuvka IP20 (74)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W; TYP ZAŘÍZENÍ: Další
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1100 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ symbolu: Zásuvka 230V IP20.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 30 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ01; Komentáře k typům: Zásuvka IP20 230 V; Nadpis OmniClass: Receptacle Terminal Units; Název typu: Zásuvka IP20; Označení typu: 12; Popis: Zásuvka; Popis sestavy: 230 V; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Zásuvka_230V.CC
Classification: ZZ01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0363416 m2; NetVolume: 0.000137732 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Rámeček: yes
Kóty - Objem: 0.000137732 m3
Jiné - Id typu: 641739; Rodina: Zásuvka_230V.CC; Rodina a typ: Zásuvka_230V.CC: Zásuvka IP20; Typ: Zásuvka IP20; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:53
Name (Zásuvka_230V.CC:Zásuvka IP20:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
671851 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2250 | ZZ01.12.0140 | 0140
671856 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2250 | ZZ01.12.0141 | 0141
683207 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0193 | 0193
683212 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0194 | 0194
683217 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0195 | 0195
683222 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0196 | 0196
683227 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0197 | 0197
683232 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0198 | 0198
683237 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0199 | 0199
683242 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0200 | 0200
683247 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0201 | 0201
683252 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0202 | 0202
683257 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0203 | 0203
683262 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0204 | 0204
683267 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0205 | 0205
683272 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0206 | 0206
683277 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0207 | 0207
683282 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0208 | 0208
683287 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0209 | 0209
683292 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0210 | 0210
683297 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0211 | 0211
683302 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0212 | 0212
683307 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0213 | 0213
683312 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0214 | 0214
683317 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0215 | 0215
683322 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0216 | 0216
683327 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0217 | 0217
683332 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0218 | 0218
683337 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0219 | 0219
683342 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0220 | 0220
683347 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0221 | 0221
683352 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0222 | 0222
683357 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0223 | 0223
683362 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0224 | 0224
683367 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0225 | 0225
683372 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0226 | 0226
683377 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0227 | 0227
683382 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 750 | ZZ01.12.0228 | 0228
704612 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2250 | ZZ01.12.0503 | 0503
704617 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 2250 | ZZ01.12.0504 | 0504
710760 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0580 | 0580
710765 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0581 | 0581
712070 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0591 | 0591
712075 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0592 | 0592
737929 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0648 | 0648
737934 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0649 | 0649
737942 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0650 | 0650
737947 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0651 | 0651
737957 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0652 | 0652
737962 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 900 | ZZ01.12.0653 | 0653
738201 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0663 | 0663
738206 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0664 | 0664
738211 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0665 | 0665
738216 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0666 | 0666
738221 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0667 | 0667
738226 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1100 | ZZ01.12.0668 | 0668
739535 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1100 | ZZ01.12.0678 | 0678
739540 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1100 | ZZ01.12.0679 | 0679
739545 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1100 | ZZ01.12.0680 | 0680
740012 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0690 | 0690
740017 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0691 | 0691
740022 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0692 | 0692
740027 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0693 | 0693
740032 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0694 | 0694
740037 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0695 | 0695
740042 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0696 | 0696
740047 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0697 | 0697
740052 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0698 | 0698
740057 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0699 | 0699
740062 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0700 | 0700
740067 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 1100 | ZZ01.12.0701 | 0701
744893 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | ZZ01.12.0762 | 0762
744898 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3000 | ZZ01.12.0763 | 0763
745201 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1100 | ZZ01.12.0778 | 0778

# IfcBuildingElementProxy: Zásuvka_400V.CC:Zásuvka 400V, IP44 (3)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; TYP ZAŘÍZENÍ: Další; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Grafika - Typ symbolu: Zásuvka 400V, IP44.CC
Type - Kóty - Délka: 125 mm; Šířka: 80 mm; Výška: 100 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ02; Komentáře k typům: Zásuvka 400V, IP44; Nadpis OmniClass: Receptacle Terminal Units; Název typu: Zásuvka 400V, IP44; Označení typu: 21; Popis: Zásuvka; Popis sestavy: 400 V; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; na stěnu: yes; na strop: no; Název rodiny: Zásuvka_400V.CC
Classification: ZZ02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0894606 m2; NetVolume: 0.000881681 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: XBB; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Rámeček: yes; Horizontální: no
Kóty - Objem: 0.000881681 m3
Jiné - Id typu: 737866; Rodina: Zásuvka_400V.CC; Rodina a typ: Zásuvka_400V.CC: Zásuvka 400V, IP44; Typ: Zásuvka 400V, IP44; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:54
Name (Zásuvka_400V.CC:Zásuvka 400V, IP44:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
737884 | 1500 | ZZ02.21.0647 | 0647
738188 | 0 | ZZ02.21.0661 | 0661
738193 | 0 | ZZ02.21.0662 | 0662

# IfcCableCarrierFitting: Bleskosvod_Svorka křížová s mezideskou.CC:FeZN, Bleskosvod_Svorka křížová s mezideskou.CC:FeZN:403095
In: -1.PP_SO-101
Type - Material: Podpěra pro vedení FeZN
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: Podpěra pro vedení FeZN
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: BL03; Model: SK+1; Název typu: FeZN; Označení typu: 02; Popis: Svorka křížova + mezideska; Popis sestavy: Svorka; Version: 1.0; Výrobce: Tremis; Značka prvku hromosvodu: SK
Type - Jiné - Kategorie: Tvarovky elektroinstalační trubky; Název rodiny: Bleskosvod_Svorka křížová s mezideskou.CC
Classification: BL03 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: XEF; CCI Technický systém: PD
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: -215 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.0000508809 m3; Průměr: 16 mm; Velikost: 16 mmø-16 mmø-16 mmø-16 mmø
Identifikační data - Kód prvku: BL03.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Id typu: 387745; RN: 8 mm; Rodina: Bleskosvod_Svorka křížová s mezideskou.CC; Rodina a typ: Bleskosvod_Svorka křížová s mezideskou.CC: FeZN; Typ: FeZN; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:07

# IfcCableCarrierFitting: Bleskosvod_spoj-svár.CC:Standard, Bleskosvod_spoj-svár.CC:Standard:400963
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: BL03; Nadpis OmniClass: Conduits; Název typu: Standard; Označení typu: 01; Popis sestavy: Svorka; Version: 1.0
Type - Jiné - Kategorie: Tvarovky elektroinstalační trubky; Název rodiny: Bleskosvod_spoj-svár.CC
Classification: BL03 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: XEF; CCI Technický systém: PD
Vazby - Podlaží: -1.PP_SO-101; Výška od podlaží: -215 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - DÉLKA: 22.56 mm; Objem: 0.00000832693 m3; Poloměr ohybu: 20 mm; Průmer: 16 mm; Úhel: 90 deg; Velikost: 16 mmø-16 mmø
Identifikační data - Kód prvku: BL03.01.0001; Označení: 0001
Jiné - Bend Radius Label: 20 mm; Délka: 5 mm; Id typu: 400294; Ohyb nebo tvarovka: Ohyb; Páteřní trasa: yes; RN: 8 mm; Rodina: Bleskosvod_spoj-svár.CC; Rodina a typ: Bleskosvod_spoj-svár.CC: Standard; SK: 25 mm; Typ: Standard; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:07

# IfcCableCarrierFitting: Parapetní žlab_Koleno:Standardní (2)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Kód sestavy: KT01; Název typu: Standardní; Označení typu: 01; Popis sestavy: Oblouk žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Parapetní žlab_Koleno
Classification: KT01 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Úhel: 90 deg; Délka lávky: 100 mm; Objem: 0.0020305 m3; Poloměr ohybu: 131 mm; Šířka lávky: 62 mm; Tloušťka: 2.54 mm; Velikost: 62 mmx125 mmø-62 mmx125 mmø; Výška lávky: 125 mm
Jiné - Páteřní trasa: yes; Délka 1: 131 mm; Délka 2: 102.54 mm; Délka 3: 56.92 mm; Id typu: 15977; Max. úhel segmentace: 90 deg; Odsazení: 62.5 mm; Ohyb nebo tvarovka: Tvarovka; Rodina: Parapetní žlab_Koleno; Rodina a typ: Parapetní žlab_Koleno: Standardní; Štítek poloměru ohybu: 131 mm; Typ: Standardní
Name (Parapetní žlab_Koleno:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
683871 | 2.NP_SO-101 | 2.NP_SO-101 | 1050 | KT01.01.0001 | 0001 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
769087 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | KT01.01.0045 | 0045

# IfcCableCarrierFitting: Žlab_Horizontální koleno:Standard (62)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.17; Kód sestavy: KT03; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: Standard; Označení typu: 02; Popis sestavy: Přechod žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Žlab_Horizontální koleno
Classification: KT03 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Angle: 90 deg; Tray Length: 5 mm
Jiné - Páteřní trasa: yes; Typ: Standard; Ohyb nebo tvarovka: Tvarovka; Id typu: 15956; Rodina: Žlab_Horizontální koleno; Rodina a typ: Žlab_Horizontální koleno: Standard
Name (Žlab_Horizontální koleno:Standard:...) | In | Podlaží | Výška od podlaží (mm) | Objem (m3) | Poloměr ohybu (mm) | Tloušťka (mm) | Tray Height (mm) | Tray Width (mm) | Velikost | Kód prvku | Označení | Bend Radius Label (mm) | Center to End (mm)
762555 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.000639012 | 25 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0002 | 0002 | 75 | 80
762656 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.000639012 | 25 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0003 | 0003 | 75 | 80
762862 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.000639012 | 25 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0004 | 0004 | 75 | 80
762863 | 2.NP_SO-101 | 2.NP_SO-101 | 750 | 0.000639012 | 25 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0005 | 0005 | 75 | 80
764562 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0008 | 0008 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
764612 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0009 | 0009 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765001 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0010 | 0010 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765045 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0012 | 0012 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765046 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0013 | 0013 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765047 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0014 | 0014 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765203 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0015 | 0015 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765313 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00122809 | 100 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0016 | 0016 | 150 | 155
765359 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00122809 | 100 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0017 | 0017 | 150 | 155 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765522 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000639012 | 25 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0018 | 0018 | 75 | 80
765523 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0019 | 0019 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765962 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0020 | 0020 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
765963 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0021 | 0021 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766475 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0022 | 0022 | 125 | 130
766555 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0023 | 0023 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766616 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0024 | 0024 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766687 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.00103175 | 75 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0025 | 0025 | 125 | 130 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766688 | 1.NP_SO-101 | 1.NP_SO-101 | 750 | 0.000835381 | 50 | 2.54 | 50 | 100 | 100 mmx50 mmø-100 mmx50 mmø | KT03.02.0026 | 0026 | 100 | 105 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
767324 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0028 | 0028 | 34.175 | 39.175
767392 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0029 | 0029 | 34.175 | 39.175
767435 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0030 | 0030 | 34.175 | 39.175
767707 | 2.NP_SO-101 | 2.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0031 | 0031 | 34.175 | 39.175
767988 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0032 | 0032 | 36.175 | 41.175
768055 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0033 | 0033 | 36.175 | 41.175
768182 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0034 | 0034 | 36.175 | 41.175
768451 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0035 | 0035 | 36.175 | 41.175
768455 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0036 | 0036 | 36.175 | 41.175
768465 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0037 | 0037 | 36.175 | 41.175
768466 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0038 | 0038 | 36.175 | 41.175
768469 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0039 | 0039 | 36.175 | 41.175
768547 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0040 | 0040 | 36.175 | 41.175
768636 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0041 | 0041 | 36.175 | 41.175
768815 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0042 | 0042 | 34.175 | 39.175
768905 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0043 | 0043 | 34.175 | 39.175
768950 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0044 | 0044 | 34.175 | 39.175
769289 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0046 | 0046 | 34.175 | 39.175
769290 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0047 | 0047 | 34.175 | 39.175
769291 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0048 | 0048 | 34.175 | 39.175
769321 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.5 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0049 | 0049 | 34.175 | 39.175
769380 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0050 | 0050 | 34.175 | 39.175
769517 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0051 | 0051 | 34.175 | 39.175
769644 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0052 | 0052 | 34.175 | 39.175
769645 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0053 | 0053 | 34.175 | 39.175
769758 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0054 | 0054 | 34.175 | 39.175
769759 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0055 | 0055 | 34.175 | 39.175
769822 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0056 | 0056 | 34.175 | 39.175
769849 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0057 | 0057 | 34.175 | 39.175
769850 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0058 | 0058 | 34.175 | 39.175
770048 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0059 | 0059 | 34.175 | 39.175
770049 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0060 | 0060 | 34.175 | 39.175
770277 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0061 | 0061 | 34.175 | 39.175
770342 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0062 | 0062 | 34.175 | 39.175
770343 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0063 | 0063 | 34.175 | 39.175
770437 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0064 | 0064 | 34.175 | 39.175
770438 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0065 | 0065 | 34.175 | 39.175
770456 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000493444 | 2 | 2.54 | 125 | 62 | 62 mmx125 mmø-62 mmx125 mmø | KT03.02.0066 | 0066 | 34.175 | 39.175
772357 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0067 | 0067 | 36.175 | 41.175
772358 | 1.NP_SO-101 | 1.NP_SO-101 | 600 | 0.000943639 | 2 | 2.54 | 214 | 66 | 66 mmx214 mmø-66 mmx214 mmø | KT03.02.0068 | 0068 | 36.175 | 41.175

# IfcCableCarrierFitting: Žlab_Horizontální odbočka:300mm Radius (2)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Radius: 300 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.17; Kód sestavy: KT02; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: 300mm Radius; Označení typu: 04; Popis sestavy: Odbočení žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Žlab_Horizontální odbočka
Classification: KT02 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Výška od podlaží: 750 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.00805651 m3; Tloušťka: 2.54 mm; Tray Height: 50 mm; Tray Length: 75 mm; Tray Width 1: 100 mm; Tray Width 3: 100 mm; Velikost: 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø
Jiné - Páteřní trasa: yes; Id typu: 15959; Radius Label: 300 mm; Radius Label 1: 302.54 mm; Rodina: Žlab_Horizontální odbočka; Rodina a typ: Žlab_Horizontální odbočka: 300mm Radius; Typ: 300mm Radius; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
Name (Žlab_Horizontální odbočka:300mm Radius:...) | Kód prvku | Označení
764458 | KT02.04.0007 | 0007
765044 | KT02.04.0011 | 0011

# IfcCableCarrierFitting: Žlab_Spojka:Standard (2)
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.17; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: Standard; Označení typu: 03; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Žlab_Spojka
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 2.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Lávka_Délka: 75 mm; Lávka_Šířka: 62 mm; Lávka_Výška: 125 mm; Objem: 0.00058125 m3; Tloušťka: 2.54 mm; Velikost: 62 mmx125 mmø-62 mmx125 mmø
Jiné - Páteřní trasa: yes; Typ: Standard; Id typu: 15967; Rodina: Žlab_Spojka; Rodina a typ: Žlab_Spojka: Standard
Name (Žlab_Spojka:Standard:...) | Výška od podlaží (mm) | Kód prvku | Označení
764348 | 1050 | .03.0006 | 0006
767247 | 600 | .03.0027 | 0027

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Kabelový žlab (31)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Spojení: Žlab_Spojka: Standard; Horizontální ohyb: Žlab_Horizontální koleno: Standard; Kříž: Žlab_Horizontální křížení: 300mm Radius; Přechod: Žlab_Redukce: Standard; T-spoj: Žlab_Horizontální odbočka: 300mm Radius; Vertikální vnější ohyb: Žlab_Svislé vnější koleno: R=300; Vertikální vnitřní ohyb: Žlab_Svislé vnitřní koleno: R=300
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ03; Komentáře k typům: 8 m;-1PP; Název typu: Kabelový žlab; Označení typu: 02; Popis: Kabelový žlab; Popis sestavy: Kabelová lávka a žebřík; Výrobce: KOPOS
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ03 Uniformat (Uniformat)
Qto_CableCarrierSegmentBaseQuantities - Length: 50 mm
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Horní výška: 775 mm; Koncová střední výška: 750 mm; Počáteční střední výška: 750 mm; Spodní výška: 725 mm; Střední výška: 750 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Šířka: 100 mm; Velikost: 100 mmx50 mmø; Výška: 50 mm
Jiné - Páteřní trasa: yes; Rodina: Kabelová lávka s tvarovkami; Id typu: 1976; Rodina a typ: Kabelová lávka s tvarovkami: Kabelový žlab; Typ: Kabelový žlab
Name (Kabelová lávka s tvarovkami:Kabelový žlab:...) | In | CrossSectionArea (m2) | OuterSurfaceArea (m2) | Referenční podlaží | Délka (mm) | Kód prvku | Označení | UPRAVIL
662867 | 1.NP_SO-101 | 0.00668034 | 0.0166803 | 1.NP_SO-101 | 66.8034 | KZ03.02.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662868 | 1.NP_SO-101 | 0.231915 | 0.241915 | 1.NP_SO-101 | 2319.15 | KZ03.02.0006 | 0006 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662869 | 1.NP_SO-101 | 0.25 | 0.26 | 1.NP_SO-101 | 2500 | KZ03.02.0007 | 0007 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662871 | 1.NP_SO-101 | 0.131163 | 0.141163 | 1.NP_SO-101 | 1311.63 | KZ03.02.0008 | 0008 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662872 | 1.NP_SO-101 | 0.131163 | 0.141163 | 1.NP_SO-101 | 1311.63 | KZ03.02.0009 | 0009 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662874 | 1.NP_SO-101 | 0.234 | 0.244 | 1.NP_SO-101 | 2340 | KZ03.02.0010 | 0010 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
662876 | 1.NP_SO-101 | 0.2215 | 0.2315 | 1.NP_SO-101 | 2215 | KZ03.02.0011 | 0011 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
667780 | 1.NP_SO-101 | 0.155663 | 0.165663 | 1.NP_SO-101 | 1556.63 | KZ03.02.0012 | 0012 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683854 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0016 | 0016 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683855 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0017 | 0017 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683856 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0018 | 0018 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683857 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0019 | 0019 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683858 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0020 | 0020 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683859 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0021 | 0021 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683860 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0022 | 0022 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683861 | 2.NP_SO-101 | 0.53 | 0.54 | 2.NP_SO-101 | 5300 | KZ03.02.0023 | 0023 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683862 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683863 | 2.NP_SO-101 | 0.56 | 0.57 | 2.NP_SO-101 | 5600 | KZ03.02.0025 | 0025 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683864 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683865 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0027 | 0027 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683866 | 2.NP_SO-101 | 0.35 | 0.36 | 2.NP_SO-101 | 3500 | KZ03.02.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683867 | 2.NP_SO-101 | 0.35 | 0.36 | 2.NP_SO-101 | 3500 | KZ03.02.0029 | 0029 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683872 | 2.NP_SO-101 | 0.280644 | 0.290644 | 2.NP_SO-101 | 2806.44 | KZ03.02.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
683873 | 2.NP_SO-101 | 0.17 | 0.18 | 2.NP_SO-101 | 1700 | KZ03.02.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
762448 | 2.NP_SO-101 | 0.325159 | 0.335159 | 2.NP_SO-101 | 3251.59 | KZ03.02.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
762493 | 2.NP_SO-101 | 0.0621966 | 0.0721966 | 2.NP_SO-101 | 621.966 | KZ03.02.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
762545 | 2.NP_SO-101 | 0.0103299 | 0.0203299 | 2.NP_SO-101 | 103.299 | KZ03.02.0042 | 0042
762741 | 2.NP_SO-101 | 0.0103299 | 0.0203299 | 2.NP_SO-101 | 103.299 | KZ03.02.0043 | 0043
765458 | 1.NP_SO-101 | 0.00728641 | 0.0172864 | 1.NP_SO-101 | 72.8641 | KZ03.02.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766049 | 1.NP_SO-101 | 0.225884 | 0.235884 | 1.NP_SO-101 | 2258.84 | KZ03.02.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
766147 | 1.NP_SO-101 | 0.0589352 | 0.0689352 | 1.NP_SO-101 | 589.352 | KZ03.02.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:52

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Parapetní žlab (56)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: Parapetní žlab_Koleno: Standardní; Spojení: Žlab_Spojka: Standard; T-spoj: Parapetní žlab_Odbočka: Standardní
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ04; Model: PK; Název typu: Parapetní žlab; Označení typu: 01; Popis: Parapetní kanál; Popis sestavy: Parapetní kanály
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ04 Uniformat (Uniformat)
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Jiné - Páteřní trasa: yes; Id typu: 16025; Rodina: Kabelová lávka s tvarovkami; Rodina a typ: Kabelová lávka s tvarovkami: Parapetní žlab; Typ: Parapetní žlab; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:52
Name (Kabelová lávka s tvarovkami:Parapetní žlab:...) | In | Length (mm) = Výška (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | Horní výška (mm) | Koncová střední výška (mm) = Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Délka (mm) | Šířka (mm) | Velikost | Kód prvku | Označení
662859 | 1.NP_SO-101 | 125 | 0.209613 | 0.860713 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 3380.85 | 62 | 62 mmx125 mmø | KZ04.01.0001 | 0001
662864 | 1.NP_SO-101 | 214 | 0.0746529 | 0.512361 | 707 | 600 | 1.NP_SO-101 | 493 | 1131.1 | 66 | 66 mmx214 mmø | KZ04.01.0002 | 0002
662865 | 1.NP_SO-101 | 214 | 0.165 | 1.09825 | 707 | 600 | 1.NP_SO-101 | 493 | 2500 | 66 | 66 mmx214 mmø | KZ04.01.0003 | 0003
662866 | 1.NP_SO-101 | 214 | 0.2772 | 1.82585 | 707 | 600 | 1.NP_SO-101 | 493 | 4200 | 66 | 66 mmx214 mmø | KZ04.01.0004 | 0004
683851 | 2.NP_SO-101 | 125 | 0.175602 | 0.723573 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 2832.29 | 62 | 62 mmx125 mmø | KZ04.01.0013 | 0013
683852 | 2.NP_SO-101 | 125 | 0.186 | 0.7655 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 3000 | 62 | 62 mmx125 mmø | KZ04.01.0014 | 0014
683853 | 2.NP_SO-101 | 125 | 0.15337 | 0.633929 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 2473.72 | 62 | 62 mmx125 mmø | KZ04.01.0015 | 0015
683869 | 2.NP_SO-101 | 125 | 0.04897 | 0.21296 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 789.839 | 62 | 62 mmx125 mmø | KZ04.01.0030 | 0030
683870 | 2.NP_SO-101 | 125 | 0.343872 | 1.40208 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 5546.33 | 62 | 62 mmx125 mmø | KZ04.01.0031 | 0031
738568 | 1.NP_SO-101 | 125 | 0.143507 | 0.594159 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2314.64 | 62 | 62 mmx125 mmø | KZ04.01.0034 | 0034
738620 | 1.NP_SO-101 | 125 | 0.227478 | 0.93275 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 3669 | 62 | 62 mmx125 mmø | KZ04.01.0035 | 0035
739734 | 3.NP_SO-101 | 125 | 0.09176 | 0.3855 | 1112.5 | 1050 | 3.NP_SO-101 | 987.5 | 1480 | 62 | 62 mmx125 mmø | KZ04.01.0036 | 0036
739912 | 3.NP_SO-101 | 125 | 0.09176 | 0.3855 | 1112.5 | 1050 | 3.NP_SO-101 | 987.5 | 1480 | 62 | 62 mmx125 mmø | KZ04.01.0037 | 0037
740105 | 4.NP_SO-101 | 125 | 0.7998 | 3.2405 | 872.5 | 810 | 4.NP_SO-101 | 747.5 | 12900 | 62 | 62 mmx125 mmø | KZ04.01.0038 | 0038
740337 | 4.NP_SO-101 | 125 | 0.96968 | 3.9255 | 872.5 | 810 | 4.NP_SO-101 | 747.5 | 15640 | 62 | 62 mmx125 mmø | KZ04.01.0039 | 0039
764264 | 2.NP_SO-101 | 125 | 0.0514931 | 0.223134 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 830.534 | 62 | 62 mmx125 mmø | KZ04.01.0044 | 0044
764347 | 2.NP_SO-101 | 125 | 0.0147356 | 0.0749179 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 237.672 | 62 | 62 mmx125 mmø | KZ04.01.0045 | 0045
767246 | 2.NP_SO-101 | 125 | 0.13423 | 0.55675 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 2165 | 62 | 62 mmx125 mmø | KZ04.01.0049 | 0049
767519 | 2.NP_SO-101 | 125 | 0.0104225 | 0.0575263 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 168.105 | 62 | 62 mmx125 mmø | KZ04.01.0050 | 0050
767708 | 2.NP_SO-101 | 125 | 0.0104225 | 0.0575263 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 168.105 | 62 | 62 mmx125 mmø | KZ04.01.0051 | 0051
767724 | 2.NP_SO-101 | 125 | 0.0307437 | 0.139467 | 662.5 | 600 | 2.NP_SO-101 | 537.5 | 495.866 | 62 | 62 mmx125 mmø | KZ04.01.0052 | 0052
767953 | 1.NP_SO-101 | 214 | 0.0786949 | 0.538572 | 707 | 600 | 1.NP_SO-101 | 493 | 1192.35 | 66 | 66 mmx214 mmø | KZ04.01.0053 | 0053
768152 | 1.NP_SO-101 | 214 | 0.0383063 | 0.276658 | 707 | 600 | 1.NP_SO-101 | 493 | 580.398 | 66 | 66 mmx214 mmø | KZ04.01.0054 | 0054
768214 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0055 | 0055
768404 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0056 | 0056
768454 | 1.NP_SO-101 | 214 | 0.0488663 | 0.345138 | 707 | 600 | 1.NP_SO-101 | 493 | 740.398 | 66 | 66 mmx214 mmø | KZ04.01.0057 | 0057
768456 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0058 | 0058
768457 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0059 | 0059
768468 | 1.NP_SO-101 | 214 | 0.0488663 | 0.345138 | 707 | 600 | 1.NP_SO-101 | 493 | 740.398 | 66 | 66 mmx214 mmø | KZ04.01.0060 | 0060
768470 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0061 | 0061
768471 | 1.NP_SO-101 | 214 | 0.0160729 | 0.132478 | 707 | 600 | 1.NP_SO-101 | 493 | 243.529 | 66 | 66 mmx214 mmø | KZ04.01.0062 | 0062
769045 | 1.NP_SO-101 | 125 | 0.13189 | 0.547315 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2127.26 | 62 | 62 mmx125 mmø | KZ04.01.0063 | 0063
769132 | 1.NP_SO-101 | 125 | 0.0517949 | 0.224351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 835.402 | 62 | 62 mmx125 mmø | KZ04.01.0064 | 0064
769182 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0065 | 0065
769255 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0066 | 0066
769292 | 1.NP_SO-101 | 125 | 0.0517949 | 0.224351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 835.402 | 62 | 62 mmx125 mmø | KZ04.01.0067 | 0067
769293 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0068 | 0068
769295 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0069 | 0069
769308 | 1.NP_SO-101 | 125 | 0.0468349 | 0.204351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 755.402 | 62 | 62 mmx125 mmø | KZ04.01.0070 | 0070
769309 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0071 | 0071
769311 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0072 | 0072
769322 | 1.NP_SO-101 | 125 | 0.0567549 | 0.244351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 915.402 | 62 | 62 mmx125 mmø | KZ04.01.0073 | 0073
769323 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0074 | 0074
769325 | 1.NP_SO-101 | 125 | 0.00744 | 0.0455 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 120 | 62 | 62 mmx125 mmø | KZ04.01.0075 | 0075
769445 | 1.NP_SO-101 | 125 | 0.12604 | 0.523724 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2032.9 | 62 | 62 mmx125 mmø | KZ04.01.0076 | 0076
769564 | 1.NP_SO-101 | 125 | 0.125265 | 0.520599 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2020.4 | 62 | 62 mmx125 mmø | KZ04.01.0077 | 0077
769801 | 1.NP_SO-101 | 125 | 0.125575 | 0.521849 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2025.4 | 62 | 62 mmx125 mmø | KZ04.01.0078 | 0078
769877 | 1.NP_SO-101 | 125 | 0.0307149 | 0.139351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 495.402 | 62 | 62 mmx125 mmø | KZ04.01.0079 | 0079
769878 | 1.NP_SO-101 | 125 | 0.0106265 | 0.0583487 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 171.395 | 62 | 62 mmx125 mmø | KZ04.01.0080 | 0080
769879 | 1.NP_SO-101 | 125 | 0.0106265 | 0.0583487 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 171.395 | 62 | 62 mmx125 mmø | KZ04.01.0081 | 0081
770249 | 1.NP_SO-101 | 125 | 0.208137 | 0.854761 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 3357.04 | 62 | 62 mmx125 mmø | KZ04.01.0082 | 0082
770339 | 1.NP_SO-101 | 125 | 0.0307149 | 0.139351 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 495.402 | 62 | 62 mmx125 mmø | KZ04.01.0083 | 0083
770340 | 1.NP_SO-101 | 125 | 0.0106265 | 0.0583487 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 171.395 | 62 | 62 mmx125 mmø | KZ04.01.0084 | 0084
770341 | 1.NP_SO-101 | 125 | 0.0106265 | 0.0583487 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 171.395 | 62 | 62 mmx125 mmø | KZ04.01.0085 | 0085
770423 | 1.NP_SO-101 | 125 | 0.14867 | 0.614974 | 662.5 | 600 | 1.NP_SO-101 | 537.5 | 2397.9 | 62 | 62 mmx125 mmø | KZ04.01.0086 | 0086
772106 | 2.NP_SO-101 | 125 | 0.295116 | 1.20548 | 1112.5 | 1050 | 2.NP_SO-101 | 987.5 | 4759.94 | 62 | 62 mmx125 mmø | KZ04.01.0087 | 0087

# IfcDistributionPort (1510)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_400963_1 | CABLECARRIER | CONVEYING
Port_400963_2 | CABLECARRIER | CONVEYING
Port_403095_1 | CABLECARRIER | CONVEYING
Port_403095_2 | CABLECARRIER | CONVEYING
Port_403095_3 | CABLECARRIER | CONVEYING
Port_403095_4 | CABLECARRIER | CONVEYING
Port_657689_1 | CABLE | ELECTRICAL
Port_657748_1 | CABLE | ELECTRICAL
Port_658692_1 | CABLE | ELECTRICAL
Port_658729_1 | CABLE | ELECTRICAL
Port_662357_1 | CABLE | ELECTRICAL
Port_662368_1 | CABLE | ELECTRICAL
Port_662425_1 | CABLE | ELECTRICAL
Port_662446_1 | CABLE | ELECTRICAL
Port_662457_1 | CABLE | ELECTRICAL
Port_662493_1 | CABLE | ELECTRICAL
Port_662544_1 | CABLE | ELECTRICAL
Port_662555_1 | CABLE | ELECTRICAL
Port_662859_0 | CABLECARRIER | CONVEYING
Port_770456_1 | CABLECARRIER | CONVEYING
Port_662859_1 | CABLECARRIER | CONVEYING
Port_662864_0 | CABLECARRIER | CONVEYING
Port_767988_1 | CABLECARRIER | CONVEYING
Port_662864_1 | CABLECARRIER | CONVEYING
Port_662865_0 | CABLECARRIER | CONVEYING
Port_662865_1 | CABLECARRIER | CONVEYING
Port_662866_0 | CABLECARRIER | CONVEYING
Port_662866_1 | CABLECARRIER | CONVEYING
Port_662867_0 | CABLECARRIER | CONVEYING
Port_662867_1 | CABLECARRIER | CONVEYING
Port_662868_0 | CABLECARRIER | CONVEYING
Port_662868_1 | CABLECARRIER | CONVEYING
Port_662869_0 | CABLECARRIER | CONVEYING
Port_765522_2 | CABLECARRIER | CONVEYING
Port_662869_1 | CABLECARRIER | CONVEYING
Port_662871_0 | CABLECARRIER | CONVEYING
Port_765044_3 | CABLECARRIER | CONVEYING
Port_662871_1 | CABLECARRIER | CONVEYING
Port_662872_0 | CABLECARRIER | CONVEYING
Port_764458_3 | CABLECARRIER | CONVEYING
