Properties of the parts of a building model (IFC4), part 5 of 5

# IfcDistributionPort (1510)
Name | PredefinedType | SystemType
Port_662872_1 | CABLECARRIER | CONVEYING
Port_662874_0 | CABLECARRIER | CONVEYING
Port_662874_1 | CABLECARRIER | CONVEYING
Port_765045_2 | CABLECARRIER | CONVEYING
Port_662876_0 | CABLECARRIER | CONVEYING
Port_764562_2 | CABLECARRIER | CONVEYING
Port_662876_1 | CABLECARRIER | CONVEYING
Port_663514_1 | CABLE | ELECTRICAL
Port_663521_1 | CABLE | ELECTRICAL
Port_663528_1 | CABLE | ELECTRICAL
Port_663535_1 | CABLE | ELECTRICAL
Port_663549_1 | CABLE | ELECTRICAL
Port_663556_1 | CABLE | ELECTRICAL
Port_663570_1 | CABLE | ELECTRICAL
Port_663591_1 | CABLE | ELECTRICAL
Port_663612_1 | CABLE | ELECTRICAL
Port_664379_1 | CABLE | ELECTRICAL
Port_664387_1 | CABLE | ELECTRICAL
Port_664421_1 | CABLE | ELECTRICAL
Port_664598_1 | CABLE | ELECTRICAL
Port_664623_1 | CABLE | ELECTRICAL
Port_664717_1 | CABLE | ELECTRICAL
Port_664775_1 | CABLE | ELECTRICAL
Port_664879_1 | CABLE | ELECTRICAL
Port_664895_1 | CABLE | ELECTRICAL
Port_665102_1 | CABLE | ELECTRICAL
Port_665118_1 | CABLE | ELECTRICAL
Port_665178_1 | CABLE | ELECTRICAL
Port_665696_1 | CABLE | ELECTRICAL
Port_665696_2 | CABLE | ELECTROACOUSTIC
Port_665696_3 | CABLE | SECURITY
Port_665696_4 | CABLE | CONTROL
Port_665696_5 | CABLE | VENTILATION
Port_665716_1 | CABLE | ELECTRICAL
Port_665716_2 | CABLE | ELECTROACOUSTIC
Port_665716_3 | CABLE | SECURITY
Port_665716_4 | CABLE | CONTROL
Port_665716_5 | CABLE | VENTILATION
Port_665728_1 | CABLE | ELECTRICAL
Port_665728_2 | CABLE | ELECTROACOUSTIC
Port_665728_3 | CABLE | SECURITY
Port_665728_4 | CABLE | CONTROL
Port_665728_5 | CABLE | VENTILATION
Port_665740_1 | CABLE | ELECTRICAL
Port_665740_2 | CABLE | ELECTROACOUSTIC
Port_665740_3 | CABLE | SECURITY
Port_665740_4 | CABLE | CONTROL
Port_665740_5 | CABLE | VENTILATION
Port_665752_1 | CABLE | ELECTRICAL
Port_665752_2 | CABLE | ELECTROACOUSTIC
Port_665752_3 | CABLE | SECURITY
Port_665752_4 | CABLE | CONTROL
Port_665752_5 | CABLE | VENTILATION
Port_665772_1 | CABLE | ELECTRICAL
Port_665772_2 | CABLE | ELECTROACOUSTIC
Port_665772_3 | CABLE | SECURITY
Port_665772_4 | CABLE | CONTROL
Port_665772_5 | CABLE | VENTILATION
Port_665982_1 | CABLE | ELECTRICAL
Port_665996_1 | CABLE | ELECTRICAL
Port_666021_1 | CABLE | ELECTRICAL
Port_666221_1 | CABLE | ELECTRICAL
Port_666404_1 | CABLE | ELECTRICAL
Port_666404_2 | CABLE | ELECTROACOUSTIC
Port_666404_3 | CABLE | SECURITY
Port_666404_4 | CABLE | CONTROL
Port_666404_5 | CABLE | VENTILATION
Port_666546_1 | CABLE | ELECTRICAL
Port_666546_2 | CABLE | ELECTROACOUSTIC
Port_666546_3 | CABLE | SECURITY
Port_666546_4 | CABLE | CONTROL
Port_666546_5 | CABLE | VENTILATION
Port_667745_1 | CABLE | ELECTRICAL
Port_667780_0 | CABLECARRIER | CONVEYING
Port_667780_1 | CABLECARRIER | CONVEYING
Port_668074_1 | CABLE | ELECTRICAL
Port_668082_1 | CABLE | ELECTRICAL
Port_668098_1 | CABLE | ELECTRICAL
Port_668159_1 | CABLE | ELECTRICAL
Port_668178_1 | CABLE | ELECTRICAL
Port_668235_1 | CABLE | ELECTRICAL
Port_668251_1 | CABLE | ELECTRICAL
Port_668273_1 | CABLE | ELECTRICAL
Port_668289_1 | CABLE | ELECTRICAL
Port_668366_1 | CABLE | ELECTRICAL
Port_668382_1 | CABLE | ELECTRICAL
Port_668626_1 | CABLE | ELECTRICAL
Port_668669_1 | CABLE | ELECTRICAL
Port_668695_1 | CABLE | ELECTRICAL
Port_668711_1 | CABLE | ELECTRICAL
Port_668735_1 | CABLE | ELECTRICAL
Port_668757_1 | CABLE | ELECTRICAL
Port_668848_1 | CABLE | ELECTRICAL
Port_668968_1 | CABLE | ELECTRICAL
Port_668987_1 | CABLE | ELECTRICAL
Port_669123_1 | CABLE | ELECTRICAL
Port_669139_1 | CABLE | ELECTRICAL
Port_669155_1 | CABLE | ELECTRICAL
Port_669226_1 | CABLE | ELECTRICAL
Port_669248_1 | CABLE | ELECTRICAL
Port_669267_1 | CABLE | ELECTRICAL
Port_669283_1 | CABLE | ELECTRICAL
Port_669351_1 | CABLE | ELECTRICAL
Port_669406_1 | CABLE | ELECTRICAL
Port_669406_2 | CABLE | ELECTROACOUSTIC
Port_669406_3 | CABLE | SECURITY
Port_669406_4 | CABLE | CONTROL
Port_669406_5 | CABLE | VENTILATION
Port_669414_1 | CABLE | ELECTRICAL
Port_669414_2 | CABLE | ELECTROACOUSTIC
Port_669414_3 | CABLE | SECURITY
Port_669414_4 | CABLE | CONTROL
Port_669414_5 | CABLE | VENTILATION
Port_669428_1 | CABLE | ELECTRICAL
Port_669428_2 | CABLE | ELECTROACOUSTIC
Port_669428_3 | CABLE | SECURITY
Port_669428_4 | CABLE | CONTROL
Port_669428_5 | CABLE | VENTILATION
Port_669438_1 | CABLE | ELECTRICAL
Port_669438_2 | CABLE | ELECTROACOUSTIC
Port_669438_3 | CABLE | SECURITY
Port_669438_4 | CABLE | CONTROL
Port_669438_5 | CABLE | VENTILATION
Port_669456_1 | CABLE | ELECTRICAL
Port_669456_2 | CABLE | ELECTROACOUSTIC
Port_669456_3 | CABLE | SECURITY
Port_669456_4 | CABLE | CONTROL
Port_669456_5 | CABLE | VENTILATION
Port_669466_1 | CABLE | ELECTRICAL
Port_669466_2 | CABLE | ELECTROACOUSTIC
Port_669466_3 | CABLE | SECURITY
Port_669466_4 | CABLE | CONTROL
Port_669466_5 | CABLE | VENTILATION
Port_669476_1 | CABLE | ELECTRICAL
Port_669476_2 | CABLE | ELECTROACOUSTIC
Port_669476_3 | CABLE | SECURITY
Port_669476_4 | CABLE | CONTROL
Port_669476_5 | CABLE | VENTILATION
Port_669484_1 | CABLE | ELECTRICAL
Port_669484_2 | CABLE | ELECTROACOUSTIC
Port_669484_3 | CABLE | SECURITY
Port_669484_4 | CABLE | CONTROL
Port_669484_5 | CABLE | VENTILATION
Port_669492_1 | CABLE | ELECTRICAL
Port_669492_2 | CABLE | ELECTROACOUSTIC
Port_669492_3 | CABLE | SECURITY
Port_669492_4 | CABLE | CONTROL
Port_669492_5 | CABLE | VENTILATION
Port_669500_1 | CABLE | ELECTRICAL
Port_669500_2 | CABLE | ELECTROACOUSTIC
Port_669500_3 | CABLE | SECURITY
Port_669500_4 | CABLE | CONTROL
Port_669500_5 | CABLE | VENTILATION
Port_669508_1 | CABLE | ELECTRICAL
Port_669508_2 | CABLE | ELECTROACOUSTIC
Port_669508_3 | CABLE | SECURITY
Port_669508_4 | CABLE | CONTROL
Port_669508_5 | CABLE | VENTILATION
Port_669516_1 | CABLE | ELECTRICAL
Port_669516_2 | CABLE | ELECTROACOUSTIC
Port_669516_3 | CABLE | SECURITY
Port_669516_4 | CABLE | CONTROL
Port_669516_5 | CABLE | VENTILATION
Port_669532_1 | CABLE | ELECTRICAL
Port_669532_2 | CABLE | ELECTROACOUSTIC
Port_669532_3 | CABLE | SECURITY
Port_669532_4 | CABLE | CONTROL
Port_669532_5 | CABLE | VENTILATION
Port_669548_1 | CABLE | ELECTRICAL
Port_669548_2 | CABLE | ELECTROACOUSTIC
Port_669548_3 | CABLE | SECURITY
Port_669548_4 | CABLE | CONTROL
Port_669548_5 | CABLE | VENTILATION
Port_669556_1 | CABLE | ELECTRICAL
Port_669556_2 | CABLE | ELECTROACOUSTIC
Port_669556_3 | CABLE | SECURITY
Port_669556_4 | CABLE | CONTROL
Port_669556_5 | CABLE | VENTILATION
Port_669564_1 | CABLE | ELECTRICAL
Port_669564_2 | CABLE | ELECTROACOUSTIC
Port_669564_3 | CABLE | SECURITY
Port_669564_4 | CABLE | CONTROL
Port_669564_5 | CABLE | VENTILATION
Port_669572_1 | CABLE | ELECTRICAL
Port_669572_2 | CABLE | ELECTROACOUSTIC
Port_669572_3 | CABLE | SECURITY
Port_669572_4 | CABLE | CONTROL
Port_669572_5 | CABLE | VENTILATION
Port_669593_1 | CABLE | ELECTRICAL
Port_669593_2 | CABLE | ELECTROACOUSTIC
Port_669593_3 | CABLE | SECURITY
Port_669593_4 | CABLE | CONTROL
Port_669593_5 | CABLE | VENTILATION
Port_669601_1 | CABLE | ELECTRICAL
Port_669601_2 | CABLE | ELECTROACOUSTIC
Port_669601_3 | CABLE | SECURITY
Port_669601_4 | CABLE | CONTROL
Port_669601_5 | CABLE | VENTILATION
Port_669609_1 | CABLE | ELECTRICAL
Port_669609_2 | CABLE | ELECTROACOUSTIC
Port_669609_3 | CABLE | SECURITY
Port_669609_4 | CABLE | CONTROL
Port_669609_5 | CABLE | VENTILATION
Port_669737_1 | CABLE | ELECTRICAL
Port_669745_1 | CABLE | ELECTRICAL
Port_669750_1 | CABLE | ELECTRICAL
Port_669837_1 | CABLE | ELECTRICAL
Port_669861_1 | CABLE | ELECTRICAL
Port_669861_2 | CABLE | ELECTROACOUSTIC
Port_669861_3 | CABLE | SECURITY
Port_669861_4 | CABLE | CONTROL
Port_669861_5 | CABLE | VENTILATION
Port_669872_1 | CABLE | ELECTRICAL
Port_669872_2 | CABLE | ELECTROACOUSTIC
Port_669872_3 | CABLE | SECURITY
Port_669872_4 | CABLE | CONTROL
Port_669872_5 | CABLE | VENTILATION
Port_669880_1 | CABLE | ELECTRICAL
Port_669880_2 | CABLE | ELECTROACOUSTIC
Port_669880_3 | CABLE | SECURITY
Port_669880_4 | CABLE | CONTROL
Port_669880_5 | CABLE | VENTILATION
Port_669888_1 | CABLE | ELECTRICAL
Port_669888_2 | CABLE | ELECTROACOUSTIC
Port_669888_3 | CABLE | SECURITY
Port_669888_4 | CABLE | CONTROL
Port_669888_5 | CABLE | VENTILATION
Port_669896_1 | CABLE | ELECTRICAL
Port_669896_2 | CABLE | ELECTROACOUSTIC
Port_669896_3 | CABLE | SECURITY
Port_669896_4 | CABLE | CONTROL
Port_669896_5 | CABLE | VENTILATION
Port_669908_1 | CABLE | ELECTRICAL
Port_669913_1 | CABLE | ELECTRICAL
Port_669918_1 | CABLE | ELECTRICAL
Port_669923_1 | CABLE | ELECTRICAL
Port_669990_1 | CABLE | ELECTRICAL
Port_669997_1 | CABLE | ELECTRICAL
Port_670004_1 | CABLE | ELECTRICAL
Port_670011_1 | CABLE | ELECTRICAL
Port_670018_1 | CABLE | ELECTRICAL
Port_670025_1 | CABLE | ELECTRICAL
Port_670060_1 | CABLE | ELECTRICAL
Port_670062_1 | CABLE | ELECTRICAL
Port_670157_1 | CABLE | ELECTRICAL
Port_670272_1 | CABLE | ELECTRICAL
Port_670317_1 | CABLE | ELECTRICAL
Port_670333_1 | CABLE | ELECTRICAL
Port_670459_1 | CABLE | ELECTRICAL
Port_670487_1 | CABLE | ELECTRICAL
Port_670612_1 | CABLE | ELECTRICAL
Port_670628_1 | CABLE | ELECTRICAL
Port_670658_1 | CABLE | ELECTRICAL
Port_670678_1 | CABLE | ELECTRICAL
Port_670843_1 | CABLE | ELECTRICAL
Port_670857_1 | CABLE | ELECTRICAL
Port_670879_1 | CABLE | ELECTRICAL
Port_671021_1 | CABLE | ELECTRICAL
Port_671061_1 | CABLE | ELECTRICAL
Port_671244_1 | CABLE | ELECTRICAL
Port_671260_1 | CABLE | ELECTRICAL
Port_671375_1 | CABLE | ELECTRICAL
Port_671403_1 | CABLE | ELECTRICAL
Port_671444_1 | CABLE | ELECTRICAL
Port_671503_1 | CABLE | ELECTRICAL
Port_671503_2 | CABLE | ELECTROACOUSTIC
Port_671503_3 | CABLE | SECURITY
Port_671503_4 | CABLE | CONTROL
Port_671503_5 | CABLE | VENTILATION
Port_671517_1 | CABLE | ELECTRICAL
Port_671517_2 | CABLE | ELECTROACOUSTIC
Port_671517_3 | CABLE | SECURITY
Port_671517_4 | CABLE | CONTROL
Port_671517_5 | CABLE | VENTILATION
Port_671525_1 | CABLE | ELECTRICAL
Port_671525_2 | CABLE | ELECTROACOUSTIC
Port_671525_3 | CABLE | SECURITY
Port_671525_4 | CABLE | CONTROL
Port_671525_5 | CABLE | VENTILATION
Port_671537_1 | CABLE | ELECTRICAL
Port_671537_2 | CABLE | ELECTROACOUSTIC
Port_671537_3 | CABLE | SECURITY
Port_671537_4 | CABLE | CONTROL
Port_671537_5 | CABLE | VENTILATION
Port_671549_1 | CABLE | ELECTRICAL
Port_671549_2 | CABLE | ELECTROACOUSTIC
Port_671549_3 | CABLE | SECURITY
Port_671549_4 | CABLE | CONTROL
Port_671549_5 | CABLE | VENTILATION
Port_671570_1 | CABLE | ELECTRICAL
Port_671570_2 | CABLE | ELECTROACOUSTIC
Port_671570_3 | CABLE | SECURITY
Port_671570_4 | CABLE | CONTROL
Port_671570_5 | CABLE | VENTILATION
Port_671582_1 | CABLE | ELECTRICAL
Port_671582_2 | CABLE | ELECTROACOUSTIC
Port_671582_3 | CABLE | SECURITY
Port_671582_4 | CABLE | CONTROL
Port_671582_5 | CABLE | VENTILATION
Port_671594_1 | CABLE | ELECTRICAL
Port_671594_2 | CABLE | ELECTROACOUSTIC
Port_671594_3 | CABLE | SECURITY
Port_671594_4 | CABLE | CONTROL
Port_671594_5 | CABLE | VENTILATION
Port_671606_1 | CABLE | ELECTRICAL
Port_671606_2 | CABLE | ELECTROACOUSTIC
Port_671606_3 | CABLE | SECURITY
Port_671606_4 | CABLE | CONTROL
Port_671606_5 | CABLE | VENTILATION
Port_671618_1 | CABLE | ELECTRICAL
Port_671618_2 | CABLE | ELECTROACOUSTIC
Port_671618_3 | CABLE | SECURITY
Port_671618_4 | CABLE | CONTROL
Port_671618_5 | CABLE | VENTILATION
Port_671756_1 | CABLE | ELECTRICAL
Port_671803_1 | CABLE | ELECTRICAL
Port_671803_2 | CABLE | ELECTROACOUSTIC
Port_671803_3 | CABLE | SECURITY
Port_671803_4 | CABLE | CONTROL
Port_671803_5 | CABLE | VENTILATION
Port_671814_1 | CABLE | ELECTRICAL
Port_671828_1 | CABLE | ELECTRICAL
Port_671828_2 | CABLE | ELECTROACOUSTIC
Port_671828_3 | CABLE | SECURITY
Port_671828_4 | CABLE | CONTROL
Port_671828_5 | CABLE | VENTILATION
Port_671851_1 | CABLE | ELECTRICAL
Port_671856_1 | CABLE | ELECTRICAL
Port_673485_1 | CABLE | ELECTRICAL
Port_673501_1 | CABLE | ELECTRICAL
Port_673609_1 | CABLE | ELECTRICAL
Port_673711_1 | CABLE | ELECTRICAL
Port_674131_1 | CABLE | ELECTRICAL
Port_674568_1 | CABLE | ELECTRICAL
Port_674806_1 | CABLE | ELECTRICAL
Port_674861_1 | CABLE | ELECTRICAL
Port_675051_1 | CABLE | ELECTRICAL
Port_675199_1 | CABLE | ELECTRICAL
Port_675415_1 | CABLE | ELECTRICAL
Port_675662_1 | CABLE | ELECTRICAL
Port_676075_1 | CABLE | ELECTRICAL
Port_676322_1 | CABLE | ELECTRICAL
Port_676732_1 | CABLE | ELECTRICAL
Port_676830_1 | CABLE | ELECTRICAL
Port_677081_1 | CABLE | ELECTRICAL
Port_677267_1 | CABLE | ELECTRICAL
Port_677573_1 | CABLE | ELECTRICAL
Port_677863_1 | CABLE | ELECTRICAL
Port_678137_1 | CABLE | ELECTRICAL
Port_678440_1 | CABLE | ELECTRICAL
Port_678732_1 | CABLE | ELECTRICAL
Port_679149_1 | CABLE | ELECTRICAL
Port_679215_1 | CABLE | ELECTRICAL
Port_681698_1 | CABLE | ELECTRICAL
Port_681703_1 | CABLE | ELECTRICAL
Port_681713_1 | CABLE | ELECTRICAL
Port_681718_1 | CABLE | ELECTRICAL
Port_681723_1 | CABLE | ELECTRICAL
Port_681728_1 | CABLE | ELECTRICAL
Port_681733_1 | CABLE | ELECTRICAL
Port_681738_1 | CABLE | ELECTRICAL
Port_681743_1 | CABLE | ELECTRICAL
Port_681748_1 | CABLE | ELECTRICAL
Port_681760_1 | CABLE | ELECTRICAL
Port_681768_1 | CABLE | ELECTRICAL
Port_681773_1 | CABLE | ELECTRICAL
Port_681778_1 | CABLE | ELECTRICAL
Port_681783_1 | CABLE | ELECTRICAL
Port_681788_1 | CABLE | ELECTRICAL
Port_681793_1 | CABLE | ELECTRICAL
Port_681798_1 | CABLE | ELECTRICAL
Port_681803_1 | CABLE | ELECTRICAL
Port_681813_1 | CABLE | ELECTRICAL
Port_681833_1 | CABLE | ELECTRICAL
Port_681849_1 | CABLE | ELECTRICAL
Port_681854_1 | CABLE | ELECTRICAL
Port_681859_1 | CABLE | ELECTRICAL
Port_681864_1 | CABLE | ELECTRICAL
Port_681872_1 | CABLE | ELECTRICAL
Port_681877_1 | CABLE | ELECTRICAL
Port_681885_1 | CABLE | ELECTRICAL
Port_681890_1 | CABLE | ELECTRICAL
Port_681898_1 | CABLE | ELECTRICAL
Port_681906_1 | CABLE | ELECTRICAL
Port_681915_1 | CABLE | ELECTRICAL
Port_681920_1 | CABLE | ELECTRICAL
Port_681925_1 | CABLE | ELECTRICAL
Port_681930_1 | CABLE | ELECTRICAL
Port_681935_1 | CABLE | ELECTRICAL
Port_681944_1 | CABLE | ELECTRICAL
Port_681949_1 | CABLE | ELECTRICAL
Port_681954_1 | CABLE | ELECTRICAL
Port_681962_1 | CABLE | ELECTRICAL
Port_681975_1 | CABLE | ELECTRICAL
Port_681993_1 | CABLE | ELECTRICAL
Port_681998_1 | CABLE | ELECTRICAL
Port_682003_1 | CABLE | ELECTRICAL
Port_682008_1 | CABLE | ELECTRICAL
Port_682013_1 | CABLE | ELECTRICAL
Port_682018_1 | CABLE | ELECTRICAL
Port_682023_1 | CABLE | ELECTRICAL
Port_682028_1 | CABLE | ELECTRICAL
Port_682056_1 | CABLE | ELECTRICAL
Port_682061_1 | CABLE | ELECTRICAL
Port_682070_1 | CABLE | ELECTRICAL
Port_682100_1 | CABLE | ELECTRICAL
Port_682105_1 | CABLE | ELECTRICAL
Port_682113_1 | CABLE | ELECTRICAL
Port_682118_1 | CABLE | ELECTRICAL
Port_682123_1 | CABLE | ELECTRICAL
Port_682128_1 | CABLE | ELECTRICAL
Port_682133_1 | CABLE | ELECTRICAL
Port_682141_1 | CABLE | ELECTRICAL
Port_682146_1 | CABLE | ELECTRICAL
Port_682151_1 | CABLE | ELECTRICAL
Port_682156_1 | CABLE | ELECTRICAL
Port_682161_1 | CABLE | ELECTRICAL
Port_682166_1 | CABLE | ELECTRICAL
Port_683207_1 | CABLE | ELECTRICAL
Port_683212_1 | CABLE | ELECTRICAL
Port_683217_1 | CABLE | ELECTRICAL
Port_683222_1 | CABLE | ELECTRICAL
Port_683227_1 | CABLE | ELECTRICAL
Port_683232_1 | CABLE | ELECTRICAL
Port_683237_1 | CABLE | ELECTRICAL
Port_683242_1 | CABLE | ELECTRICAL
Port_683247_1 | CABLE | ELECTRICAL
Port_683252_1 | CABLE | ELECTRICAL
Port_683257_1 | CABLE | ELECTRICAL
Port_683262_1 | CABLE | ELECTRICAL
Port_683267_1 | CABLE | ELECTRICAL
Port_683272_1 | CABLE | ELECTRICAL
Port_683277_1 | CABLE | ELECTRICAL
Port_683282_1 | CABLE | ELECTRICAL
Port_683287_1 | CABLE | ELECTRICAL
Port_683292_1 | CABLE | ELECTRICAL
Port_683297_1 | CABLE | ELECTRICAL
Port_683302_1 | CABLE | ELECTRICAL
Port_683307_1 | CABLE | ELECTRICAL
Port_683312_1 | CABLE | ELECTRICAL
Port_683317_1 | CABLE | ELECTRICAL
Port_683322_1 | CABLE | ELECTRICAL
Port_683327_1 | CABLE | ELECTRICAL
Port_683332_1 | CABLE | ELECTRICAL
Port_683337_1 | CABLE | ELECTRICAL
Port_683342_1 | CABLE | ELECTRICAL
Port_683347_1 | CABLE | ELECTRICAL
Port_683352_1 | CABLE | ELECTRICAL
Port_683357_1 | CABLE | ELECTRICAL
Port_683362_1 | CABLE | ELECTRICAL
Port_683367_1 | CABLE | ELECTRICAL
Port_683372_1 | CABLE | ELECTRICAL
Port_683377_1 | CABLE | ELECTRICAL
Port_683382_1 | CABLE | ELECTRICAL
Port_683454_1 | CABLE | ELECTRICAL
Port_683461_1 | CABLE | ELECTRICAL
Port_683468_1 | CABLE | ELECTRICAL
Port_683475_1 | CABLE | ELECTRICAL
Port_683482_1 | CABLE | ELECTRICAL
Port_683489_1 | CABLE | ELECTRICAL
Port_683499_1 | CABLE | ELECTRICAL
Port_683506_1 | CABLE | ELECTRICAL
Port_683513_1 | CABLE | ELECTRICAL
Port_683520_1 | CABLE | ELECTRICAL
Port_683527_1 | CABLE | ELECTRICAL
Port_683534_1 | CABLE | ELECTRICAL
Port_683644_1 | CABLE | ELECTRICAL
Port_683645_1 | CABLE | ELECTRICAL
Port_683706_1 | CABLE | ELECTRICAL
Port_683707_1 | CABLE | ELECTRICAL
Port_683718_1 | CABLE | ELECTRICAL
Port_683719_1 | CABLE | ELECTRICAL
Port_683728_1 | CABLE | ELECTRICAL
Port_683729_1 | CABLE | ELECTRICAL
Port_683738_1 | CABLE | ELECTRICAL
Port_683739_1 | CABLE | ELECTRICAL
Port_683750_1 | CABLE | ELECTRICAL
Port_683751_1 | CABLE | ELECTRICAL
Port_683764_1 | CABLE | ELECTRICAL
Port_683765_1 | CABLE | ELECTRICAL
Port_683820_1 | CABLE | ELECTRICAL
Port_683821_1 | CABLE | ELECTRICAL
Port_683851_0 | CABLECARRIER | CONVEYING
Port_683851_1 | CABLECARRIER | CONVEYING
Port_683852_0 | CABLECARRIER | CONVEYING
Port_683852_1 | CABLECARRIER | CONVEYING
Port_683853_0 | CABLECARRIER | CONVEYING
Port_767392_1 | CABLECARRIER | CONVEYING
Port_683853_1 | CABLECARRIER | CONVEYING
Port_683854_0 | CABLECARRIER | CONVEYING
Port_683854_1 | CABLECARRIER | CONVEYING
Port_683855_0 | CABLECARRIER | CONVEYING
Port_683855_1 | CABLECARRIER | CONVEYING
Port_683856_0 | CABLECARRIER | CONVEYING
Port_683856_1 | CABLECARRIER | CONVEYING
Port_683857_0 | CABLECARRIER | CONVEYING
Port_683857_1 | CABLECARRIER | CONVEYING
Port_683858_0 | CABLECARRIER | CONVEYING
Port_683858_1 | CABLECARRIER | CONVEYING
Port_683859_0 | CABLECARRIER | CONVEYING
Port_683859_1 | CABLECARRIER | CONVEYING
Port_683860_0 | CABLECARRIER | CONVEYING
Port_683860_1 | CABLECARRIER | CONVEYING
Port_683861_0 | CABLECARRIER | CONVEYING
Port_683861_1 | CABLECARRIER | CONVEYING
Port_683862_0 | CABLECARRIER | CONVEYING
Port_683862_1 | CABLECARRIER | CONVEYING
Port_683863_0 | CABLECARRIER | CONVEYING
Port_683863_1 | CABLECARRIER | CONVEYING
Port_683864_0 | CABLECARRIER | CONVEYING
Port_683864_1 | CABLECARRIER | CONVEYING
Port_683865_0 | CABLECARRIER | CONVEYING
Port_683865_1 | CABLECARRIER | CONVEYING
Port_683866_0 | CABLECARRIER | CONVEYING
Port_683866_1 | CABLECARRIER | CONVEYING
Port_683867_0 | CABLECARRIER | CONVEYING
Port_683867_1 | CABLECARRIER | CONVEYING
Port_683869_0 | CABLECARRIER | CONVEYING
Port_683869_1 | CABLECARRIER | CONVEYING
Port_683870_0 | CABLECARRIER | CONVEYING
Port_764348_2 | CABLECARRIER | CONVEYING
Port_683870_1 | CABLECARRIER | CONVEYING
Port_683871_1 | CABLECARRIER | CONVEYING
Port_764264_0 | CABLECARRIER | CONVEYING
Port_683871_2 | CABLECARRIER | CONVEYING
Port_764347_0 | CABLECARRIER | CONVEYING
Port_683872_0 | CABLECARRIER | CONVEYING
Port_762862_1 | CABLECARRIER | CONVEYING
Port_683872_1 | CABLECARRIER | CONVEYING
Port_683873_0 | CABLECARRIER | CONVEYING
Port_683873_1 | CABLECARRIER | CONVEYING
Port_684415_1 | CABLE | ELECTRICAL
Port_684423_1 | CABLE | ELECTRICAL
Port_684448_1 | CABLE | ELECTRICAL
Port_684482_1 | CABLE | ELECTRICAL
Port_684513_1 | CABLE | ELECTRICAL
Port_684580_1 | CABLE | ELECTRICAL
Port_684611_1 | CABLE | ELECTRICAL
Port_684630_1 | CABLE | ELECTRICAL
Port_684679_1 | CABLE | ELECTRICAL
Port_684781_1 | CABLE | ELECTRICAL
Port_684812_1 | CABLE | ELECTRICAL
Port_684837_1 | CABLE | ELECTRICAL
Port_684874_1 | CABLE | ELECTRICAL
Port_684909_1 | CABLE | ELECTRICAL
Port_684943_1 | CABLE | ELECTRICAL
Port_684986_1 | CABLE | ELECTRICAL
Port_685035_1 | CABLE | ELECTRICAL
Port_685240_1 | CABLE | ELECTRICAL
Port_685274_1 | CABLE | ELECTRICAL
Port_685320_1 | CABLE | ELECTRICAL
Port_685342_1 | CABLE | ELECTRICAL
Port_685433_1 | CABLE | ELECTRICAL
Port_685455_1 | CABLE | ELECTRICAL
Port_685477_1 | CABLE | ELECTRICAL
Port_685517_1 | CABLE | ELECTRICAL
Port_685563_1 | CABLE | ELECTRICAL
Port_685618_1 | CABLE | ELECTRICAL
Port_685670_1 | CABLE | ELECTRICAL
Port_685710_1 | CABLE | ELECTRICAL
Port_685762_1 | CABLE | ELECTRICAL
Port_685796_1 | CABLE | ELECTRICAL
Port_685827_1 | CABLE | ELECTRICAL
Port_686179_1 | CABLE | ELECTRICAL
Port_686187_1 | CABLE | ELECTRICAL
Port_686215_1 | CABLE | ELECTRICAL
Port_686550_1 | CABLE | ELECTRICAL
Port_686677_1 | CABLE | ELECTRICAL
Port_686682_1 | CABLE | ELECTRICAL
Port_686690_1 | CABLE | ELECTRICAL
Port_686695_1 | CABLE | ELECTRICAL
Port_687074_1 | CABLE | ELECTRICAL
Port_687085_1 | CABLE | ELECTRICAL
Port_687113_1 | CABLE | ELECTRICAL
Port_687150_1 | CABLE | ELECTRICAL
Port_687190_1 | CABLE | ELECTRICAL
Port_687360_1 | CABLE | ELECTRICAL
Port_687442_1 | CABLE | ELECTRICAL
Port_687494_1 | CABLE | ELECTRICAL
Port_687528_1 | CABLE | ELECTRICAL
Port_687571_1 | CABLE | ELECTRICAL
Port_687759_1 | CABLE | ELECTRICAL
Port_687793_1 | CABLE | ELECTRICAL
Port_687830_1 | CABLE | ELECTRICAL
Port_688004_1 | CABLE | ELECTRICAL
Port_688053_1 | CABLE | ELECTRICAL
Port_688276_1 | CABLE | ELECTRICAL
Port_688310_1 | CABLE | ELECTRICAL
Port_688335_1 | CABLE | ELECTRICAL
Port_688375_1 | CABLE | ELECTRICAL
Port_688571_1 | CABLE | ELECTRICAL
Port_688593_1 | CABLE | ELECTRICAL
Port_688639_1 | CABLE | ELECTRICAL
Port_688667_1 | CABLE | ELECTRICAL
Port_688714_1 | CABLE | ELECTRICAL
Port_688745_1 | CABLE | ELECTRICAL
Port_688761_1 | CABLE | ELECTRICAL
Port_688795_1 | CABLE | ELECTRICAL
Port_688890_1 | CABLE | ELECTRICAL
Port_688915_1 | CABLE | ELECTRICAL
Port_688943_1 | CABLE | ELECTRICAL
Port_688974_1 | CABLE | ELECTRICAL
Port_689060_1 | CABLE | ELECTRICAL
Port_689106_1 | CABLE | ELECTRICAL
Port_689173_1 | CABLE | ELECTRICAL
Port_689216_1 | CABLE | ELECTRICAL
Port_689266_1 | CABLE | ELECTRICAL
Port_689288_1 | CABLE | ELECTRICAL
Port_689310_1 | CABLE | ELECTRICAL
Port_690983_1 | CABLE | ELECTRICAL
Port_690996_1 | CABLE | ELECTRICAL
Port_691478_1 | CABLE | ELECTRICAL
Port_691947_1 | CABLE | ELECTRICAL
Port_692209_1 | CABLE | ELECTRICAL
Port_692653_1 | CABLE | ELECTRICAL
Port_692813_1 | CABLE | ELECTRICAL
Port_693126_1 | CABLE | ELECTRICAL
Port_693399_1 | CABLE | ELECTRICAL
Port_693631_1 | CABLE | ELECTRICAL
Port_693962_1 | CABLE | ELECTRICAL
Port_694113_1 | CABLE | ELECTRICAL
Port_694349_1 | CABLE | ELECTRICAL
Port_694683_1 | CABLE | ELECTRICAL
Port_695109_1 | CABLE | ELECTRICAL
Port_695531_1 | CABLE | ELECTRICAL
Port_695779_1 | CABLE | ELECTRICAL
Port_697172_1 | CABLE | ELECTRICAL
Port_697235_1 | CABLE | ELECTRICAL
Port_697245_1 | CABLE | ELECTRICAL
Port_697274_1 | CABLE | ELECTRICAL
Port_697297_1 | CABLE | ELECTRICAL
Port_697319_1 | CABLE | ELECTRICAL
Port_697368_1 | CABLE | ELECTRICAL
Port_697531_1 | CABLE | ELECTRICAL
Port_697545_1 | CABLE | ELECTRICAL
Port_697701_1 | CABLE | ELECTRICAL
Port_698046_1 | CABLE | ELECTRICAL
Port_698262_1 | CABLE | ELECTRICAL
Port_698417_1 | CABLE | ELECTRICAL
Port_698923_1 | CABLE | ELECTRICAL
Port_699137_1 | CABLE | ELECTRICAL
Port_699283_1 | CABLE | ELECTRICAL
Port_699515_1 | CABLE | ELECTRICAL
Port_700025_1 | CABLE | ELECTRICAL
Port_700346_1 | CABLE | ELECTRICAL
Port_700754_1 | CABLE | ELECTRICAL
Port_700991_1 | CABLE | ELECTRICAL
Port_701398_1 | CABLE | ELECTRICAL
Port_701668_1 | CABLE | ELECTRICAL
Port_702114_1 | CABLE | ELECTRICAL
Port_702390_1 | CABLE | ELECTRICAL
Port_702656_1 | CABLE | ELECTRICAL
Port_703295_1 | CABLE | ELECTRICAL
Port_703302_1 | CABLE | ELECTRICAL
Port_703309_1 | CABLE | ELECTRICAL
Port_703316_1 | CABLE | ELECTRICAL
Port_703323_1 | CABLE | ELECTRICAL
Port_703330_1 | CABLE | ELECTRICAL
Port_703337_1 | CABLE | ELECTRICAL
Port_703344_1 | CABLE | ELECTRICAL
Port_703351_1 | CABLE | ELECTRICAL
Port_703358_1 | CABLE | ELECTRICAL
Port_703365_1 | CABLE | ELECTRICAL
Port_703372_1 | CABLE | ELECTRICAL
Port_703379_1 | CABLE | ELECTRICAL
Port_703386_1 | CABLE | ELECTRICAL
Port_703393_1 | CABLE | ELECTRICAL
Port_703400_1 | CABLE | ELECTRICAL
Port_703407_1 | CABLE | ELECTRICAL
Port_703414_1 | CABLE | ELECTRICAL
Port_703421_1 | CABLE | ELECTRICAL
Port_703428_1 | CABLE | ELECTRICAL
Port_703435_1 | CABLE | ELECTRICAL
Port_703442_1 | CABLE | ELECTRICAL
Port_703449_1 | CABLE | ELECTRICAL
Port_703456_1 | CABLE | ELECTRICAL
Port_703463_1 | CABLE | ELECTRICAL
Port_703470_1 | CABLE | ELECTRICAL
Port_703477_1 | CABLE | ELECTRICAL
Port_703484_1 | CABLE | ELECTRICAL
Port_703491_1 | CABLE | ELECTRICAL
Port_703498_1 | CABLE | ELECTRICAL
Port_703505_1 | CABLE | ELECTRICAL
Port_703512_1 | CABLE | ELECTRICAL
Port_703519_1 | CABLE | ELECTRICAL
Port_703526_1 | CABLE | ELECTRICAL
Port_703533_1 | CABLE | ELECTRICAL
Port_703540_1 | CABLE | ELECTRICAL
Port_703547_1 | CABLE | ELECTRICAL
Port_703554_1 | CABLE | ELECTRICAL
Port_703561_1 | CABLE | ELECTRICAL
Port_703568_1 | CABLE | ELECTRICAL
Port_703575_1 | CABLE | ELECTRICAL
Port_703582_1 | CABLE | ELECTRICAL
Port_703589_1 | CABLE | ELECTRICAL
Port_703596_1 | CABLE | ELECTRICAL
Port_703603_1 | CABLE | ELECTRICAL
Port_703610_1 | CABLE | ELECTRICAL
Port_703617_1 | CABLE | ELECTRICAL
Port_703624_1 | CABLE | ELECTRICAL
Port_703631_1 | CABLE | ELECTRICAL
Port_703638_1 | CABLE | ELECTRICAL
Port_703645_1 | CABLE | ELECTRICAL
Port_703652_1 | CABLE | ELECTRICAL
Port_703659_1 | CABLE | ELECTRICAL
Port_703666_1 | CABLE | ELECTRICAL
Port_703673_1 | CABLE | ELECTRICAL
Port_703680_1 | CABLE | ELECTRICAL
Port_703765_1 | CABLE | ELECTRICAL
Port_703780_1 | CABLE | ELECTRICAL
Port_703955_1 | CABLE | ELECTRICAL
Port_703965_1 | CABLE | ELECTRICAL
Port_703970_1 | CABLE | ELECTRICAL
Port_703975_1 | CABLE | ELECTRICAL
Port_703980_1 | CABLE | ELECTRICAL
Port_703985_1 | CABLE | ELECTRICAL
Port_703990_1 | CABLE | ELECTRICAL
Port_704155_1 | CABLE | ELECTRICAL
Port_704160_1 | CABLE | ELECTRICAL
Port_704165_1 | CABLE | ELECTRICAL
Port_704170_1 | CABLE | ELECTRICAL
Port_704175_1 | CABLE | ELECTRICAL
Port_704180_1 | CABLE | ELECTRICAL
Port_704185_1 | CABLE | ELECTRICAL
Port_704190_1 | CABLE | ELECTRICAL
Port_704195_1 | CABLE | ELECTRICAL
Port_704200_1 | CABLE | ELECTRICAL
Port_704205_1 | CABLE | ELECTRICAL
Port_704210_1 | CABLE | ELECTRICAL
Port_704215_1 | CABLE | ELECTRICAL
Port_704342_1 | CABLE | ELECTRICAL
Port_704392_1 | CABLE | ELECTRICAL
Port_704397_1 | CABLE | ELECTRICAL
Port_704402_1 | CABLE | ELECTRICAL
Port_704407_1 | CABLE | ELECTRICAL
Port_704412_1 | CABLE | ELECTRICAL
Port_704417_1 | CABLE | ELECTRICAL
Port_704422_1 | CABLE | ELECTRICAL
Port_704427_1 | CABLE | ELECTRICAL
Port_704432_1 | CABLE | ELECTRICAL
Port_704437_1 | CABLE | ELECTRICAL
Port_704442_1 | CABLE | ELECTRICAL
Port_704447_1 | CABLE | ELECTRICAL
Port_704452_1 | CABLE | ELECTRICAL
Port_704460_1 | CABLE | ELECTRICAL
Port_704465_1 | CABLE | ELECTRICAL
Port_704470_1 | CABLE | ELECTRICAL
Port_704495_1 | CABLE | ELECTRICAL
Port_704496_1 | CABLE | ELECTRICAL
Port_704497_1 | CABLE | ELECTRICAL
Port_704498_1 | CABLE | ELECTRICAL
Port_704508_1 | CABLE | ELECTRICAL
Port_704509_1 | CABLE | ELECTRICAL
Port_704510_1 | CABLE | ELECTRICAL
Port_704511_1 | CABLE | ELECTRICAL
Port_704529_6 | CABLE | DATA
Port_704529_7 | CABLE | ELECTRICAL
Port_704538_1 | CABLE | ELECTRICAL
Port_704543_1 | CABLE | ELECTRICAL
Port_704548_1 | CABLE | ELECTRICAL
Port_704553_1 | CABLE | ELECTRICAL
Port_704568_1 | CABLE | ELECTRICAL
Port_704612_1 | CABLE | ELECTRICAL
Port_704617_1 | CABLE | ELECTRICAL
Port_704625_1 | CABLE | ELECTRICAL
Port_704625_2 | CABLE | ELECTROACOUSTIC
Port_704625_3 | CABLE | SECURITY
Port_704625_4 | CABLE | CONTROL
Port_704625_5 | CABLE | VENTILATION
Port_704677_1 | CABLE | ELECTRICAL
Port_704684_1 | CABLE | ELECTRICAL
Port_704691_1 | CABLE | ELECTRICAL
Port_704698_1 | CABLE | ELECTRICAL
Port_704957_1 | CABLE | ELECTRICAL
Port_704964_1 | CABLE | ELECTRICAL
Port_704971_1 | CABLE | ELECTRICAL
Port_704978_1 | CABLE | ELECTRICAL
Port_704985_1 | CABLE | ELECTRICAL
Port_704992_1 | CABLE | ELECTRICAL
Port_704999_1 | CABLE | ELECTRICAL
Port_705006_1 | CABLE | ELECTRICAL
Port_705344_1 | CABLE | ELECTRICAL
Port_705345_1 | CABLE | ELECTRICAL
Port_705346_1 | CABLE | ELECTRICAL
Port_705347_1 | CABLE | ELECTRICAL
Port_705357_1 | CABLE | ELECTRICAL
Port_705358_1 | CABLE | ELECTRICAL
Port_705359_1 | CABLE | ELECTRICAL
Port_705360_1 | CABLE | ELECTRICAL
Port_705370_1 | CABLE | ELECTRICAL
Port_705371_1 | CABLE | ELECTRICAL
Port_705372_1 | CABLE | ELECTRICAL
Port_705373_1 | CABLE | ELECTRICAL
Port_706190_1 | CABLE | ELECTRICAL
Port_706202_1 | CABLE | ELECTRICAL
Port_706227_1 | CABLE | ELECTRICAL
Port_706252_1 | CABLE | ELECTRICAL
Port_706277_1 | CABLE | ELECTRICAL
Port_706433_1 | CABLE | ELECTRICAL
Port_706467_1 | CABLE | ELECTRICAL
Port_706504_1 | CABLE | ELECTRICAL
Port_706558_1 | CABLE | ELECTRICAL
Port_706778_1 | CABLE | ELECTRICAL
Port_706813_1 | CABLE | ELECTRICAL
Port_706836_1 | CABLE | ELECTRICAL
Port_706975_1 | CABLE | ELECTRICAL
Port_706980_1 | CABLE | ELECTRICAL
Port_706985_1 | CABLE | ELECTRICAL
Port_706990_1 | CABLE | ELECTRICAL
Port_706995_1 | CABLE | ELECTRICAL
Port_707000_1 | CABLE | ELECTRICAL
Port_707005_1 | CABLE | ELECTRICAL
Port_707010_1 | CABLE | ELECTRICAL
Port_707018_1 | CABLE | ELECTRICAL
Port_707028_1 | CABLE | ELECTRICAL
Port_707225_1 | CABLE | ELECTRICAL
Port_707234_1 | CABLE | ELECTRICAL
Port_707592_1 | CABLE | ELECTRICAL
Port_707618_1 | CABLE | ELECTRICAL
Port_707623_1 | CABLE | ELECTRICAL
Port_707628_1 | CABLE | ELECTRICAL
Port_707633_1 | CABLE | ELECTRICAL
Port_707638_1 | CABLE | ELECTRICAL
Port_707646_1 | CABLE | ELECTRICAL
Port_707651_1 | CABLE | ELECTRICAL
Port_707656_1 | CABLE | ELECTRICAL
Port_707684_1 | CABLE | ELECTRICAL
Port_707694_1 | CABLE | ELECTRICAL
Port_708098_1 | CABLE | ELECTRICAL
Port_708289_1 | CABLE | ELECTRICAL
Port_709195_1 | CABLE | ELECTRICAL
Port_709232_1 | CABLE | ELECTRICAL
Port_710760_1 | CABLE | ELECTRICAL
Port_710765_1 | CABLE | ELECTRICAL
Port_711979_1 | CABLE | ELECTRICAL
Port_711984_1 | CABLE | ELECTRICAL
Port_711992_1 | CABLE | ELECTRICAL
Port_711997_1 | CABLE | ELECTRICAL
Port_712002_1 | CABLE | ELECTRICAL
Port_712007_1 | CABLE | ELECTRICAL
Port_712020_1 | CABLE | ELECTRICAL
Port_712025_1 | CABLE | ELECTRICAL
Port_712070_1 | CABLE | ELECTRICAL
Port_712075_1 | CABLE | ELECTRICAL
Port_712086_1 | CABLE | ELECTRICAL
Port_712091_1 | CABLE | ELECTRICAL
Port_712209_1 | CABLE | ELECTRICAL
Port_712223_1 | CABLE | ELECTRICAL
Port_712606_1 | CABLE | ELECTRICAL
Port_712909_1 | CABLE | ELECTRICAL
Port_712955_1 | CABLE | ELECTRICAL
Port_713181_1 | CABLE | ELECTRICAL
Port_713577_1 | CABLE | ELECTRICAL
Port_714002_1 | CABLE | ELECTRICAL
Port_714420_1 | CABLE | ELECTRICAL
Port_715841_1 | CABLE | ELECTRICAL
Port_715858_1 | CABLE | ELECTRICAL
Port_716244_1 | CABLE | ELECTRICAL
Port_716249_1 | CABLE | ELECTRICAL
Port_716257_1 | CABLE | ELECTRICAL
Port_716262_1 | CABLE | ELECTRICAL
Port_716267_1 | CABLE | ELECTRICAL
Port_716272_1 | CABLE | ELECTRICAL
Port_716288_1 | CABLE | ELECTRICAL
Port_716293_1 | CABLE | ELECTRICAL
Port_716329_1 | CABLE | ELECTRICAL
Port_716337_1 | CABLE | ELECTRICAL
Port_716349_1 | CABLE | ELECTRICAL
Port_716357_1 | CABLE | ELECTRICAL
Port_716367_1 | CABLE | ELECTRICAL
Port_716375_1 | CABLE | ELECTRICAL
Port_716402_1 | CABLE | ELECTRICAL
Port_716427_1 | CABLE | ELECTRICAL
Port_716435_1 | CABLE | ELECTRICAL
Port_716443_1 | CABLE | ELECTRICAL
Port_716451_1 | CABLE | ELECTRICAL
Port_716459_1 | CABLE | ELECTRICAL
Port_716475_1 | CABLE | ELECTRICAL
Port_716480_1 | CABLE | ELECTRICAL
Port_716490_1 | CABLE | ELECTRICAL
Port_716495_1 | CABLE | ELECTRICAL
Port_716521_1 | CABLE | ELECTRICAL
Port_716541_1 | CABLE | ELECTRICAL
Port_716546_1 | CABLE | ELECTRICAL
Port_716551_1 | CABLE | ELECTRICAL
Port_716556_1 | CABLE | ELECTRICAL
Port_716564_1 | CABLE | ELECTRICAL
Port_716578_1 | CABLE | ELECTRICAL
Port_716583_1 | CABLE | ELECTRICAL
Port_716588_1 | CABLE | ELECTRICAL
Port_716593_1 | CABLE | ELECTRICAL
Port_716598_1 | CABLE | ELECTRICAL
Port_716603_1 | CABLE | ELECTRICAL
Port_716611_1 | CABLE | ELECTRICAL
Port_716616_1 | CABLE | ELECTRICAL
Port_716621_1 | CABLE | ELECTRICAL
Port_716626_1 | CABLE | ELECTRICAL
Port_716743_1 | CABLE | ELECTRICAL
Port_716748_1 | CABLE | ELECTRICAL
Port_716753_1 | CABLE | ELECTRICAL
Port_716758_1 | CABLE | ELECTRICAL
Port_716763_1 | CABLE | ELECTRICAL
Port_716768_1 | CABLE | ELECTRICAL
Port_733604_1 | CABLE | ELECTRICAL
Port_733616_1 | CABLE | ELECTRICAL
Port_733616_2 | CABLE | ELECTROACOUSTIC
Port_733616_3 | CABLE | SECURITY
Port_733616_4 | CABLE | CONTROL
Port_733616_5 | CABLE | VENTILATION
Port_733624_1 | CABLE | ELECTRICAL
Port_733624_2 | CABLE | ELECTROACOUSTIC
Port_733624_3 | CABLE | SECURITY
Port_733624_4 | CABLE | CONTROL
Port_733624_5 | CABLE | VENTILATION
Port_733635_1 | CABLE | ELECTRICAL
Port_733635_2 | CABLE | ELECTROACOUSTIC
Port_733635_3 | CABLE | SECURITY
Port_733635_4 | CABLE | CONTROL
Port_733635_5 | CABLE | VENTILATION
Port_733643_1 | CABLE | ELECTRICAL
Port_733643_2 | CABLE | ELECTROACOUSTIC
Port_733643_3 | CABLE | SECURITY
Port_733643_4 | CABLE | CONTROL
Port_733643_5 | CABLE | VENTILATION
Port_733651_1 | CABLE | ELECTRICAL
Port_733651_2 | CABLE | ELECTROACOUSTIC
Port_733651_3 | CABLE | SECURITY
Port_733651_4 | CABLE | CONTROL
Port_733651_5 | CABLE | VENTILATION
Port_733659_1 | CABLE | ELECTRICAL
Port_733659_2 | CABLE | ELECTROACOUSTIC
Port_733659_3 | CABLE | SECURITY
Port_733659_4 | CABLE | CONTROL
Port_733659_5 | CABLE | VENTILATION
Port_734382_1 | CABLE | ELECTRICAL
Port_734390_1 | CABLE | ELECTRICAL
Port_734390_2 | CABLE | ELECTROACOUSTIC
Port_734390_3 | CABLE | SECURITY
Port_734390_4 | CABLE | CONTROL
Port_734390_5 | CABLE | VENTILATION
Port_734414_1 | CABLE | ELECTRICAL
Port_734782_1 | CABLE | ELECTRICAL
Port_734796_1 | CABLE | ELECTRICAL
Port_734796_2 | CABLE | ELECTROACOUSTIC
Port_734796_3 | CABLE | SECURITY
Port_734796_4 | CABLE | CONTROL
Port_734796_5 | CABLE | VENTILATION
Port_735427_1 | CABLE | ELECTRICAL
Port_735427_2 | CABLE | ELECTROACOUSTIC
Port_735427_3 | CABLE | SECURITY
Port_735427_4 | CABLE | CONTROL
Port_735427_5 | CABLE | VENTILATION
Port_735435_1 | CABLE | ELECTRICAL
Port_735435_2 | CABLE | ELECTROACOUSTIC
Port_735435_3 | CABLE | SECURITY
Port_735435_4 | CABLE | CONTROL
Port_735435_5 | CABLE | VENTILATION
Port_735446_1 | CABLE | ELECTRICAL
Port_735451_1 | CABLE | ELECTRICAL
Port_735473_1 | CABLE | ELECTRICAL
Port_735478_1 | CABLE | ELECTRICAL
Port_735608_1 | CABLE | ELECTRICAL
Port_735608_2 | CABLE | ELECTROACOUSTIC
Port_735608_3 | CABLE | SECURITY
Port_735608_4 | CABLE | CONTROL
Port_735608_5 | CABLE | VENTILATION
Port_735657_1 | CABLE | ELECTRICAL
Port_735657_2 | CABLE | ELECTROACOUSTIC
Port_735657_3 | CABLE | SECURITY
Port_735657_4 | CABLE | CONTROL
Port_735657_5 | CABLE | VENTILATION
Port_735668_1 | CABLE | ELECTRICAL
Port_735709_1 | CABLE | ELECTRICAL
Port_735736_1 | CABLE | ELECTRICAL
Port_735766_1 | CABLE | ELECTRICAL
Port_735795_1 | CABLE | ELECTRICAL
Port_735800_1 | CABLE | ELECTRICAL
Port_735805_1 | CABLE | ELECTRICAL
Port_735813_1 | CABLE | ELECTRICAL
Port_735813_2 | CABLE | ELECTROACOUSTIC
Port_735813_3 | CABLE | SECURITY
Port_735813_4 | CABLE | CONTROL
Port_735813_5 | CABLE | VENTILATION
Port_735821_1 | CABLE | ELECTRICAL
Port_735821_2 | CABLE | ELECTROACOUSTIC
Port_735821_3 | CABLE | SECURITY
Port_735821_4 | CABLE | CONTROL
Port_735821_5 | CABLE | VENTILATION
Port_735829_1 | CABLE | ELECTRICAL
Port_735829_2 | CABLE | ELECTROACOUSTIC
Port_735829_3 | CABLE | SECURITY
Port_735829_4 | CABLE | CONTROL
Port_735829_5 | CABLE | VENTILATION
Port_735898_1 | CABLE | ELECTRICAL
Port_735903_1 | CABLE | ELECTRICAL
Port_735908_1 | CABLE | ELECTRICAL
Port_735924_1 | CABLE | ELECTRICAL
Port_735924_2 | CABLE | ELECTROACOUSTIC
Port_735924_3 | CABLE | SECURITY
Port_735924_4 | CABLE | CONTROL
Port_735924_5 | CABLE | VENTILATION
Port_735932_1 | CABLE | ELECTRICAL
Port_735932_2 | CABLE | ELECTROACOUSTIC
Port_735932_3 | CABLE | SECURITY
Port_735932_4 | CABLE | CONTROL
Port_735932_5 | CABLE | VENTILATION
Port_735940_1 | CABLE | ELECTRICAL
Port_735940_2 | CABLE | ELECTROACOUSTIC
Port_735940_3 | CABLE | SECURITY
Port_735940_4 | CABLE | CONTROL
Port_735940_5 | CABLE | VENTILATION
Port_735956_1 | CABLE | ELECTRICAL
Port_735961_1 | CABLE | ELECTRICAL
Port_735966_1 | CABLE | ELECTRICAL
Port_735974_1 | CABLE | ELECTRICAL
Port_735974_2 | CABLE | ELECTROACOUSTIC
Port_735974_3 | CABLE | SECURITY
Port_735974_4 | CABLE | CONTROL
Port_735974_5 | CABLE | VENTILATION
Port_735982_1 | CABLE | ELECTRICAL
Port_735982_2 | CABLE | ELECTROACOUSTIC
Port_735982_3 | CABLE | SECURITY
Port_735982_4 | CABLE | CONTROL
Port_735982_5 | CABLE | VENTILATION
Port_735990_1 | CABLE | ELECTRICAL
Port_735990_2 | CABLE | ELECTROACOUSTIC
Port_735990_3 | CABLE | SECURITY
Port_735990_4 | CABLE | CONTROL
Port_735990_5 | CABLE | VENTILATION
Port_737884_1 | CABLE | ELECTRICAL
Port_737917_1 | CABLE | ELECTRICAL
Port_737929_1 | CABLE | ELECTRICAL
Port_737934_1 | CABLE | ELECTRICAL
Port_737942_1 | CABLE | ELECTRICAL
Port_737947_1 | CABLE | ELECTRICAL
Port_737957_1 | CABLE | ELECTRICAL
Port_737962_1 | CABLE | ELECTRICAL
Port_738011_1 | CABLE | ELECTRICAL
Port_738021_1 | CABLE | ELECTRICAL
Port_738033_1 | CABLE | ELECTRICAL
Port_738051_1 | CABLE | ELECTRICAL
Port_738074_1 | CABLE | ELECTRICAL
Port_738079_1 | CABLE | ELECTRICAL
Port_738084_1 | CABLE | ELECTRICAL
Port_738089_1 | CABLE | ELECTRICAL
Port_738104_1 | CABLE | ELECTRICAL
Port_738109_1 | CABLE | ELECTRICAL
Port_738124_1 | CABLE | ELECTRICAL
Port_738132_1 | CABLE | ELECTRICAL
Port_738132_2 | CABLE | ELECTROACOUSTIC
Port_738132_3 | CABLE | SECURITY
Port_738132_4 | CABLE | CONTROL
Port_738132_5 | CABLE | VENTILATION
Port_738140_1 | CABLE | ELECTRICAL
Port_738140_2 | CABLE | ELECTROACOUSTIC
Port_738140_3 | CABLE | SECURITY
Port_738140_4 | CABLE | CONTROL
Port_738140_5 | CABLE | VENTILATION
Port_738176_1 | CABLE | ELECTRICAL
Port_738176_2 | CABLE | ELECTROACOUSTIC
Port_738176_3 | CABLE | SECURITY
Port_738176_4 | CABLE | CONTROL
Port_738176_5 | CABLE | VENTILATION
Port_738188_1 | CABLE | ELECTRICAL
Port_738193_1 | CABLE | ELECTRICAL
Port_738201_1 | CABLE | ELECTRICAL
Port_738206_1 | CABLE | ELECTRICAL
Port_738211_1 | CABLE | ELECTRICAL
Port_738216_1 | CABLE | ELECTRICAL
Port_738221_1 | CABLE | ELECTRICAL
Port_738226_1 | CABLE | ELECTRICAL
Port_738234_1 | CABLE | ELECTRICAL
Port_738239_1 | CABLE | ELECTRICAL
Port_738247_1 | CABLE | ELECTRICAL
Port_738252_1 | CABLE | ELECTRICAL
Port_738283_1 | CABLE | ELECTRICAL
Port_738288_1 | CABLE | ELECTRICAL
Port_738293_1 | CABLE | ELECTRICAL
Port_738305_1 | CABLE | ELECTRICAL
Port_738305_2 | CABLE | ELECTROACOUSTIC
Port_738305_3 | CABLE | SECURITY
Port_738305_4 | CABLE | CONTROL
Port_738305_5 | CABLE | VENTILATION
Port_738362_1 | CABLE | ELECTRICAL
Port_738367_1 | CABLE | ELECTRICAL
Port_738568_0 | CABLECARRIER | CONVEYING
Port_769517_1 | CABLECARRIER | CONVEYING
Port_738568_1 | CABLECARRIER | CONVEYING
Port_738620_0 | CABLECARRIER | CONVEYING
Port_769087_2 | CABLECARRIER | CONVEYING
Port_738620_1 | CABLECARRIER | CONVEYING
Port_738994_1 | CABLE | ELECTRICAL
Port_738994_2 | CABLE | ELECTROACOUSTIC
Port_738994_3 | CABLE | SECURITY
Port_738994_4 | CABLE | CONTROL
Port_738994_5 | CABLE | VENTILATION
Port_739006_1 | CABLE | ELECTRICAL
Port_739006_2 | CABLE | ELECTROACOUSTIC
Port_739006_3 | CABLE | SECURITY
Port_739006_4 | CABLE | CONTROL
Port_739006_5 | CABLE | VENTILATION
Port_739018_1 | CABLE | ELECTRICAL
Port_739018_2 | CABLE | ELECTROACOUSTIC
Port_739018_3 | CABLE | SECURITY
Port_739018_4 | CABLE | CONTROL
Port_739018_5 | CABLE | VENTILATION
Port_739030_1 | CABLE | ELECTRICAL
Port_739030_2 | CABLE | ELECTROACOUSTIC
Port_739030_3 | CABLE | SECURITY
Port_739030_4 | CABLE | CONTROL
Port_739030_5 | CABLE | VENTILATION
Port_739042_1 | CABLE | ELECTRICAL
Port_739042_2 | CABLE | ELECTROACOUSTIC
Port_739042_3 | CABLE | SECURITY
Port_739042_4 | CABLE | CONTROL
Port_739042_5 | CABLE | VENTILATION
Port_739221_1 | CABLE | ELECTRICAL
Port_739226_1 | CABLE | ELECTRICAL
Port_739518_6 | CABLE | DATA
Port_739518_7 | CABLE | ELECTRICAL
Port_739535_1 | CABLE | ELECTRICAL
Port_739540_1 | CABLE | ELECTRICAL
Port_739545_1 | CABLE | ELECTRICAL
Port_739637_1 | CABLE | ELECTRICAL
Port_739645_1 | CABLE | ELECTRICAL
Port_739725_1 | CABLE | ELECTRICAL
Port_739734_0 | CABLECARRIER | CONVEYING
Port_739734_1 | CABLECARRIER | CONVEYING
Port_739871_1 | CABLE | ELECTRICAL
Port_739872_1 | CABLE | ELECTRICAL
Port_739873_1 | CABLE | ELECTRICAL
Port_739874_1 | CABLE | ELECTRICAL
Port_739912_0 | CABLECARRIER | CONVEYING
Port_739912_1 | CABLECARRIER | CONVEYING
Port_739914_1 | CABLE | ELECTRICAL
Port_739915_1 | CABLE | ELECTRICAL
Port_739916_1 | CABLE | ELECTRICAL
Port_739917_1 | CABLE | ELECTRICAL
Port_740012_1 | CABLE | ELECTRICAL
Port_740017_1 | CABLE | ELECTRICAL
Port_740022_1 | CABLE | ELECTRICAL
Port_740027_1 | CABLE | ELECTRICAL
Port_740032_1 | CABLE | ELECTRICAL
Port_740037_1 | CABLE | ELECTRICAL
Port_740042_1 | CABLE | ELECTRICAL
Port_740047_1 | CABLE | ELECTRICAL
Port_740052_1 | CABLE | ELECTRICAL
Port_740057_1 | CABLE | ELECTRICAL
Port_740062_1 | CABLE | ELECTRICAL
Port_740067_1 | CABLE | ELECTRICAL
Port_740105_0 | CABLECARRIER | CONVEYING
Port_740105_1 | CABLECARRIER | CONVEYING
Port_740107_1 | CABLE | ELECTRICAL
Port_740108_1 | CABLE | ELECTRICAL
Port_740109_1 | CABLE | ELECTRICAL
Port_740110_1 | CABLE | ELECTRICAL
Port_740337_0 | CABLECARRIER | CONVEYING
Port_740337_1 | CABLECARRIER | CONVEYING
Port_740494_1 | CABLE | ELECTRICAL
Port_740495_1 | CABLE | ELECTRICAL
Port_740513_1 | CABLE | ELECTRICAL
Port_740514_1 | CABLE | ELECTRICAL
Port_740515_1 | CABLE | ELECTRICAL
Port_740521_1 | CABLE | ELECTRICAL
Port_740522_1 | CABLE | ELECTRICAL
Port_740523_1 | CABLE | ELECTRICAL
Port_740529_1 | CABLE | ELECTRICAL
Port_740530_1 | CABLE | ELECTRICAL
Port_740531_1 | CABLE | ELECTRICAL
Port_740537_1 | CABLE | ELECTRICAL
Port_740538_1 | CABLE | ELECTRICAL
Port_740539_1 | CABLE | ELECTRICAL
Port_740545_1 | CABLE | ELECTRICAL
Port_740546_1 | CABLE | ELECTRICAL
Port_740547_1 | CABLE | ELECTRICAL
Port_740553_1 | CABLE | ELECTRICAL
Port_740554_1 | CABLE | ELECTRICAL
Port_740555_1 | CABLE | ELECTRICAL
Port_740561_1 | CABLE | ELECTRICAL
Port_740562_1 | CABLE | ELECTRICAL
Port_740563_1 | CABLE | ELECTRICAL
Port_740569_1 | CABLE | ELECTRICAL
Port_740570_1 | CABLE | ELECTRICAL
Port_740571_1 | CABLE | ELECTRICAL
Port_740698_1 | CABLE | ELECTRICAL
Port_740699_1 | CABLE | ELECTRICAL
Port_740700_1 | CABLE | ELECTRICAL
Port_740813_1 | CABLE | ELECTRICAL
Port_740814_1 | CABLE | ELECTRICAL
Port_740815_1 | CABLE | ELECTRICAL
Port_740822_1 | CABLE | ELECTRICAL
Port_740823_1 | CABLE | ELECTRICAL
Port_740824_1 | CABLE | ELECTRICAL
Port_740831_1 | CABLE | ELECTRICAL
Port_740832_1 | CABLE | ELECTRICAL
Port_740833_1 | CABLE | ELECTRICAL
Port_740839_1 | CABLE | ELECTRICAL
Port_740840_1 | CABLE | ELECTRICAL
Port_740841_1 | CABLE | ELECTRICAL
Port_740847_1 | CABLE | ELECTRICAL
Port_740848_1 | CABLE | ELECTRICAL
Port_740849_1 | CABLE | ELECTRICAL
Port_740855_1 | CABLE | ELECTRICAL
Port_740856_1 | CABLE | ELECTRICAL
Port_740857_1 | CABLE | ELECTRICAL
Port_740863_1 | CABLE | ELECTRICAL
Port_740864_1 | CABLE | ELECTRICAL
Port_740865_1 | CABLE | ELECTRICAL
Port_740871_1 | CABLE | ELECTRICAL
Port_740872_1 | CABLE | ELECTRICAL
Port_740873_1 | CABLE | ELECTRICAL
Port_744825_1 | CABLE | ELECTRICAL
Port_744836_1 | CABLE | ELECTRICAL
Port_744893_1 | CABLE | ELECTRICAL
Port_744898_1 | CABLE | ELECTRICAL
Port_745033_1 | CABLE | ELECTRICAL
Port_745034_1 | CABLE | ELECTRICAL
Port_745035_1 | CABLE | ELECTRICAL
Port_745042_1 | CABLE | ELECTRICAL
Port_745043_1 | CABLE | ELECTRICAL
Port_745044_1 | CABLE | ELECTRICAL
Port_745071_1 | CABLE | ELECTRICAL
Port_745078_1 | CABLE | ELECTRICAL
Port_745150_1 | CABLE | ELECTRICAL
Port_745157_1 | CABLE | ELECTRICAL
Port_745164_1 | CABLE | ELECTRICAL
Port_745170_1 | CABLE | ELECTRICAL
Port_745176_1 | CABLE | ELECTRICAL
Port_745182_1 | CABLE | ELECTRICAL
Port_745201_1 | CABLE | ELECTRICAL
Port_750243_1 | CABLE | ELECTRICAL
Port_750250_1 | CABLE | ELECTRICAL
Port_752261_1 | CABLE | ELECTRICAL
Port_752450_1 | CABLE | ELECTRICAL
Port_752455_1 | CABLE | ELECTRICAL
Port_752460_1 | CABLE | ELECTRICAL
Port_752465_1 | CABLE | ELECTRICAL
Port_752470_1 | CABLE | ELECTRICAL
Port_752475_1 | CABLE | ELECTRICAL
Port_752480_1 | CABLE | ELECTRICAL
Port_752485_1 | CABLE | ELECTRICAL
Port_752515_1 | CABLE | ELECTRICAL
Port_753185_1 | CABLE | ELECTRICAL
Port_753193_1 | CABLE | ELECTRICAL
Port_753201_1 | CABLE | ELECTRICAL
Port_753209_1 | CABLE | ELECTRICAL
Port_753372_1 | CABLE | ELECTRICAL
Port_753373_1 | CABLE | ELECTRICAL
Port_754856_1 | CABLE | ELECTRICAL
Port_754861_1 | CABLE | ELECTRICAL
Port_762448_0 | CABLECARRIER | CONVEYING
Port_762656_2 | CABLECARRIER | CONVEYING
Port_762448_1 | CABLECARRIER | CONVEYING
Port_762493_0 | CABLECARRIER | CONVEYING
Port_762555_2 | CABLECARRIER | CONVEYING
Port_762493_1 | CABLECARRIER | CONVEYING
Port_762863_1 | CABLECARRIER | CONVEYING
Port_762545_0 | CABLECARRIER | CONVEYING
Port_762555_1 | CABLECARRIER | CONVEYING
Port_762545_1 | CABLECARRIER | CONVEYING
Port_762656_1 | CABLECARRIER | CONVEYING
Port_762741_0 | CABLECARRIER | CONVEYING
Port_762862_2 | CABLECARRIER | CONVEYING
Port_762741_1 | CABLECARRIER | CONVEYING
Port_762863_2 | CABLECARRIER | CONVEYING
Port_764264_1 | CABLECARRIER | CONVEYING
Port_764347_1 | CABLECARRIER | CONVEYING
Port_764348_1 | CABLECARRIER | CONVEYING
Port_764458_1 | CABLECARRIER | CONVEYING
Port_764612_2 | CABLECARRIER | CONVEYING
Port_764458_2 | CABLECARRIER | CONVEYING
Port_764562_1 | CABLECARRIER | CONVEYING
Port_764612_1 | CABLECARRIER | CONVEYING
Port_765001_1 | CABLECARRIER | CONVEYING
Port_765001_2 | CABLECARRIER | CONVEYING
Port_765044_1 | CABLECARRIER | CONVEYING
Port_765046_2 | CABLECARRIER | CONVEYING
Port_765044_2 | CABLECARRIER | CONVEYING
Port_765045_1 | CABLECARRIER | CONVEYING
Port_765046_1 | CABLECARRIER | CONVEYING
Port_765047_1 | CABLECARRIER | CONVEYING
Port_765047_2 | CABLECARRIER | CONVEYING
Port_765203_1 | CABLECARRIER | CONVEYING
Port_765359_1 | CABLECARRIER | CONVEYING
Port_765203_2 | CABLECARRIER | CONVEYING
Port_765313_1 | CABLECARRIER | CONVEYING
Port_765313_2 | CABLECARRIER | CONVEYING
Port_765359_2 | CABLECARRIER | CONVEYING
Port_765458_0 | CABLECARRIER | CONVEYING
Port_765458_1 | CABLECARRIER | CONVEYING
Port_765522_1 | CABLECARRIER | CONVEYING
Port_765523_2 | CABLECARRIER | CONVEYING
Port_765523_1 | CABLECARRIER | CONVEYING
Port_765962_1 | CABLECARRIER | CONVEYING
Port_765962_2 | CABLECARRIER | CONVEYING
Port_765963_1 | CABLECARRIER | CONVEYING
Port_765963_2 | CABLECARRIER | CONVEYING
Port_766049_1 | CABLECARRIER | CONVEYING
Port_766049_0 | CABLECARRIER | CONVEYING
Port_766147_0 | CABLECARRIER | CONVEYING
Port_766147_1 | CABLECARRIER | CONVEYING
Port_766250_1 | CABLE | ELECTRICAL
Port_766252_1 | CABLE | ELECTRICAL
Port_766475_1 | CABLECARRIER | CONVEYING
Port_766475_2 | CABLECARRIER | CONVEYING
Port_766555_1 | CABLECARRIER | CONVEYING
Port_766555_2 | CABLECARRIER | CONVEYING
Port_766616_1 | CABLECARRIER | CONVEYING
Port_766616_2 | CABLECARRIER | CONVEYING
Port_766687_1 | CABLECARRIER | CONVEYING
Port_766687_2 | CABLECARRIER | CONVEYING
Port_766688_1 | CABLECARRIER | CONVEYING
Port_766688_2 | CABLECARRIER | CONVEYING
Port_767246_0 | CABLECARRIER | CONVEYING
Port_767246_1 | CABLECARRIER | CONVEYING
Port_767324_1 | CABLECARRIER | CONVEYING
Port_767247_1 | CABLECARRIER | CONVEYING
Port_767247_2 | CABLECARRIER | CONVEYING
Port_767324_2 | CABLECARRIER | CONVEYING
Port_767392_2 | CABLECARRIER | CONVEYING
Port_767435_1 | CABLECARRIER | CONVEYING
Port_767519_1 | CABLECARRIER | CONVEYING
Port_767435_2 | CABLECARRIER | CONVEYING
Port_767519_0 | CABLECARRIER | CONVEYING
Port_767707_1 | CABLECARRIER | CONVEYING
Port_767708_1 | CABLECARRIER | CONVEYING
Port_767707_2 | CABLECARRIER | CONVEYING
Port_767708_0 | CABLECARRIER | CONVEYING
Port_767724_0 | CABLECARRIER | CONVEYING
Port_767724_1 | CABLECARRIER | CONVEYING
Port_767953_0 | CABLECARRIER | CONVEYING
Port_772357_1 | CABLECARRIER | CONVEYING
Port_767953_1 | CABLECARRIER | CONVEYING
Port_772358_2 | CABLECARRIER | CONVEYING
Port_767988_2 | CABLECARRIER | CONVEYING
Port_768214_0 | CABLECARRIER | CONVEYING
Port_768055_1 | CABLECARRIER | CONVEYING
Port_768055_2 | CABLECARRIER | CONVEYING
Port_768152_0 | CABLECARRIER | CONVEYING
Port_768182_2 | CABLECARRIER | CONVEYING
Port_768152_1 | CABLECARRIER | CONVEYING
Port_768182_1 | CABLECARRIER | CONVEYING
Port_768214_1 | CABLECARRIER | CONVEYING
Port_768404_0 | CABLECARRIER | CONVEYING
Port_772357_2 | CABLECARRIER | CONVEYING
Port_768404_1 | CABLECARRIER | CONVEYING
Port_768451_1 | CABLECARRIER | CONVEYING
Port_768451_2 | CABLECARRIER | CONVEYING
Port_768457_0 | CABLECARRIER | CONVEYING
Port_768454_0 | CABLECARRIER | CONVEYING
Port_768455_2 | CABLECARRIER | CONVEYING
Port_768454_1 | CABLECARRIER | CONVEYING
Port_768547_2 | CABLECARRIER | CONVEYING
Port_768455_1 | CABLECARRIER | CONVEYING
Port_768457_1 | CABLECARRIER | CONVEYING
Port_768456_0 | CABLECARRIER | CONVEYING
Port_772358_1 | CABLECARRIER | CONVEYING
Port_768456_1 | CABLECARRIER | CONVEYING
Port_768547_1 | CABLECARRIER | CONVEYING
Port_768465_1 | CABLECARRIER | CONVEYING
Port_768465_2 | CABLECARRIER | CONVEYING
Port_768471_0 | CABLECARRIER | CONVEYING
Port_768466_1 | CABLECARRIER | CONVEYING
Port_768466_2 | CABLECARRIER | CONVEYING
Port_768470_0 | CABLECARRIER | CONVEYING
Port_768468_0 | CABLECARRIER | CONVEYING
Port_768469_2 | CABLECARRIER | CONVEYING
Port_768468_1 | CABLECARRIER | CONVEYING
Port_768636_2 | CABLECARRIER | CONVEYING
Port_768469_1 | CABLECARRIER | CONVEYING
Port_768471_1 | CABLECARRIER | CONVEYING
Port_768470_1 | CABLECARRIER | CONVEYING
Port_768636_1 | CABLECARRIER | CONVEYING
Port_768815_1 | CABLECARRIER | CONVEYING
Port_768815_2 | CABLECARRIER | CONVEYING
Port_769045_1 | CABLECARRIER | CONVEYING
Port_768905_1 | CABLECARRIER | CONVEYING
Port_768905_2 | CABLECARRIER | CONVEYING
Port_768950_1 | CABLECARRIER | CONVEYING
Port_768950_2 | CABLECARRIER | CONVEYING
Port_769132_0 | CABLECARRIER | CONVEYING
Port_769045_0 | CABLECARRIER | CONVEYING
Port_769087_1 | CABLECARRIER | CONVEYING
Port_769132_1 | CABLECARRIER | CONVEYING
Port_769182_0 | CABLECARRIER | CONVEYING
Port_769822_2 | CABLECARRIER | CONVEYING
Port_769182_1 | CABLECARRIER | CONVEYING
Port_769255_0 | CABLECARRIER | CONVEYING
Port_769255_1 | CABLECARRIER | CONVEYING
Port_769289_1 | CABLECARRIER | CONVEYING
Port_769289_2 | CABLECARRIER | CONVEYING
Port_769801_1 | CABLECARRIER | CONVEYING
Port_769290_1 | CABLECARRIER | CONVEYING
Port_769290_2 | CABLECARRIER | CONVEYING
Port_769291_1 | CABLECARRIER | CONVEYING
Port_769291_2 | CABLECARRIER | CONVEYING
Port_769292_0 | CABLECARRIER | CONVEYING
Port_769292_1 | CABLECARRIER | CONVEYING
Port_769293_0 | CABLECARRIER | CONVEYING
Port_769850_2 | CABLECARRIER | CONVEYING
Port_769293_1 | CABLECARRIER | CONVEYING
Port_769295_0 | CABLECARRIER | CONVEYING
Port_769295_1 | CABLECARRIER | CONVEYING
Port_769308_0 | CABLECARRIER | CONVEYING
Port_769758_1 | CABLECARRIER | CONVEYING
Port_769308_1 | CABLECARRIER | CONVEYING
Port_769759_2 | CABLECARRIER | CONVEYING
Port_769309_0 | CABLECARRIER | CONVEYING
Port_769645_2 | CABLECARRIER | CONVEYING
Port_769309_1 | CABLECARRIER | CONVEYING
Port_769758_2 | CABLECARRIER | CONVEYING
Port_769311_0 | CABLECARRIER | CONVEYING
Port_769849_1 | CABLECARRIER | CONVEYING
Port_769311_1 | CABLECARRIER | CONVEYING
Port_769759_1 | CABLECARRIER | CONVEYING
Port_769321_1 | CABLECARRIER | CONVEYING
Port_769323_1 | CABLECARRIER | CONVEYING
Port_769321_2 | CABLECARRIER | CONVEYING
Port_769322_0 | CABLECARRIER | CONVEYING
Port_769322_1 | CABLECARRIER | CONVEYING
Port_769380_2 | CABLECARRIER | CONVEYING
Port_769323_0 | CABLECARRIER | CONVEYING
Port_769517_2 | CABLECARRIER | CONVEYING
Port_769325_0 | CABLECARRIER | CONVEYING
Port_769644_1 | CABLECARRIER | CONVEYING
Port_769325_1 | CABLECARRIER | CONVEYING
Port_769380_1 | CABLECARRIER | CONVEYING
Port_769445_0 | CABLECARRIER | CONVEYING
Port_769644_2 | CABLECARRIER | CONVEYING
Port_769445_1 | CABLECARRIER | CONVEYING
Port_769645_1 | CABLECARRIER | CONVEYING
Port_769564_0 | CABLECARRIER | CONVEYING
Port_769849_2 | CABLECARRIER | CONVEYING
Port_769564_1 | CABLECARRIER | CONVEYING
Port_769850_1 | CABLECARRIER | CONVEYING
Port_769801_0 | CABLECARRIER | CONVEYING
Port_769822_1 | CABLECARRIER | CONVEYING
Port_769877_0 | CABLECARRIER | CONVEYING
Port_770048_1 | CABLECARRIER | CONVEYING
Port_769877_1 | CABLECARRIER | CONVEYING
Port_770049_2 | CABLECARRIER | CONVEYING
Port_769878_0 | CABLECARRIER | CONVEYING
Port_770437_2 | CABLECARRIER | CONVEYING
Port_769878_1 | CABLECARRIER | CONVEYING
Port_770048_2 | CABLECARRIER | CONVEYING
Port_769879_0 | CABLECARRIER | CONVEYING
Port_770277_1 | CABLECARRIER | CONVEYING
Port_769879_1 | CABLECARRIER | CONVEYING
Port_770049_1 | CABLECARRIER | CONVEYING
Port_770249_0 | CABLECARRIER | CONVEYING
Port_770277_2 | CABLECARRIER | CONVEYING
Port_770249_1 | CABLECARRIER | CONVEYING
Port_770339_0 | CABLECARRIER | CONVEYING
Port_770342_1 | CABLECARRIER | CONVEYING
Port_770339_1 | CABLECARRIER | CONVEYING
Port_770343_2 | CABLECARRIER | CONVEYING
Port_770340_0 | CABLECARRIER | CONVEYING
Port_770456_2 | CABLECARRIER | CONVEYING
Port_770340_1 | CABLECARRIER | CONVEYING
Port_770342_2 | CABLECARRIER | CONVEYING
Port_770341_0 | CABLECARRIER | CONVEYING
Port_770438_1 | CABLECARRIER | CONVEYING
Port_770341_1 | CABLECARRIER | CONVEYING
Port_770343_1 | CABLECARRIER | CONVEYING
Port_770423_0 | CABLECARRIER | CONVEYING
Port_770437_1 | CABLECARRIER | CONVEYING
Port_770423_1 | CABLECARRIER | CONVEYING
Port_770438_2 | CABLECARRIER | CONVEYING
Port_772106_0 | CABLECARRIER | CONVEYING
Port_772106_1 | CABLECARRIER | CONVEYING

# IfcLightFixture: Vývod_Osvětlení.CC:Vývod_Osvětlení (19)
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W; Zdánlivé zatížení: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 230 V
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 230V, osvětlení; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod_Osvětlení; Označení typu: 01; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Osvětlovací tělesa; Název rodiny: Vývod_Osvětlení.CC
Classification: KB00 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Osvětlení
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - CCI Funkční systém: K; CCI Komponenta: UAC; CCI Technický systém: HH
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000468875 m3
Jiné - Id typu: 273252; Rodina: Vývod_Osvětlení.CC; Rodina a typ: Vývod_Osvětlení.CC: Vývod_Osvětlení; Typ: Vývod_Osvětlení; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18
Name (Vývod_Osvětlení.CC:Vývod_Osvětlení:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
738247 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | KB00.01.0001 | 0001
738252 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2500 | KB00.01.0002 | 0002
752450 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0003 | 0003
752455 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0004 | 0004
752460 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0005 | 0005
752465 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0006 | 0006
752470 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0007 | 0007
752475 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0008 | 0008
752480 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0009 | 0009
752485 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0010 | 0010
752515 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0011 | 0011
753185 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0012 | 0012
753193 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0013 | 0013
753201 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0014 | 0014
753209 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0015 | 0015
753372 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0016 | 0016
753373 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | KB00.01.0017 | 0017
754856 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | KB00.01.0018 | 0018
754861 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | KB00.01.0019 | 0019
