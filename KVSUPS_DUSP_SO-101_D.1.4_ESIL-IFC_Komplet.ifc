Properties of the parts of a building model (IFC4), part 1 of 5

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: cceb0251-b5e7-4883-bf97-80c5808426ee, NumberOfSaves: 111], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-13T16:49:54
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject
Phase: SpD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 05/2023; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.05.19 10:16

# IfcBuilding, Budova E
LongName: Budova E
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 05/2023; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.05.19 10:16

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-101
In: Budova E
LongName: 2.NP_SO-101; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-101
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:07
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (4)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:07
1.NP_SO-101 | 1.NP_SO-101 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.21 10:54
3.NP_SO-101 | 3.NP_SO-101 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:07
4.NP_SO-101 | 4.NP_SO-101 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:07

# IfcBuildingElementProxy: DEHN jímač 3500_16-10 AlMgSi_103450:DEHN jímač tyče 3500_Algi_103450 (3)
Type - Material: 209_209_255, <Unnamed>
Type - Vazby - Výchozí výška: -423 mm
Type - Identifikační data - Číslo OmniClass: 23.85.80.11.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: BL01; Komentáře k typům: Konektor obecný; Model: Model; Nadpis OmniClass: Lighting Controls; Název typu: DEHN jímač tyče 3500_Algi_103450; Označení typu: 16; Popis: Konektor; Popis sestavy: Jímací tyč; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: DEHN jímač 3500_16-10 AlMgSi_103450
Classification: BL01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.159849 m2; NetVolume: 0.00058868 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - POČET FÁZÍ: 1; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XEF; CCI Technický systém: PD
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V
Grafika - Geometrie: yes
Kóty - Objem: 0.00058068 m3
Jiné - Páteřní trasa: yes; FAKTOR ÚČINNOSTI: 0; Id typu: 750205; Rodina: DEHN jímač 3500_16-10 AlMgSi_103450; Rodina a typ: DEHN jímač 3500_16-10 AlMgSi_103450: DEHN jímač tyče 3500_Algi_103450; Typ: DEHN jímač tyče 3500_Algi_103450; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:10
Name (DEHN jímač 3500_16-10 AlMgSi_103450:DEHN jímač tyče 3500_Algi_103450:...) | In | Výška od podlaží (mm) | Hostitel | Podlaží = Vztažné podlaží | Kód prvku | Označení
750243 | 4.NP_SO-101 | 0 | Podlaží : STŘECHA_SO-101 | STŘECHA_SO-101 | BL01.16.0016 | 0016
750250 | 1.NP_SO-101 | 23302.7 | Osamocené | 1.NP_SO-101 | BL01.16.0017 | 0017
752261 | 4.NP_SO-101 | 0 | Podlaží : STŘECHA_SO-101 | STŘECHA_SO-101 | BL01.16.0018 | 0018

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1A.1, Datový rozvaděč rack.CC:Rack 48U 600x800_1A.1:739518
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 800 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1A.1; Označení typu: 15; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.15.0015; Označení: 0015
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 739509; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1A.1; Typ: Rack 48U 600x800_1A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:56; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_3A.1, Datový rozvaděč rack.CC:Rack 48U 600x800_3A.1:704529
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 800 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_3A.1; Označení typu: 14; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 3.NP_SO-101; Hostitel: Podlaží : 3.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.14.0014; Označení: 0014
Jiné - Páteřní trasa: yes; Id typu: 704530; Rodina: Datový rozvaděč rack.CC; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_3A.1; Typ: Rack 48U 600x800_3A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:56; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Odpínač_400V.CC:ABB_Servisní vypínač OTP125B3M, Odpínač_400V.CC:ABB_Servisní vypínač OTP125B3M:667745
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Kóty - HLOUBKA: 60 mm; ŠÍŘKA: 130 mm; VÝŠKA: 150 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Indexovaná poznámka: 3-pólový odpínač, krytí IP65, 130x150x60; Kód sestavy: VY01; Model: OTP25B3M; Nadpis OmniClass: Switches and Receptacles; Název typu: ABB_Servisní vypínač OTP125B3M; Označení typu: 06; Popis: Odpínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Výrobce: ABB
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Odpínač_400V.CC; S1: 90 mm; V1: 120 mm
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.12052 m2; NetVolume: 0.00124237 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QBB; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 1250 mm; Výška od podlaží: 1250 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Odsazení svítidla: 0 mm; Rámeček: yes
Kóty - Objem: 0.00124237 m3
Identifikační data - Kód prvku: VY01.06.0036; Označení: 0036
Jiné - Id typu: 667711; Rodina: Odpínač_400V.CC; Rodina a typ: Odpínač_400V.CC: ABB_Servisní vypínač OTP125B3M; Typ: ABB_Servisní vypínač OTP125B3M; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:11

# IfcBuildingElementProxy: Odpínač_400V.CC:ABB_Servisní vypínač OTP25B3M (5)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Kóty - HLOUBKA: 60 mm; ŠÍŘKA: 130 mm; VÝŠKA: 150 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Indexovaná poznámka: 3-pólový odpínač, krytí IP65, 130x150x60; Kód sestavy: VY01; Model: OTP25B3M; Nadpis OmniClass: Switches and Receptacles; Název typu: ABB_Servisní vypínač OTP25B3M; Označení typu: 19; Popis: Odpínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Výrobce: ABB
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Odpínač_400V.CC; S1: 90 mm; V1: 120 mm
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.12052 m2; NetVolume: 0.00124237 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QBB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Odsazení svítidla: 0 mm; Rámeček: yes
Kóty - Objem: 0.00124237 m3
Jiné - Rodina: Odpínač_400V.CC; Id typu: 667715; Rodina a typ: Odpínač_400V.CC: ABB_Servisní vypínač OTP25B3M; Typ: ABB_Servisní vypínač OTP25B3M; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:11
Name (Odpínač_400V.CC:ABB_Servisní vypínač OTP25B3M:...) | In | Podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Hostitel | Kód prvku | Označení
733604 | -1.PP_SO-101 | -1.PP_SO-101 | 0 | Podlaží : -1.PP_SO-101 | VY01.19.0608 | 0608
734382 | 1.NP_SO-101 | 1.NP_SO-101 | 1500 | Podlaží : 1.NP_SO-101 | VY01.19.0615 | 0615
734782 | 2.NP_SO-101 | 2.NP_SO-101 | 1500 | Podlaží : 2.NP_SO-101 | VY01.19.0618 | 0618
735446 | 4.NP_SO-101 | 4.NP_SO-101 | 1500 | Podlaží : 4.NP_SO-101 | VY01.19.0622 | 0622
735451 | 4.NP_SO-101 | 4.NP_SO-101 | 1500 | Podlaží : 4.NP_SO-101 | VY01.19.0623 | 0623

# IfcBuildingElementProxy: Odpínač_400V.CC:Eaton_Servisní vypínač 13kW (2)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Kóty - HLOUBKA: 75 mm; ŠÍŘKA: 80 mm; VÝŠKA: 137 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Indexovaná poznámka: 3-pólový odpínač, 3+1Z 13kW 25A AC3; Kód sestavy: VY01; Model: 207295; Nadpis OmniClass: Switches and Receptacles; Název typu: Eaton_Servisní vypínač 13kW; Označení typu: 10; Popis: Odpínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Výrobce: Eaton
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Odpínač_400V.CC; S1: 80 mm; V1: 107 mm
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0928377 m2; NetVolume: 0.000882267 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QBB; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Rámeček: yes; Odsazení svítidla: 1050 mm
Kóty - Objem: 0.000882267 m3
Jiné - Rodina: Odpínač_400V.CC; Id typu: 667723; Rodina a typ: Odpínač_400V.CC: Eaton_Servisní vypínač 13kW; Typ: Eaton_Servisní vypínač 13kW; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:12
Name (Odpínač_400V.CC:Eaton_Servisní vypínač 13kW:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
669923 | 1500 | VY01.10.0097 | 0097
671814 | 1250 | VY01.10.0138 | 0138

# IfcBuildingElementProxy: Odpínač_400V.CC:Eaton_Servisní vypínač 37kW (4)
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Kóty - HLOUBKA: 75 mm; ŠÍŘKA: 80 mm; VÝŠKA: 137 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Indexovaná poznámka: 3-pólový odpínač, 3+1Z 37kW 63A AC3; Kód sestavy: VY01; Model: 207345; Nadpis OmniClass: Switches and Receptacles; Název typu: Eaton_Servisní vypínač 37kW; Označení typu: 09; Popis: Odpínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Výrobce: Eaton
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Odpínač_400V.CC; S1: 80 mm; V1: 107 mm
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0928377 m2; NetVolume: 0.000882267 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QBB; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Rámeček: yes; Odsazení svítidla: 1050 mm
Kóty - Objem: 0.000882267 m3
Jiné - Rodina: Odpínač_400V.CC; Id typu: 667727; Rodina a typ: Odpínač_400V.CC: Eaton_Servisní vypínač 37kW; Typ: Eaton_Servisní vypínač 37kW; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:12
Name (Odpínač_400V.CC:Eaton_Servisní vypínač 37kW:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
669745 | 1250 | VY01.09.0086 | 0086
669750 | 1250 | VY01.09.0087 | 0087
669913 | 1500 | VY01.09.0095 | 0095
669918 | 1500 | VY01.09.0096 | 0096

# IfcBuildingElementProxy: Odpínač_400V.CC:Eaton_Servisní vypínač 6,5kW (13)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1500 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V
Type - Kóty - HLOUBKA: 75 mm; ŠÍŘKA: 80 mm; VÝŠKA: 137 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Indexovaná poznámka: 3-pólový odpínač, 3+1Z 6,5kW 20A AC3; Kód sestavy: VY01; Model: 207150; Nadpis OmniClass: Switches and Receptacles; Název typu: Eaton_Servisní vypínač 6,5kW; Označení typu: 08; Popis: Odpínač; Popis sestavy: Vypínač; URL: www.cadconsulting.cz; Výrobce: Eaton
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Odpínač_400V.CC; S1: 80 mm; V1: 107 mm
Classification: VY01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0928377 m2; NetVolume: 0.000882267 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: QBB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes; Rámeček: yes; Odsazení svítidla: 1050 mm
Kóty - Objem: 0.000882267 m3
Jiné - Rodina: Odpínač_400V.CC; Id typu: 667729; Rodina a typ: Odpínač_400V.CC: Eaton_Servisní vypínač 6,5kW; Typ: Eaton_Servisní vypínač 6,5kW; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:11
Name (Odpínač_400V.CC:Eaton_Servisní vypínač 6,5kW:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
669737 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1250 | VY01.08.0085 | 0085
669837 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1250 | VY01.08.0088 | 0088
669908 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | VY01.08.0094 | 0094
735668 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0628 | 0628
735795 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0629 | 0629
735800 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0630 | 0630
735805 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0631 | 0631
735898 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0635 | 0635
735903 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0636 | 0636
735908 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0637 | 0637
735956 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0641 | 0641
735961 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0642 | 0642
735966 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 1500 | VY01.08.0643 | 0643

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 12 modulů (23)
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 12
Type - Kóty - DÉLKA: 215 mm; HLOUBKA: 50 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 12 modulů; Označení typu: 16; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 90 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.26051 m2
Text - CCI Funkční systém: K; CCI Komponenta: XDE; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - Materiál: Červená
Grafika - Úhel natočení: 0 deg; Víko: no; SESTAVA_POPIS: PPXX
Kóty - Objem: 0.00109618 m3
Jiné - Rodina: Podlahová krabice.CC; H: -55 mm; iD: 225 mm; Id typu: 318547; iH: 40 mm; iS: 265 mm; O: -40 mm; oD: 235 mm; oS: 275 mm; pm: 4; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 12 modulů; Typ: Podlahová krabice - 12 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:12
Name (Podlahová krabice.CC:Podlahová krabice - 12 modulů:...) | In | NetVolume (m3) | Podlaží | Hostitel | Kód prvku | Označení
695955 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0369 | 0369
695956 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0370 | 0370
695957 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0371 | 0371
695958 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0372 | 0372
695959 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0373 | 0373
695960 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0374 | 0374
695961 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0375 | 0375
695962 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0376 | 0376
695963 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0377 | 0377
695964 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0378 | 0378
695965 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0379 | 0379
695966 | 3.NP_SO-101 | 0.00109618 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0380 | 0380
695969 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0381 | 0381
695970 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0382 | 0382
704494 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0491 | 0491
704507 | 3.NP_SO-101 | 0.00109617 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | PQ00.16.0496 | 0496
704638 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0506 | 0506
704659 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0507 | 0507
704661 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0508 | 0508
704662 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0509 | 0509
705343 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0522 | 0522
705356 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0527 | 0527
705369 | 4.NP_SO-101 | 0.00109617 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | PQ00.16.0532 | 0532

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 18 modulů (2)
In: 2.NP_SO-101
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 18
Type - Kóty - DÉLKA: 255 mm; HLOUBKA: 65 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 18 modulů; Označení typu: 14; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 135 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.32467 m2; NetVolume: 0.00134997 m3
Text - CCI Funkční systém: K; CCI Komponenta: XDE; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-101; Hostitel: Podlaží : 2.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - Materiál: Červená
Grafika - SESTAVA_POPIS: PPXX; Úhel natočení: 0 deg; Víko: no
Kóty - Objem: 0.00134997 m3
Jiné - H: -70 mm; iD: 265 mm; Id typu: 330022; iH: 40 mm; iS: 265 mm; O: -55 mm; oD: 275 mm; oS: 275 mm; pm: 6; Rodina: Podlahová krabice.CC; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 18 modulů; Typ: Podlahová krabice - 18 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:13
Name (Podlahová krabice.CC:Podlahová krabice - 18 modulů:...) | Kód prvku | Označení
683850 | PQ00.14.0257 | 0257
683868 | PQ00.14.0258 | 0258

# IfcBuildingElementProxy: Pohybové čidlo stropní.CC:INFRAPASIVNÍ SNÍMAČ POHYBU, 360° (47)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; JMENOVITÝ PROUD: 0 A; TYP ZAŘÍZENÍ: Osvětlení
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ symbolu: Pohybové čidlo stropní, úhel záběru 360°.CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 40 mm; PRŮMĚR: 58 mm; Šířka: 80 mm; Výška: 40 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: INFRAPASIVNÍ SNÍMAČ POHYBU, 360°; Označení typu: 01; Popis: Popis; Popis sestavy: Pohybové čidlo; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Osvětlení; Název rodiny: Pohybové čidlo stropní.CC
Classification: VY02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0146924 m2; NetVolume: 0.000112747 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: BGA; CCI Technický systém: HH
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000112747 m3
Jiné - Id typu: 681680; Rodina: Pohybové čidlo stropní.CC; Rodina a typ: Pohybové čidlo stropní.CC: INFRAPASIVNÍ SNÍMAČ POHYBU, 360°; Typ: INFRAPASIVNÍ SNÍMAČ POHYBU, 360°; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59
Name (Pohybové čidlo stropní.CC:INFRAPASIVNÍ SNÍMAČ POHYBU, 360°:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
681698 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 1818.99 | VY02.01.0001 | 0001
681703 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0002 | 0002
681713 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0003 | 0003
681718 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0004 | 0004
681723 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0005 | 0005
681728 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0006 | 0006
681733 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0007 | 0007
681738 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0008 | 0008
681743 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0009 | 0009
681748 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3701.28 | VY02.01.0010 | 0010
681760 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0011 | 0011
681813 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.01.0020 | 0020
682113 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 1729.64 | VY02.01.0055 | 0055
682118 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0056 | 0056
682123 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0057 | 0057
682128 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0058 | 0058
682133 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0059 | 0059
686677 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0066 | 0066
686682 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.01.0067 | 0067
703955 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3950 | VY02.01.0070 | 0070
703965 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0071 | 0071
703970 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0072 | 0072
703975 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0073 | 0073
703980 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0074 | 0074
703985 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0075 | 0075
703990 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0076 | 0076
704342 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0090 | 0090
706980 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.01.0112 | 0112
706985 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.01.0113 | 0113
707000 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.01.0116 | 0116
707005 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 3750 | VY02.01.0117 | 0117
707010 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.01.0118 | 0118
707018 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.01.0119 | 0119
716257 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0131 | 0131
716427 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0144 | 0144
716435 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0145 | 0145
716443 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0146 | 0146
716451 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0147 | 0147
716459 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0148 | 0148
716521 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.01.0153 | 0153
716743 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0169 | 0169
716748 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0170 | 0170
716753 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0171 | 0171
716758 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0172 | 0172
716763 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0173 | 0173
716768 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0174 | 0174
738124 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.01.0185 | 0185

# IfcBuildingElementProxy: Pohybové čidlo stropní.CC:PŘÍTOMNOSTNÍ DETEKTOR, DALI (51)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; TYP ZAŘÍZENÍ: Osvětlení; JMENOVITÝ PROUD: 0 A
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Typ symbolu: Pohybové čidlo stropní, úhel záběru 360° přítomnostní .CC
Type - Kóty - Délka: 80 mm; HLOUBKA: 40 mm; PRŮMĚR: 58 mm; Šířka: 80 mm; Výška: 30 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.80.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VY02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Building Automation and Control; Název typu: PŘÍTOMNOSTNÍ DETEKTOR, DALI; Označení typu: 02; Popis: Popis; Popis sestavy: Pohybové čidlo; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Osvětlení; Název rodiny: Pohybové čidlo stropní.CC
Classification: VY02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0146924 m2; NetVolume: 0.000112747 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: BGA; CCI Technický systém: HH
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000112747 m3
Jiné - Rodina: Pohybové čidlo stropní.CC; Id typu: 681682; Rodina a typ: Pohybové čidlo stropní.CC: PŘÍTOMNOSTNÍ DETEKTOR, DALI; Typ: PŘÍTOMNOSTNÍ DETEKTOR, DALI; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:00
Name (Pohybové čidlo stropní.CC:PŘÍTOMNOSTNÍ DETEKTOR, DALI:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
681768 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0012 | 0012
681773 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0013 | 0013
681778 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0014 | 0014
681783 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0015 | 0015
681788 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0016 | 0016
681793 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0017 | 0017
681798 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0018 | 0018
681803 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0019 | 0019
681833 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3700 | VY02.02.0021 | 0021
682141 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | VY02.02.0060 | 0060
682146 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0061 | 0061
682151 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0062 | 0062
682156 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0063 | 0063
682161 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0064 | 0064
682166 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0065 | 0065
686690 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0068 | 0068
686695 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 3700 | VY02.02.0069 | 0069
704155 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0077 | 0077
704160 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0078 | 0078
704165 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0079 | 0079
704170 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0080 | 0080
704175 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0081 | 0081
704180 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0082 | 0082
704185 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0083 | 0083
704190 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0084 | 0084
704195 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0085 | 0085
704200 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0086 | 0086
704205 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0087 | 0087
704210 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0088 | 0088
704215 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | VY02.02.0089 | 0089
704538 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0107 | 0107
704543 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0108 | 0108
704548 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0109 | 0109
704553 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 3750 | VY02.02.0110 | 0110
706975 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.02.0111 | 0111
706990 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.02.0114 | 0114
706995 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | VY02.02.0115 | 0115
716262 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0132 | 0132
716267 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0133 | 0133
716272 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0134 | 0134
716329 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0137 | 0137
716337 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0138 | 0138
716349 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0139 | 0139
716357 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0140 | 0140
716367 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0141 | 0141
716375 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0142 | 0142
716402 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 2850 | VY02.02.0143 | 0143
716611 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.02.0165 | 0165
716616 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.02.0166 | 0166
716621 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.02.0167 | 0167
716626 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | VY02.02.0168 | 0168

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RHA.01.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RHA.01.1:657689
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; ÚČINÍK: 1
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 400 V; POČET FÁZÍ: 3
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 400 mm; ŠÍŘKA: 800 mm; VÝŠKA: 2100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RHA.01.1; Označení typu: 01; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.68 m2; NetVolume: 0.672 m3
Elektroinstalace – obvody - Klasifikace MCB: 1 A; Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.672 m3; Plocha: 2.84 m2
Identifikační data - Kód prvku: RV00.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Id typu: 657690; Rodina: Rozvaděč, rozvodnice.CC; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RHA.01.1; Typ: Rozvaděč NN - RHA.01.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:57

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RHA.01.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RHA.01.2:657748
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 400 mm; ŠÍŘKA: 800 mm; VÝŠKA: 2100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RHA.01.2; Označení typu: 02; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.68 m2; NetVolume: 0.672 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.672 m3; Plocha: 2.84 m2
Identifikační data - Kód prvku: RV00.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 657745; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RHA.01.2; Typ: Rozvaděč NN - RHA.01.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:58

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.01A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.01A.1:658692
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.01A.1; Označení typu: 03; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.03.0003; Označení: 0003
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 658689; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.01A.1; Typ: Rozvaděč NN - RP.01A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:58

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.01A.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.01A.2:658729
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 6000 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.01A.2; Označení typu: 04; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.04.0004; Označení: 0004
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 658726; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.01A.2; Typ: Rozvaděč NN - RP.01A.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.1:662368
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.1A.1; Označení typu: 06; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.06.0006; Označení: 0006
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 661166; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.1A.1; Typ: Rozvaděč NN - RP.1A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:58

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.2:662357
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.1A.2; Označení typu: 05; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 600 mm; Podlaží: 1.NP_SO-101; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.05.0005; Označení: 0005
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 661168; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.1A.2; Typ: Rozvaděč NN - RP.1A.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:58

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.3, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.1A.3:671756
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 400 mm; ŠÍŘKA: 800 mm; VÝŠKA: 2100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.1A.3; Označení typu: 13; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.68 m2; NetVolume: 0.672 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.672 m3; Plocha: 2.84 m2
Identifikační data - Kód prvku: RV00.13.0013; Označení: 0013
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 671753; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.1A.3; Typ: Rozvaděč NN - RP.1A.3; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.2A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.2A.1:662446
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.2A.1; Označení typu: 08; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Podlaží: 2.NP_SO-101; Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 600 mm; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.08.0008; Označení: 0008
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662101; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.2A.1; Typ: Rozvaděč NN - RP.2A.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.2A.2, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.2A.2:662425
In: 2.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
Type - Kóty - Délka: 300 mm; HLOUBKA: 250 mm; ŠÍŘKA: 800 mm; VÝŠKA: 1200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV00; Komentáře k typům: silnoproudý; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rozvaděč NN - RP.2A.2; Označení typu: 07; Popis: Rozvaděč; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozvaděč, rozvodnice.CC
Classification: RV00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.92 m2; NetVolume: 0.24 m3
Elektroinstalace – obvody - Možnost číslování obvodu: Výchozí; Podružné rozvaděče: yes; Připojení přes kabelová oka: yes; Klasifikace MCB: 1 A; TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W; PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: XDC; CCI Technický systém: HG
Vazby - Hostitel: Podlaží : 2.NP_SO-101; Odsazení od hostitele: 600 mm; Podlaží: 2.NP_SO-101; Výška od podlaží: 600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Odsazení symbolu od stěny: 25 mm
Kóty - Objem: 0.24 m3; Plocha: 1.46 m2
Identifikační data - Kód prvku: RV00.07.0007; Označení: 0007
Jiné - Páteřní trasa: yes; Rodina: Rozvaděč, rozvodnice.CC; Id typu: 662103; Rodina a typ: Rozvaděč, rozvodnice.CC: Rozvaděč NN - RP.2A.2; Typ: Rozvaděč NN - RP.2A.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:59

# IfcBuildingElementProxy: Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.1, Rozvaděč, rozvodnice.CC:Rozvaděč NN - RP.3A.1:662493
In: 3.NP_SO-101
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace - ÚČINÍK: 1; JMENOVITÝ PROUD: 0 A
Type - Vazby - Výchozí výška: 600 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Rozvaděč: yes; Rozvodnice: no
