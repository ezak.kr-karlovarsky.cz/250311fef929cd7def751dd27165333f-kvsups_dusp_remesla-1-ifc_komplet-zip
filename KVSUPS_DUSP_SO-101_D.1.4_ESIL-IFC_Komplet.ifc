Properties of the parts of a building model (IFC4), part 3 of 5

# IfcBuildingElementProxy: Vývod.CC:Vývod 230V ukončený v krabici (47)
Name (Vývod.CC:Vývod 230V ukončený v krabici:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
738305 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 600 | KB00.03.0672 | 0672
738994 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0673 | 0673
739006 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0674 | 0674
739018 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0675 | 0675
739030 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0676 | 0676
739042 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | KB00.03.0677 | 0677

# IfcBuildingElementProxy: Vývod.CC:Vývod 400V (15)
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 800 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Typ symbolu: Vývod 400V.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 400V; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod 400V; Označení typu: 07; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vývod.CC
Classification: KB00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0114775 m2; NetVolume: 0.0000268875 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Napájení
Text - CCI Funkční systém: K; CCI Komponenta: XDD; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000268875 m3
Jiné - Rodina: Vývod.CC; Id typu: 272100; Rodina a typ: Vývod.CC: Vývod 400V; Typ: Vývod 400V; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18
Name (Vývod.CC:Vývod 400V:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
669593 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0082 | 0082
669601 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0083 | 0083
669609 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0084 | 0084
669861 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 800 | KB00.07.0089 | 0089
669872 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0090 | 0090
669880 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0091 | 0091
669888 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0092 | 0092
669896 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0093 | 0093
671803 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 800 | KB00.07.0137 | 0137
733616 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 800 | KB00.07.0609 | 0609
733624 | -1.PP_SO-101 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 800 | KB00.07.0610 | 0610
734390 | 1.NP_SO-101 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 3500 | KB00.07.0616 | 0616
734796 | 2.NP_SO-101 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 800 | KB00.07.0619 | 0619
735427 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 800 | KB00.07.0620 | 0620
735435 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 800 | KB00.07.0621 | 0621

# IfcBuildingElementProxy: Vývod.CC:Vývod 400V T3 ukončený v krabici, Vývod.CC:Vývod 400V T3 ukončený v krabici:666404
In: 1.NP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Typ symbolu: Vývod 400V T3 ukončený v krabici.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 400V, T3, ukončený v krabici; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod 400V T3 ukončený v krabici; Označení typu: 05; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vývod.CC
Classification: KB00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0114775 m2; NetVolume: 0.0000268875 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Napájení
Text - CCI Funkční systém: K; CCI Komponenta: XDD; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Hostitel: Podlaží : 1.NP_SO-101; Odsazení od hostitele: 1250 mm; Výška od podlaží: 1250 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000268875 m3
Identifikační data - Kód prvku: KB00.05.0034; Označení: 0034
Jiné - Rodina: Vývod.CC; Id typu: 272094; Rodina a typ: Vývod.CC: Vývod 400V T3 ukončený v krabici; Typ: Vývod 400V T3 ukončený v krabici; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18

# IfcBuildingElementProxy: Vývod.CC:Vývod 400V v krabici (11)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Type - Grafika - Typ symbolu: Vývod 400V ukončený v krabici.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.50.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KB00; Komentáře k typům: 400V, ukončený v krabici; Model: Model; Nadpis OmniClass: Plug Connectors; Název typu: Vývod 400V v krabici; Označení typu: 20; Popis: Vývod; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vývod.CC
Classification: KB00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0114775 m2; NetVolume: 0.0000268875 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - TYP ZAŘÍZENÍ: Napájení
Text - CCI Funkční systém: K; CCI Komponenta: XDD; CCI Technický systém: HG
Vazby - Podlaží: -1.PP_SO-101; Hostitel: Podlaží : -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000268875 m3
Jiné - Rodina: Vývod.CC; Id typu: 272092; Rodina a typ: Vývod.CC: Vývod 400V v krabici; Typ: Vývod 400V v krabici; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:18
Name (Vývod.CC:Vývod 400V v krabici:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
735657 | 800 | KB00.20.0627 | 0627
735813 | 800 | KB00.20.0632 | 0632
735821 | 800 | KB00.20.0633 | 0633
735829 | 800 | KB00.20.0634 | 0634
735924 | 0 | KB00.20.0638 | 0638
735932 | 0 | KB00.20.0639 | 0639
735940 | 0 | KB00.20.0640 | 0640
735974 | 0 | KB00.20.0644 | 0644
735982 | 0 | KB00.20.0645 | 0645
735990 | 0 | KB00.20.0646 | 0646
738176 | 0 | KB00.20.0660 | 0660

# IfcBuildingElementProxy: Zásuvka 230V do PK.CC:Zásuvka jednoduchá 230V , IP20 (27)
In: 1.NP_SO-101
Type - Material: Bílá
Type - Elektroinstalace - JMENOVITÝ PROUD: 0 A; POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Typ symbolu: Zásuvka 230V IP20.CC
Type - Kóty - Délka: 45 mm; HLOUBKA: 0 mm; ŠÍŘKA: 0 mm; VÝŠKA: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ01; Komentáře k typům: Zásuvka 230V; Model: Model; Nadpis OmniClass: Receptacle Terminal Units; Název typu: Zásuvka jednoduchá 230V , IP20; Označení typu: 02; Popis: Zásuvka; Popis sestavy: 230 V; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Zásuvka 230V do PK.CC
Classification: ZZ01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.00647832 m2; NetVolume: 0.0000139671 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101; Vztažné podlaží: 1.NP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000139671 m3
Jiné - Id typu: 318542; Rodina: Zásuvka 230V do PK.CC; Rodina a typ: Zásuvka 230V do PK.CC: Zásuvka jednoduchá 230V , IP20; Typ: Zásuvka jednoduchá 230V , IP20; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 01:55
Name (Zásuvka 230V do PK.CC:Zásuvka jednoduchá 230V , IP20:...) | Výška od podlaží (mm) | Hostitel | Kód prvku | Označení
663514 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0002 | 0002
663521 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0003 | 0003
663528 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0004 | 0004
663535 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0005 | 0005
663549 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0006 | 0006
663556 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0007 | 0007
663570 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0008 | 0008
663591 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0009 | 0009
663612 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0010 | 0010
664379 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0011 | 0011
664387 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0012 | 0012
664421 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0013 | 0013
664598 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0014 | 0014
664623 | 640 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0015 | 0015
664717 | 640 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0016 | 0016
664775 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0017 | 0017
664879 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0018 | 0018
664895 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0019 | 0019
665102 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0020 | 0020
665118 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0021 | 0021
665178 | 600 | Kabelová lávka s tvarovkami : Parapetní žlab | ZZ01.02.0022 | 0022
669990 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0098 | 0098
669997 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0099 | 0099
670004 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0100 | 0100
670011 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0101 | 0101
670018 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0102 | 0102
670025 | 0 | Podlaží : 1.NP_SO-101 | ZZ01.02.0103 | 0103

# IfcBuildingElementProxy: Zásuvka 230V_vícerámečky.CC:Zásuvka jednoduchá 230V , IP20 (431)
Type - Material: Bílá
Type - Elektroinstalace - POČET FÁZÍ: 1; JMENOVITÝ PROUD: 0 A; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 2600 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Typ symbolu: Zásuvka 230V IP20.CC
Type - Kóty - HLOUBKA: 0 mm; ŠÍŘKA: 0 mm; VÝŠKA: 0 mm; Délka: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.80.50.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ01; Komentáře k typům: 230V; Model: Model; Nadpis OmniClass: Receptacle Terminal Units; Název typu: Zásuvka jednoduchá 230V , IP20; Označení typu: 04; Popis: Zásuvka; Popis sestavy: 230 V; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; FAKTOR ÚČINNOSTI: 1; Název rodiny: Zásuvka 230V_vícerámečky.CC
Classification: ZZ01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.00647832 m2; NetVolume: 0.0000139671 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: K; CCI Komponenta: XDB; CCI Technický systém: HG
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000139671 m3
Jiné - Typ: Zásuvka jednoduchá 230V , IP20; Id typu: 353145; Rodina: Zásuvka 230V_vícerámečky.CC; Rodina a typ: Zásuvka 230V_vícerámečky.CC: Zásuvka jednoduchá 230V , IP20
Name (Zásuvka 230V_vícerámečky.CC:Zásuvka jednoduchá 230V , IP20:...) | In | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení | UPRAVIL
665982 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2656.9 | ZZ01.04.0030 | 0030 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
665996 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2656.9 | ZZ01.04.0031 | 0031 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
666021 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2556.9 | ZZ01.04.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
666221 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2556.9 | ZZ01.04.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668074 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0037 | 0037 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668082 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0038 | 0038 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668098 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668159 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668178 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668235 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668251 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668273 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668289 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668366 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668382 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668626 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668669 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668695 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668711 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668735 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668757 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668848 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668968 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
668987 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669123 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669139 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669155 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669226 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669248 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669267 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669283 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0063 | 0063 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
669351 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 750 | ZZ01.04.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670060 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2556.9 | ZZ01.04.0105 | 0105 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670062 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 2556.9 | ZZ01.04.0106 | 0106 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670157 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0107 | 0107 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670272 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0108 | 0108 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670317 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0109 | 0109 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670333 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0110 | 0110 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670459 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0111 | 0111 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670487 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0112 | 0112 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670612 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0113 | 0113 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670628 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0114 | 0114 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670658 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0115 | 0115 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670678 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0116 | 0116 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670843 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0117 | 0117 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670857 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0118 | 0118 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
670879 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0119 | 0119 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671021 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0120 | 0120 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671061 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0121 | 0121 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671244 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0122 | 0122 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671260 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0123 | 0123 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671375 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0124 | 0124 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671403 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0125 | 0125 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
671444 | 1.NP_SO-101 | 1.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 600 | ZZ01.04.0126 | 0126 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
673485 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0166 | 0166 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
673501 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0167 | 0167 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
673609 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
673711 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0169 | 0169 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
674131 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0170 | 0170 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
674568 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0171 | 0171 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
674806 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0172 | 0172 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
674861 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0173 | 0173 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
675051 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0174 | 0174 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
675199 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0175 | 0175 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
675415 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0176 | 0176 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
675662 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0177 | 0177 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
676075 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0178 | 0178 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
676322 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0179 | 0179 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
676732 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0180 | 0180 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
676830 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0181 | 0181 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
677081 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0182 | 0182 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
677267 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0183 | 0183 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
677573 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0184 | 0184 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
677863 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0185 | 0185 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
678137 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0186 | 0186 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
678440 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0187 | 0187 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
678732 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0188 | 0188 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
679149 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0190 | 0190 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
679215 | 1.NP_SO-101 | 1.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0192 | 0192 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683454 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0229 | 0229 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683461 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0230 | 0230 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683468 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0231 | 0231 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683475 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0232 | 0232 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683482 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0233 | 0233 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683489 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0234 | 0234 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683499 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0235 | 0235 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683506 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0236 | 0236 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683513 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0237 | 0237 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683520 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0238 | 0238 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683527 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0239 | 0239 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683534 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 0 | ZZ01.04.0240 | 0240 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683644 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 900 | ZZ01.04.0241 | 0241 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683645 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 900 | ZZ01.04.0242 | 0242 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683706 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0243 | 0243 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683707 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0244 | 0244 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683718 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0245 | 0245 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683719 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0246 | 0246 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683728 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0247 | 0247 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683729 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0248 | 0248 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683738 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0249 | 0249 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683739 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0250 | 0250 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683750 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0251 | 0251 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683751 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0252 | 0252 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683764 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0253 | 0253 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683765 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0254 | 0254 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683820 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0255 | 0255 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
683821 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Kabelový žlab | 0 | ZZ01.04.0256 | 0256 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684415 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0259 | 0259 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684423 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0260 | 0260 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684448 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0261 | 0261 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684482 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0262 | 0262 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684513 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0263 | 0263 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684580 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0264 | 0264 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684611 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0265 | 0265 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684630 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0266 | 0266 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684679 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0267 | 0267 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684781 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0268 | 0268 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684812 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0269 | 0269 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684837 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0270 | 0270 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684874 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0271 | 0271 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684909 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0272 | 0272 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684943 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0273 | 0273 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
684986 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0274 | 0274 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685035 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0275 | 0275 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685240 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0276 | 0276 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685274 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0277 | 0277 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685320 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0278 | 0278 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685342 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0279 | 0279 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685433 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0280 | 0280 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685455 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0281 | 0281 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685477 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0282 | 0282 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685517 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0283 | 0283 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685563 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0284 | 0284 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685618 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0285 | 0285 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685670 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0286 | 0286 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685710 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0287 | 0287 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685762 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0288 | 0288 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685796 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0289 | 0289 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
685827 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0290 | 0290 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
686179 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2536.9 | ZZ01.04.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
686187 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2536.9 | ZZ01.04.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
686215 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ01.04.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
686550 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.9 | ZZ01.04.0296 | 0296 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687074 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0297 | 0297 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687085 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0298 | 0298 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687113 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0299 | 0299 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687150 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0300 | 0300 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687190 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0301 | 0301 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687360 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0302 | 0302 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687442 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0303 | 0303 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687494 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0304 | 0304 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687528 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0305 | 0305 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687571 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0306 | 0306 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687759 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0307 | 0307 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687793 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0308 | 0308 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
687830 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688004 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0310 | 0310 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688053 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0311 | 0311 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688276 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0312 | 0312 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688310 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0313 | 0313 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688335 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0314 | 0314 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688375 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0315 | 0315 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688571 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0316 | 0316 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688593 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0317 | 0317 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688639 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0318 | 0318 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688667 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0319 | 0319 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688714 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0320 | 0320 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688745 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0321 | 0321 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688761 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0322 | 0322 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688795 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0323 | 0323 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688890 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0324 | 0324 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688915 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0325 | 0325 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688943 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0326 | 0326 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
688974 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0327 | 0327 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689060 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0328 | 0328 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689106 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0329 | 0329 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689173 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0330 | 0330 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689216 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689266 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0332 | 0332 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689288 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0333 | 0333 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
689310 | 2.NP_SO-101 | 2.NP_SO-101 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | ZZ01.04.0334 | 0334 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
690983 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0352 | 0352 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
690996 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0353 | 0353 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
691478 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0354 | 0354 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
691947 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0355 | 0355 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
692209 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0356 | 0356 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
692653 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0357 | 0357 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
692813 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0358 | 0358 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
693126 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0359 | 0359 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
693399 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0360 | 0360 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
693631 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0361 | 0361 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
693962 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0362 | 0362 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
694113 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0363 | 0363 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
694349 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0364 | 0364 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
694683 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0365 | 0365 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
695109 | 2.NP_SO-101 | 2.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0366 | 0366 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
695531 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 900 | ZZ01.04.0367 | 0367 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
695779 | 2.NP_SO-101 | 2.NP_SO-101 | <nepřiřazeno> | 900 | ZZ01.04.0368 | 0368 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697172 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0405 | 0405 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697235 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0406 | 0406 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697245 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0407 | 0407 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697274 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0408 | 0408 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697297 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0409 | 0409 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697319 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0410 | 0410 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697368 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 1100 | ZZ01.04.0411 | 0411 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697531 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0412 | 0412 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697545 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0413 | 0413 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
697701 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0414 | 0414 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
698046 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0415 | 0415 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
698262 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0416 | 0416 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
698417 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0417 | 0417 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
698923 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0418 | 0418 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
699137 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0419 | 0419 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
699283 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0420 | 0420 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
699515 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0421 | 0421 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
700025 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0422 | 0422 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
700346 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0423 | 0423 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
700754 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0424 | 0424 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
700991 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0425 | 0425 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
701398 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0426 | 0426 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
701668 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0427 | 0427 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
702114 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0428 | 0428 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
702390 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0429 | 0429 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
702656 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 300 | ZZ01.04.0430 | 0430 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703295 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0431 | 0431 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703302 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0432 | 0432 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703309 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0433 | 0433 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703316 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0434 | 0434 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703323 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0435 | 0435 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703330 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0436 | 0436 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703337 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0437 | 0437 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703344 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0438 | 0438 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703351 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0439 | 0439 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703358 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0440 | 0440 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703365 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0441 | 0441 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703372 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0442 | 0442 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703379 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0443 | 0443 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703386 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0444 | 0444 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703393 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0445 | 0445 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703400 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0446 | 0446 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703407 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0447 | 0447 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703414 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0448 | 0448 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703421 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0449 | 0449 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703428 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0450 | 0450 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703435 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0451 | 0451 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703442 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0452 | 0452 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703449 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0453 | 0453 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703456 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0454 | 0454 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703463 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0455 | 0455 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703470 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0456 | 0456 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703477 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0457 | 0457 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703484 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0458 | 0458 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703491 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0459 | 0459 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703498 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0460 | 0460 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703505 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0461 | 0461 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703512 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0462 | 0462 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703519 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0463 | 0463 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703526 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0464 | 0464 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703533 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0465 | 0465 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703540 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0466 | 0466 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703547 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0467 | 0467 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703554 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0468 | 0468 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703561 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0469 | 0469 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703568 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0470 | 0470 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703575 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0471 | 0471 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703582 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0472 | 0472 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703589 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0473 | 0473 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703596 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0474 | 0474 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703603 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0475 | 0475 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703610 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0476 | 0476 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703617 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0477 | 0477 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703624 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0478 | 0478 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703631 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0479 | 0479 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703638 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0480 | 0480 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703645 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0481 | 0481 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703652 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0482 | 0482 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703659 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0483 | 0483 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703666 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0484 | 0484 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703673 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0485 | 0485 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703680 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0486 | 0486 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703765 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0489 | 0489 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
703780 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0490 | 0490 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704495 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0492 | 0492 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704496 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0493 | 0493 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704497 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0494 | 0494 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704498 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0495 | 0495 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704508 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0497 | 0497 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704509 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0498 | 0498 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704510 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0499 | 0499 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704511 | 3.NP_SO-101 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | ZZ01.04.0500 | 0500 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704568 | 3.NP_SO-101 | 3.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 1x | 900 | ZZ01.04.0502 | 0502 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704677 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0510 | 0510 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704684 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0511 | 0511 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704691 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0512 | 0512 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704698 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0513 | 0513 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704957 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0514 | 0514 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704964 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0515 | 0515 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704971 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0516 | 0516 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704978 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0517 | 0517 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704985 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0518 | 0518 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704992 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0519 | 0519 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
704999 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0520 | 0520 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705006 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0521 | 0521 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705344 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0523 | 0523 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705345 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0524 | 0524 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705346 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0525 | 0525 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705347 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0526 | 0526 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705357 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0528 | 0528 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705358 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0529 | 0529 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705359 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0530 | 0530 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705360 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0531 | 0531 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705370 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0533 | 0533 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705371 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0534 | 0534 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705372 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0535 | 0535 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
705373 | 4.NP_SO-101 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | ZZ01.04.0536 | 0536 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706190 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0546 | 0546 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706202 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0547 | 0547 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
706227 | 4.NP_SO-101 | 4.NP_SO-101 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 300 | ZZ01.04.0548 | 0548 | Fruhauf.vinarice@seznam.cz 2023.06.26 01:51
