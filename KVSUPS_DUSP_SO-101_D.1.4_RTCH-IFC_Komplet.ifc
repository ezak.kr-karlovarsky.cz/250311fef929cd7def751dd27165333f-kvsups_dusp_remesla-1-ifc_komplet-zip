Properties of the parts of a building model (IFC4), part 19 of 23

# IfcPipeFitting: M_Spoj T, obecný:Standardní (265)
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13108069 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0435 | 0435 | no | 9.5875
13108941 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2250 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0437 | 0437 | yes | 17.4625
13109211 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.02.0440 | 0440 | yes | 20.6375
13109257 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.02.0441 | 0441 | yes | 20.6375
13113819 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0461 | 0461 | no | 9.5875
13113848 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0462 | 0462 | no | 9.5875
13121160 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0496 | 0496 | no | 9.5875
13121187 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0497 | 0497 | no | 9.5875
13137632 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 89.9533 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0508 | 0508 | no | 9.5875
13137637 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0509 | 0509 | yes | 14.2875
13140540 | -1.PP_SO-101 | 40 | ø112 mm-ø112 mm-ø112 mm | HD | -1.PP_SO-101 | 2200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0522 | 0522 | yes | 17.4625 | Izolace - Typ izolace: Tepelná
13140620 | 1.NP_SO-101 | 40 | ø112 mm-ø112 mm-ø112 mm | HD | 1.NP_SO-101 | -949.37 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0526 | 0526 | yes | 17.4625 | Izolace - Typ izolace: Tepelná
13143819 | 3.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0531 | 0531 | yes | 14.2875
13143829 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0533 | 0533 | no | 9.5875
13143988 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0534 | 0534 | no | 9.5875
13143992 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0535 | 0535 | yes | 14.2875
13144140 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0537 | 0537 | no | 9.5875
13144144 | 3.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0538 | 0538 | yes | 14.2875
13144422 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0543 | 0543 | yes | 17.4625
13144572 | 2.NP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 2.NP_SO-101 | -1200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0546 | 0546 | yes | 17.4625
13146331 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0553 | 0553 | no | 9.5875
13155951 | 1.NP_SO-101 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.02.0581 | 0581 | yes | 20.6375
13158425 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0603 | 0603 | no | 9.5875
13158466 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0605 | 0605 | no | 9.5875
13158702 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0607 | 0607 | no | 9.5875
13158729 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0608 | 0608 | no | 9.5875
13159697 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0613 | 0613 | yes | 14.2875
13159748 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0617 | 0617 | no | 9.5875
13159820 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0619 | 0619 | yes | 14.2875
13159953 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0621 | 0621 | no | 9.5875
13160255 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0625 | 0625 | no | 9.5875
13160283 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0627 | 0627 |  | 9.5875
13163196 | 3.NP_SO-101 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.02.0640 | 0640 | yes | 14.2875
13165691 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0661 | 0661 | no | 9.5875
13165715 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0662 | 0662 | no | 9.5875
13167571 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0663 | 0663 | no | 9.5875
13167594 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0664 | 0664 | no | 9.5875

# IfcPipeFitting: M_Spojka, obecná:Standardní, M_Spojka, obecná:Standardní:13087322
In: 4.NP_SO-101
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT04; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Spojení; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT04 Uniformat (Uniformat); Group: HT_přívodní vodní (65 °C) 6
Qto_PipeFittingBaseQuantities - Length: 7.9375 mm; GrossCrossSectionArea: 0.000197906 m2; NetCrossSectionArea: 0.000197906 m2; OuterSurfaceArea: 0.000395865 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 4.NP_SO-101; Výška od podlaží: -50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_přívodní vodní (65 °C); Klasifikace systému: Přívod teplé vody; Název systému: HT_přívodní vodní (65 °C) 6
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 7.9375 mm; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.00000157102 m3; Velikost: ø15-ø15; Velikost značky: 6.35 mm; Vnější průměr tvarovky: 15.875 mm
Identifikační data - Kód prvku: TT04.04.0376; Označení: 0376
Jiné - Páteřní trasa: no; Typ: Standardní; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Vnější poloměr tvarovky: 7.9375 mm

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (670)
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: B2
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR13; Model: RAUTITAN flex; Název typu: Kompozit PE-Xa_RAUTITAN flex; Označení typu: 01; Popis: PE-Xa/EVAL; Popis sestavy: Cross-Linked Polyethylene (PEX); Výrobce: Rehau
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR13 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Tlaková ztráta: 0 Pa; Třecí faktor: 0; Tření: 0
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.01 mm; Materiál: RAU–PE–Xa; Popis úseku: RAU–PE–Xa; Typ přípoje: Obecné; Úsek potrubí: RAU–PE–Xa - Univerzální trubka RAUTITAN flex; Výkaz/typ: Univerzální trubka RAUTITAN flex
Jiné - Id typu: 8027472; Rodina: Typy trubek; Rodina a typ: Typy trubek: Kompozit PE-Xa_RAUTITAN flex; Typ: Kompozit PE-Xa_RAUTITAN flex
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
12944109 | 3.NP_SO-101 | 444.063 | 0.000201032 | 0.022321 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 3 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0001 | 0001 | no
12944154 | 3.NP_SO-101 | 437.713 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 13 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0002 | 0002 | no
12944165 | 3.NP_SO-101 | 437.713 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 11 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0003 | 0003 | no
12944176 | 3.NP_SO-101 | 437.712 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 9 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0004 | 0004 | no
12944189 | 3.NP_SO-101 | 437.712 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 7 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0005 | 0005 | no
12944202 | 3.NP_SO-101 | 437.712 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 1 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0006 | 0006 | no
12944403 | 3.NP_SO-101 | 437.712 | 0.000201032 | 0.0220018 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 46 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0007 | 0007 | no
12944430 | 3.NP_SO-101 | 3535.43 | 0.000201032 | 0.17771 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 8 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0008 | 0008 | no
12944451 | 3.NP_SO-101 | 3534.18 | 0.000201032 | 0.177647 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 10 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0009 | 0009 | no
12944472 | 3.NP_SO-101 | 3451.53 | 0.000201032 | 0.173493 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 12 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0010 | 0010 | no
12944493 | 3.NP_SO-101 | 3785.42 | 0.000201032 | 0.190276 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 14 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0011 | 0011 | no
12944514 | 3.NP_SO-101 | 3131.78 | 0.000201032 | 0.15742 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 3 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0012 | 0012 | no
12944524 | 3.NP_SO-101 | 2797.23 | 0.000201032 | 0.140604 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 39 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0013 | 0013 | no
12944533 | 3.NP_SO-101 | 524.063 | 0.000201032 | 0.0263423 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 39 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0014 | 0014 | no
12944550 | 3.NP_SO-101 | 524.063 | 0.000201032 | 0.0263423 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 40 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0015 | 0015 | no
12944569 | 3.NP_SO-101 | 517.713 | 0.000201032 | 0.0260231 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 41 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0016 | 0016 | no
12944578 | 3.NP_SO-101 | 3066.78 | 0.000201032 | 0.154153 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 40 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0017 | 0017 | no
12944581 | 3.NP_SO-101 | 517.713 | 0.000201032 | 0.0260231 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 5 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0018 | 0018 | no
12944590 | 3.NP_SO-101 | 2898.16 | 0.000201032 | 0.145677 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 2 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0019 | 0019 | no
12944602 | 3.NP_SO-101 | 2797.23 | 0.000201032 | 0.140604 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 4 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0020 | 0020 | no
12944640 | 3.NP_SO-101 | 594.571 | 0.000201032 | 0.0298864 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 44 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0021 | 0021 | no
12944649 | 3.NP_SO-101 | 4400.01 | 0.000201032 | 0.221169 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 16 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0022 | 0022 | no
12944852 | 3.NP_SO-101 | 777.713 | 0.000201032 | 0.0390921 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 153 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0023 | 0023 | no
12945193 | 2.NP_SO-101 | 504.063 | 0.000201032 | 0.0253369 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 8 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0024 | 0024 | no
12945301 | 2.NP_SO-101 | 497.713 | 0.000201032 | 0.0250178 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 9 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0025 | 0025 | no
12945312 | 2.NP_SO-101 | 497.713 | 0.000201032 | 0.0250178 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 7 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0026 | 0026 | no
12945323 | 2.NP_SO-101 | 497.713 | 0.000201032 | 0.0250178 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 5 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0027 | 0027 | no
12945334 | 2.NP_SO-101 | 497.713 | 0.000201032 | 0.0250178 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 3 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0028 | 0028 | no
12945368 | 2.NP_SO-101 | 10494.5 | 0.000201032 | 0.52751 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 205 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0029 | 0029 | no
12945393 | 2.NP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 1 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0030 | 0030 | no
12945418 | 2.NP_SO-101 | 3485.57 | 0.000201032 | 0.175204 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 4 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0031 | 0031 | no
12945443 | 2.NP_SO-101 | 3455.96 | 0.000201032 | 0.173716 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 6 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0032 | 0032 | no
12945453 | 2.NP_SO-101 | 3457.6 | 0.000201032 | 0.173798 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 8 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0033 | 0033 | no
12945482 | 2.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 11 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0034 | 0034 | no
12945564 | 2.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 15 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0035 | 0035 | no
12945618 | 2.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 16 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0036 | 0036 | no
12945631 | 2.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 17 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0037 | 0037 | no
12945644 | 2.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 12 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0038 | 0038 | no
12945674 | 2.NP_SO-101 | 4362.21 | 0.000201032 | 0.219269 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 11 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0039 | 0039 | no
12945724 | 2.NP_SO-101 | 2931.03 | 0.000201032 | 0.14733 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 14 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0040 | 0040 | no
12945734 | 2.NP_SO-101 | 4412.89 | 0.000201032 | 0.221816 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 15 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0041 | 0041 | no
12945828 | 2.NP_SO-101 | 1638.18 | 0.000201032 | 0.0823438 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 152 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0042 | 0042 | no
12946351 | 2.NP_SO-101 | 5955.42 | 0.000201032 | 0.299352 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 148 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0043 | 0043 | no
12946373 | 2.NP_SO-101 | 1638.18 | 0.000201032 | 0.0823438 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 153 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0044 | 0044 | no
12946403 | 2.NP_SO-101 | 3076.38 | 0.000201032 | 0.154636 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 147 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0045 | 0045 | no
12946413 | 2.NP_SO-101 | 1929.43 | 0.000201032 | 0.0969838 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 25 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0046 | 0046 | no
12946433 | 2.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 26 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0047 | 0047 | no
12946440 | 2.NP_SO-101 | 4799.14 | 0.000201032 | 0.241231 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 26 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0048 | 0048 | no
12946451 | 2.NP_SO-101 | 6018.7 | 0.000201032 | 0.302533 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 155 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0049 | 0049 | no
12946477 | 2.NP_SO-101 | 455.425 | 0.000201032 | 0.0228922 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 18 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0050 | 0050 | no
12946488 | 2.NP_SO-101 | 455.425 | 0.000201032 | 0.0228922 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 15 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0051 | 0051 | no
12946503 | 2.NP_SO-101 | 455.425 | 0.000201032 | 0.0228922 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 160 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0052 | 0052 | no
12946520 | 2.NP_SO-101 | 7857.23 | 0.000201032 | 0.394947 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 157 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0053 | 0053 | no
12946543 | 2.NP_SO-101 | 3463.17 | 0.000201032 | 0.174078 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 23 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0054 | 0054 | no
12946546 | 2.NP_SO-101 | 7299.92 | 0.000201032 | 0.366934 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 157 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0055 | 0055 | no
12946563 | 2.NP_SO-101 | 2268.94 | 0.000201032 | 0.114049 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 17 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0056 | 0056 | no
12946572 | 2.NP_SO-101 | 1152.23 | 0.000201032 | 0.0579176 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 156 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0057 | 0057 | no
12946612 | 2.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 22 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0058 | 0058 | no
12946622 | 2.NP_SO-101 | 3684.06 | 0.000201032 | 0.185181 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 270 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0059 | 0059 | no
12946631 | 2.NP_SO-101 | 1368.13 | 0.000201032 | 0.0687695 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 270 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0060 | 0060 | no
12946641 | 2.NP_SO-101 | 1588.85 | 0.000201032 | 0.0798643 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 270 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0061 | 0061 | no
12946986 | 1.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 102 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0062 | 0062 | no
12947110 | 1.NP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 103 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0063 | 0063 | no
12947125 | 1.NP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 104 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0064 | 0064 | no
12947331 | 1.NP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 105 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0065 | 0065 | no
12947386 | 1.NP_SO-101 | 3487.21 | 0.000201032 | 0.175286 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 100 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0066 | 0066 | no
12947411 | 1.NP_SO-101 | 3471.82 | 0.000201032 | 0.174513 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 101 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0067 | 0067 | no
12947421 | 1.NP_SO-101 | 3419.09 | 0.000201032 | 0.171862 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 102 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0068 | 0068 | no
12947446 | 1.NP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 106 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0069 | 0069 | no
12947470 | 1.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 99 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0070 | 0070 | no
12947507 | 1.NP_SO-101 | 2171.78 | 0.000201032 | 0.109165 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 126 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0071 | 0071 | no
12947517 | 1.NP_SO-101 | 264.063 | 0.000201032 | 0.0132732 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 126 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0072 | 0072 | no
12947545 | 1.NP_SO-101 | 1688.79 | 0.000201032 | 0.0848878 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 127 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0073 | 0073 | no
12947554 | 1.NP_SO-101 | 6011.15 | 0.000201032 | 0.302153 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 125 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0074 | 0074 | no
12947558 | 1.NP_SO-101 | 1709.02 | 0.000201032 | 0.0859048 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 128 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0075 | 0075 | no
12947567 | 1.NP_SO-101 | 3315.17 | 0.000201032 | 0.166638 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 144 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0076 | 0076 | no
12947580 | 1.NP_SO-101 | 3024.99 | 0.000201032 | 0.152052 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 129 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0077 | 0077 | no
12947584 | 1.NP_SO-101 | 3070.36 | 0.000201032 | 0.154333 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 130 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0078 | 0078 | no
12947593 | 1.NP_SO-101 | 3305.43 | 0.000201032 | 0.166149 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 124 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0079 | 0079 | no
12947597 | 1.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 120 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0080 | 0080 | no
12947703 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 24 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0081 | 0081 | no
12947718 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 121 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0082 | 0082 | no
12947748 | 1.NP_SO-101 | 2961.77 | 0.000201032 | 0.148875 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 120 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0083 | 0083 | no
12947752 | 1.NP_SO-101 | 2954.99 | 0.000201032 | 0.148534 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 119 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0084 | 0084 | no
12947762 | 1.NP_SO-101 | 7743.24 | 0.000201032 | 0.389218 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 118 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0085 | 0085 | no
12947771 | 1.NP_SO-101 | 888.142 | 0.000201032 | 0.0446429 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 118 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0086 | 0086 | no
12947784 | 1.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 19 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0087 | 0087 | no
12947793 | 1.NP_SO-101 | 5715.68 | 0.000201032 | 0.287302 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 19 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0088 | 0088 | no
12947812 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 95 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0089 | 0089 | no
12947878 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 94 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0090 | 0090 | no
12947891 | 1.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 93 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0091 | 0091 | no
12947947 | 1.NP_SO-101 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 90 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0092 | 0092 | no
12947983 | 1.NP_SO-101 | 4369.14 | 0.000201032 | 0.219617 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 93 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0093 | 0093 | no
12947987 | 1.NP_SO-101 | 2973.28 | 0.000201032 | 0.149453 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 92 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0094 | 0094 | no
12948072 | 1.NP_SO-101 | 5257.68 | 0.000201032 | 0.26428 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 191 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0095 | 0095 | no
12948081 | 1.NP_SO-101 | 2533.4 | 0.000201032 | 0.127343 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 97 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0096 | 0096 | no
12948094 | 1.NP_SO-101 | 1861.77 | 0.000201032 | 0.093583 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 107 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0097 | 0097 | no
12948110 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 137 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0098 | 0098 | no
12948183 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 138 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0099 | 0099 | no
12948198 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 139 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0100 | 0100 | no
12948209 | 1.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 136 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0101 | 0101 | no
12948246 | 1.NP_SO-101 | 4343.09 | 0.000201032 | 0.218308 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 135 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0102 | 0102 | no
12948263 | 1.NP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 132 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0103 | 0103 | no
12948267 | 1.NP_SO-101 | 3463.17 | 0.000201032 | 0.174078 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 133 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0104 | 0104 | no
12948271 | 1.NP_SO-101 | 3391.26 | 0.000201032 | 0.170463 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 134 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0105 | 0105 | no
12948274 | 1.NP_SO-101 | 7662.76 | 0.000201032 | 0.385172 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 135 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0106 | 0106 | no
12948294 | 3.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 21 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0107 | 0107 | no
12948411 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 160 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0108 | 0108 | no
12948426 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 161 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0109 | 0109 | no
12948439 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 162 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0110 | 0110 | no
12948454 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 18 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0111 | 0111 | no
12948670 | 3.NP_SO-101 | 10409.9 | 0.000201032 | 0.523259 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 208 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0112 | 0112 | no
12948674 | 3.NP_SO-101 | 3447.92 | 0.000201032 | 0.173312 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 157 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0113 | 0113 | no
12948678 | 3.NP_SO-101 | 3488.23 | 0.000201032 | 0.175338 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 158 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0114 | 0114 | no
12948837 | 3.NP_SO-101 | 3461.78 | 0.000201032 | 0.174008 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 21 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0115 | 0115 | no
12948847 | 3.NP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 159 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0116 | 0116 | no
12949020 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 155 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0117 | 0117 | no
12949069 | 3.NP_SO-101 | 4621.54 | 0.000201032 | 0.232304 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 151 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0118 | 0118 | no
12949111 | 3.NP_SO-101 | 1671.95 | 0.000201032 | 0.0840414 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 30 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0119 | 0119 | no
12949117 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 154 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0120 | 0120 | no
12949236 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 28 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0121 | 0121 | no
12949263 | 3.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 29 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0122 | 0122 | no
12949410 | 3.NP_SO-101 | 1409.34 | 0.000201032 | 0.0708412 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 16 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0123 | 0123 | no
12949431 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 32 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0124 | 0124 | no
12949442 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 43 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0125 | 0125 | no
12949465 | 3.NP_SO-101 | 2503.73 | 0.000201032 | 0.125851 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 29 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0126 | 0126 | no
12949483 | 3.NP_SO-101 | 7460.34 | 0.000201032 | 0.374998 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 28 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0127 | 0127 | no
12949492 | 3.NP_SO-101 | 473.466 | 0.000201032 | 0.023799 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 30 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0128 | 0128 | no
12949496 | 3.NP_SO-101 | 5961.52 | 0.000201032 | 0.299659 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 35 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0129 | 0129 | no
12949548 | 3.NP_SO-101 | 3521.87 | 0.000201032 | 0.177029 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 34 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0130 | 0130 | no
12949557 | 3.NP_SO-101 | 2707.48 | 0.000201032 | 0.136093 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 33 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0131 | 0131 | no
12949560 | 3.NP_SO-101 | 289.744 | 0.000201032 | 0.0145641 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 36 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0132 | 0132 | no
12949569 | 3.NP_SO-101 | 2160.82 | 0.000201032 | 0.108614 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 36 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0133 | 0133 | no
12949578 | 3.NP_SO-101 | 1650.47 | 0.000201032 | 0.0829615 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 38 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0134 | 0134 | no
12949752 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 87 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0135 | 0135 | no
12949765 | -1.PP_SO-101 | 500 | 0.000201032 | 0.0251327 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 256 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0136 | 0136 | no
12949823 | -1.PP_SO-101 | 2859.16 | 0.000201032 | 0.143717 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 256 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0137 | 0137 | no
12949834 | -1.PP_SO-101 | 7470.19 | 0.000201032 | 0.375493 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 234 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0138 | 0138 | no
12949944 | -1.PP_SO-101 | 12177.7 | 0.000201032 | 0.612119 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 85 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0139 | 0139 | no
12949986 | -1.PP_SO-101 | 8014.77 | 0.000201032 | 0.402866 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 238 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0140 | 0140 | no
12949998 | -1.PP_SO-101 | 7204.73 | 0.000201032 | 0.362149 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 82 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0141 | 0141 | no
12950051 | -1.PP_SO-101 | 424.063 | 0.000201032 | 0.0213157 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 24 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0142 | 0142 | no
12950060 | -1.PP_SO-101 | 1843.66 | 0.000201032 | 0.0926725 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 24 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0143 | 0143 | no
12950241 | -1.PP_SO-101 | 184.86 | 0.000201032 | 0.00929206 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 19 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0144 | 0144 | no
12950261 | -1.PP_SO-101 | 641.017 | 0.000201032 | 0.032221 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 69 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0145 | 0145 | no
12950281 | -1.PP_SO-101 | 3881.43 | 0.000201032 | 0.195102 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 67 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0146 | 0146 | no
12950341 | -1.PP_SO-101 | 256.775 | 0.000201032 | 0.0129069 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 20 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0147 | 0147 | no
12950428 | -1.PP_SO-101 | 4246.98 | 0.000201032 | 0.213476 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 71 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0148 | 0148 | no
12950436 | -1.PP_SO-101 | 320.227 | 0.000201032 | 0.0160964 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 74 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0149 | 0149 | no
12950445 | -1.PP_SO-101 | 256.892 | 0.000201032 | 0.0129128 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 73 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0150 | 0150 | no
12950497 | -1.PP_SO-101 | 377.543 | 0.000201032 | 0.0189774 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 72 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0151 | 0151 | no
12950501 | -1.PP_SO-101 | 661.775 | 0.000201032 | 0.0332644 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 67 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0152 | 0152 | no
12950509 | -1.PP_SO-101 | 231.694 | 0.000201032 | 0.0116462 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 68 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0153 | 0153 | no
12950534 | -1.PP_SO-101 | 3173.15 | 0.000201032 | 0.1595 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 68 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0154 | 0154 | no
12950542 | -1.PP_SO-101 | 622.647 | 0.000201032 | 0.0312977 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 23 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0155 | 0155 | no
12950551 | -1.PP_SO-101 | 2669.83 | 0.000201032 | 0.1342 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 70 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0156 | 0156 | no
12950554 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 97 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0157 | 0157 | no
12950653 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 96 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0158 | 0158 | no
12950670 | -1.PP_SO-101 | 57.7125 | 0.000201032 | 0.00290095 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 98 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0159 | 0159 | no
12950730 | -1.PP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 92 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0160 | 0160 | no
12950741 | -1.PP_SO-101 | 1384.06 | 0.000201032 | 0.0695706 | ø16 mm | 0.000862069 | HD | -342 | -350 | -350 | -1.PP_SO-101 | 0 | -358 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3505.8 | 16 | 249 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0161 | 0161 | no
12950812 | -1.PP_SO-101 | 2483.55 | 0.000201032 | 0.124837 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 90 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0162 | 0162 | no
12950816 | -1.PP_SO-101 | 3342.9 | 0.000201032 | 0.168033 | ø16 mm | 0.000862069 | HD | -342 | -350 | -350 | -1.PP_SO-101 | 0 | -358 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3505.8 | 16 | 249 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0163 | 0163 | no
12951639 | 4.NP_SO-101 | 1740 | 0.000201032 | 0.0874619 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 48 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0164 | 0164 | no
12951642 | 4.NP_SO-101 | 1737.71 | 0.000201032 | 0.087347 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 51 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0165 | 0165 | no
12951651 | 4.NP_SO-101 | 1283.5 | 0.000201032 | 0.0645156 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 49 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0166 | 0166 | no
12951696 | 4.NP_SO-101 | 104.063 | 0.000201032 | 0.00523075 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 52 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0167 | 0167 | no
12951705 | 4.NP_SO-101 | 1551.65 | 0.000201032 | 0.0779943 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 52 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0168 | 0168 | no
12951716 | 4.NP_SO-101 | 249.402 | 0.000201032 | 0.0125363 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 176 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0169 | 0169 | no
12951730 | 4.NP_SO-101 | 665.208 | 0.000201032 | 0.033437 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 163 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0170 | 0170 | no
12951747 | 4.NP_SO-101 | 1329.85 | 0.000201032 | 0.0668456 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 107 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0171 | 0171 | no
12951760 | 4.NP_SO-101 | 471.723 | 0.000201032 | 0.0237114 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 174 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0172 | 0172 | no
12951769 | 4.NP_SO-101 | 4816.63 | 0.000201032 | 0.24211 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 162 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0173 | 0173 | no
