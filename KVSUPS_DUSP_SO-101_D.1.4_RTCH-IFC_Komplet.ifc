Properties of the parts of a building model (IFC4), part 15 of 23

# IfcDistributionPort (3628)
Name | FlowDirection | Group
Port_13087239_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086793_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087239_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086793_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086804_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087249_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086804_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086815_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087245_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086815_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086830_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087008_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086830_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087235_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086841_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087008_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086841_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087012_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087091_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087092_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087092_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087171_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087235_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087246_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087245_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087250_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087245_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087246_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087249_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087250_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087322_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 6
Port_13087322_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 6
Port_13087415_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087636_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087415_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087426_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087860_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087426_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087636_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087806_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100599_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087806_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087807_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087806_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159954_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087860_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146655_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13088226_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13148781_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088226_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088318_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088237_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088318_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088237_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13088459_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155948_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13088459_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146331_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13088535_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146331_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13090200_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13120538_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13090200_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13090637_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13120553_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13090637_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13090646_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13120574_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13090646_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13090672_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13120593_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13090672_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13090681_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13120614_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13090681_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13090690_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13090690_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13120633_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13090871_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13120631_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13090871_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13092667_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13091287_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13120612_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13091287_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13092705_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13092903_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13120631_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13092903_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13120633_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13092938_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13120612_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13092938_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13120614_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13093146_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13120591_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13093146_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13120593_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13093155_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13120572_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13093155_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13120574_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13093164_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13120551_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13093164_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13120553_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13093173_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13108668_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13093173_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13120538_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094085_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13120591_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13094085_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13094444_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13094094_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13120572_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13094094_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13094495_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13094103_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13120551_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094103_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094541_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094112_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13108668_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094112_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094583_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094539_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094541_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094581_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094583_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13097367_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097374_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097367_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097374_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097375_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097374_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097392_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097397_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097392_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097397_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097398_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097397_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097480_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097485_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097480_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097485_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097486_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097485_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097505_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097510_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097505_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097510_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097511_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097510_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097563_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097669_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097563_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097570_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097639_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097570_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097669_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097612_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097639_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097639_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097640_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097640_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13106712_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13098076_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098142_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098076_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098085_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098142_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098085_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098144_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098136_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098144_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098144_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098145_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098145_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106714_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098165_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098173_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098165_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098183_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098173_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098174_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098174_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13106665_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098177_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098183_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098177_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098200_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098290_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098200_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098209_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098290_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098209_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098292_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098287_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098292_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098292_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098293_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098293_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13106667_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13100496_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100577_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100496_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100622_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100505_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100577_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100513_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100598_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100513_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100655_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100555_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100598_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100577_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160059_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100598_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100599_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100620_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100622_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100620_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100653_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100655_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100653_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13101787_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13120652_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101787_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101814_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13120650_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101814_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13120652_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101823_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101877_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101823_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13120650_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101832_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157288_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101832_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13101877_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102158_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164259_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102158_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164263_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102166_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164285_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102166_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164289_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102459_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13112074_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102459_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151708_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102516_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104190_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102516_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13146757_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102820_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13146755_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102820_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102836_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102828_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102836_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102828_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13102856_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13120671_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102856_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102883_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13120669_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102883_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13120671_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102892_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13120669_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102892_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102992_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102901_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102992_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102901_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157271_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102919_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164272_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102919_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164276_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102928_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13112060_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102928_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13153896_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102946_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164270_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13102946_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164296_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103456_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157273_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103456_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157895_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103703_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103768_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103703_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152788_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103714_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103737_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103714_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103768_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103725_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103737_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103725_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13103919_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104188_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13103919_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104198_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13103926_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104188_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13103926_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104083_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13144759_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13104083_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13104190_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104191_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104190_3 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104198_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13104191_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151642_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13107371_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107378_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107378_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107379_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13108069_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13108070_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13108069_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13165716_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13108939_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108941_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108939_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108951_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108941_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108942_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108942_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128420_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109155_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109258_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109155_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157899_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109209_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13112076_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109209_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164263_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109211_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13112074_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109211_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109212_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109211_3 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13112076_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109212_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109922_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109255_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13112062_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109255_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164276_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109257_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13112060_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109257_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109258_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109257_3 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13112062_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109399_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109415_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109399_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164473_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109409_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109415_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109409_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13109435_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109449_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109435_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164484_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109443_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109449_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109443_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13109473_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164283_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109473_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109490_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109481_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109490_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109481_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13109512_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164298_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109512_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164302_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109520_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164302_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109520_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13109922_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157937_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13110789_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13146755_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13110789_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13146757_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13110965_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157982_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13110969_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158021_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13111128_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111136_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111128_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111156_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111138_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111156_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111165_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150865_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111165_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111183_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111173_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111183_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111662_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111664_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13113819_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113820_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113848_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113849_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113859_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114072_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113882_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114134_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113908_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114167_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113925_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114105_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114060_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114062_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114060_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114072_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114093_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114095_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114093_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114105_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114132_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114134_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114132_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114144_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114165_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114167_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114165_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114177_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13115875_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13116859_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13115875_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13116861_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13115905_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158178_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13115905_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13117038_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13115955_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116967_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13115955_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116969_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13115979_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117028_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13115979_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117032_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13116007_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13157324_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13116007_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13157326_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13116031_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157307_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13116031_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157309_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13116340_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157271_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13116340_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157273_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13116661_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117028_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13116661_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117024_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13116667_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116969_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116667_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13117010_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116690_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158174_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13116690_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158178_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13116696_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13116861_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13116696_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13158110_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13119995_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13140938_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13119995_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13140942_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13121160_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13121161_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13121187_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13121188_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13126729_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157288_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13126729_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157290_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13127616_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13127720_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13127616_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13128213_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13127640_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158174_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13127640_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140001_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13127669_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128594_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13127669_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128596_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13127691_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13158110_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13127691_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13158114_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13127927_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13128213_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13127927_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13128217_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13128243_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128596_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128243_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128420_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13128594_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139528_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13137298_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137632_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137417_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137419_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137438_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13137440_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13137623_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137637_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137623_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144580_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137632_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137633_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137637_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143820_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137637_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137645_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137755_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143988_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13137755_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144000_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13139104_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139143_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139104_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139149_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139147_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139149_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139518_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139526_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139518_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139539_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139524_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139526_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139528_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139539_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140001_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140621_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140004_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140613_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140474_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140550_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140474_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140554_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140538_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140540_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140538_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140554_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140540_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140541_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140541_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13158114_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140613_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140620_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140620_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140621_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140955_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140969_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140955_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140973_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13142742_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13153892_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13142742_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13153896_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13143797_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143829_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143819_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143820_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143819_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143827_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143829_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143830_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143941_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143988_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143988_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143989_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143992_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144145_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143992_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144000_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144072_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144140_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144140_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144141_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144144_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144145_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144144_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144152_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144189_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144191_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144191_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144390_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144211_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144417_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144211_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144636_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144390_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144610_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144398_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144610_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144398_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144629_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144422_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144629_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144422_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144423_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144422_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144636_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144423_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144543_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144573_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144548_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144560_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144560_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144572_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144572_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144594_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144572_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144580_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144573_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144594_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144728_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13144759_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13144728_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152987_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13144960_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155908_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146067_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155951_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146067_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155910_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146304_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155948_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146304_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155959_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146331_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146332_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146655_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159953_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13147571_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13162450_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13147571_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160175_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13148038_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163072_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13148038_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162993_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13148781_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149648_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149067_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150865_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149067_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150869_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149638_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150867_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149638_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160470_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13149648_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160468_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150867_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13150869_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13151634_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151642_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151634_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151689_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151681_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151689_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151681_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151738_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151708_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151782_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151738_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151774_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151774_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151792_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151782_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13151792_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13152235_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152609_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152235_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152545_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152537_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152545_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152537_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13153892_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152601_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152609_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152601_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152792_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152788_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152990_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152792_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152978_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152811_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152987_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152811_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152997_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152978_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152989_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152989_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152990_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152989_3 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13152997_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13155037_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13155039_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13155039_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159449_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13155511_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163213_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155511_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162376_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155908_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155952_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155910_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159023_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155951_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155952_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155951_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13155959_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13157151_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157290_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157151_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157933_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157880_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157895_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157880_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157911_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157899_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157911_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13157925_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157933_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157925_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157949_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157937_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157949_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13157965_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157978_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157965_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157992_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157982_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157992_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13158005_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158017_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158005_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158031_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158021_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158031_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158425_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158426_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158430_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158438_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158430_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158466_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158467_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158471_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158479_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158471_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158702_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158703_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158729_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13158730_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13158730_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159023_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159425_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159386_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159474_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159386_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159598_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159413_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159425_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159413_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159639_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159449_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159474_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159598_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159821_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159639_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159698_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159670_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159746_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159670_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159748_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159687_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159705_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159687_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159727_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159697_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159698_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159697_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162986_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159697_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159705_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159715_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159727_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159715_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159746_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159748_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159749_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159765_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159818_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159787_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159818_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159787_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159828_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159820_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159821_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159820_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163197_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159820_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159828_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159953_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159954_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159953_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160500_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159970_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162373_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159970_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160498_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160059_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160255_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160069_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160281_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160069_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160283_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160144_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160281_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160144_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160173_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160173_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160175_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160253_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160284_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160255_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160256_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160255_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160278_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160278_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160283_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160283_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160284_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160444_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160468_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160444_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160470_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13160487_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160498_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160487_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160508_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160500_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13160508_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162373_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162376_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162985_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162986_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162985_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163213_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162985_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13162993_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163026_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163086_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163026_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163088_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163058_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163072_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163058_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163086_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163186_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163204_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163186_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163207_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163196_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163197_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163196_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163204_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13164255_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164289_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164255_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164259_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164268_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164270_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164268_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164272_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164281_0 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164283_2 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164281_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164285_1 | SOURCEANDSINK | CL_přívodní vodní (10 °C) 1
Port_13164294_0 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164296_2 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164294_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164298_1 | SOURCEANDSINK | CL_vratné vodní (15 °C) 1
Port_13164465_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164467_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164465_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164469_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164476_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164478_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164476_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164480_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13165691_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13165692_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13165715_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13165716_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13167571_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13167572_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13167594_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13167595_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1

# IfcDistributionSystem: CL_přívodní vodní (10 °C), CL_přívodní vodní (10 °C) 1
PredefinedType: HEATING

# IfcDistributionSystem: CL_vratné vodní (15 °C), CL_vratné vodní (15 °C) 1
PredefinedType: HEATING

# IfcDistributionSystem: HT_přívodní vodní (65 °C) (4)
PredefinedType: HEATING
Name
HT_přívodní vodní (65 °C) 2
HT_přívodní vodní (65 °C) 4
HT_přívodní vodní (65 °C) 9
HT_přívodní vodní (65 °C) 6

# IfcDistributionSystem: HT_vratné vodní (45 °C) (8)
PredefinedType: HEATING
Name
HT_vratné vodní (45 °C) 1
HT_vratné vodní (45 °C) 4
HT_vratné vodní (45 °C) 3
HT_vratné vodní (45 °C) 6
HT_vratné vodní (45 °C) 7
HT_vratné vodní (45 °C) 10
HT_vratné vodní (45 °C) 2
HT_vratné vodní (45 °C) 17

# IfcPipeFitting: M_Koleno, obecné:Standardní (335)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní; Typ: Standardní
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12944408 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0001 | 0001 | no | 15.9375 | 9.5875
12944541 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0007 | 0007 | no | 15.9375 | 9.5875
12944558 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0008 | 0008 | no | 15.9375 | 9.5875
12945272 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0013 | 0013 | no | 15.9375 | 9.5875
