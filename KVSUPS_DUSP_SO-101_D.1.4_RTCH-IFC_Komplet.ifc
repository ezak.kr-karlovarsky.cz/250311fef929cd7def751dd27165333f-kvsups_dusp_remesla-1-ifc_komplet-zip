Properties of the parts of a building model (IFC4), part 14 of 23

# IfcDistributionPort (3628)
Name | FlowDirection | Group
Port_13064829_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064613_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064624_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064850_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064624_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064635_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064886_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064635_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064646_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064949_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064646_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064657_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158425_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064657_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158438_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064763_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064830_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064829_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064830_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064949_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158426_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13065093_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065163_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065105_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065105_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065162_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065162_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065191_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065162_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065163_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065191_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065266_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065193_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065266_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065193_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065241_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065356_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065241_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065266_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065357_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065331_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065423_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065331_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065356_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065424_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065356_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065357_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065423_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13146332_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065423_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065424_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065440_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065549_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065440_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065473_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065628_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065473_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065484_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065685_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065484_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065517_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065712_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065517_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065549_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065629_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065549_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065713_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065628_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065686_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065628_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065629_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065685_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065867_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065685_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065686_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065712_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066351_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065712_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065713_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065738_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065866_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065738_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065870_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065749_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065870_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065749_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065777_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065866_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065777_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065840_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065845_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065840_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065845_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065846_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065866_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065867_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065904_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065988_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065904_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066037_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065926_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066170_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065926_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065937_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065937_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066231_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065948_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066070_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065948_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065988_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066283_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066037_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066071_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066061_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066170_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066061_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066231_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066070_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066171_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066070_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066071_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066170_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066171_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066258_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066348_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066258_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066350_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066269_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066269_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066348_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066283_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066288_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066288_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066345_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066288_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13088535_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066345_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066350_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066350_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066351_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13066386_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066667_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066386_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066397_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066698_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066397_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066408_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066723_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066408_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066419_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066812_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066419_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066515_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067694_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066515_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13076531_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066541_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067693_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066541_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066667_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066699_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066698_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066724_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066698_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066699_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066714_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067620_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066714_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066812_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066723_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067621_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066723_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13066724_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067620_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067621_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067620_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067698_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067632_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067693_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067632_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067697_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067690_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067697_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067690_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144189_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067693_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067694_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067697_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13067698_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13069375_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070658_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069375_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140550_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069638_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140456_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069638_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140458_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069882_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069910_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069882_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140456_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069891_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069910_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069891_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070025_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069993_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070025_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13069993_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13106579_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070064_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070166_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070064_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070170_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070123_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070124_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070166_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13106579_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070259_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13106581_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13070650_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070658_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070650_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13139760_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070672_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13139760_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070672_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070807_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140973_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13070807_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13139524_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13070946_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13140938_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13070946_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139147_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13071509_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107327_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13071842_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144417_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13071842_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143992_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13072126_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072194_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072126_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072188_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13140942_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072188_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072194_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13072334_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072409_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072334_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072403_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13140969_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072403_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072409_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072947_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108941_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13072947_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13117010_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13073303_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13128217_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13073312_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13139143_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13073312_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13127720_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13074910_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140540_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13074910_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13140458_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13075686_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075812_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075686_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075687_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075686_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13111173_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075687_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13108951_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075769_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164469_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075769_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164473_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075771_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075812_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075771_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13164467_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13075840_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13157326_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13075840_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158017_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13075849_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076101_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13075849_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13110969_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076101_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106924_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076101_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13144960_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076102_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106924_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076102_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076331_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076223_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076358_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076223_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076362_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076244_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106926_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076244_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076358_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076331_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106926_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076355_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076362_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076355_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114144_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076445_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158466_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13076531_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13158425_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13076557_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107152_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13076557_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107156_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13076681_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144144_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13076681_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107150_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13077736_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107132_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077736_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107138_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077811_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143819_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077811_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107130_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077815_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107130_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077815_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107132_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077863_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137632_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13077863_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137645_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078038_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143827_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078038_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143829_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078212_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107140_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078212_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137419_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078214_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107138_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078214_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107140_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13078287_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078677_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078287_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078298_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078298_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078641_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078309_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078601_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078309_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078603_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078344_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078409_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078344_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078355_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078852_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078355_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078366_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078479_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078366_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078377_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078424_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078377_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078409_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078480_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078409_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078410_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078410_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078424_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078424_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078425_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078425_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078601_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078479_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078853_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078479_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078480_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078598_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078603_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078598_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078641_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078603_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078604_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078604_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078677_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078696_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078951_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078696_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078707_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078930_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078707_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078951_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078718_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078917_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078718_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078930_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078742_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079912_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078742_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078764_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079163_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078764_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078775_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079102_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078775_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078852_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159749_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078852_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078853_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078908_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078917_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078908_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078993_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078917_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081579_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078988_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078993_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078988_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080544_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078993_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078994_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13078994_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079976_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079102_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080445_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079102_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079164_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079163_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079977_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079163_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079164_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079253_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079976_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079253_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079810_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079738_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079874_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079738_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079782_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079787_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079782_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079787_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079788_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079787_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079956_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079788_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079874_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079805_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079810_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079805_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079810_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079811_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079811_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079912_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079955_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079956_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079976_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13079977_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080000_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080259_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080000_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080298_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080233_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080259_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080233_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080259_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080260_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080292_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080298_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080292_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080320_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080444_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080320_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080448_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080331_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080448_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080331_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080422_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080444_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080422_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080444_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080445_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080463_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080595_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080463_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080474_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080614_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080474_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080485_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080595_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080485_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080614_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080544_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080596_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080595_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080596_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13080633_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080916_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080633_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080644_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080644_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080910_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080655_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080758_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080655_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080666_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080815_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080666_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080677_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080677_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080855_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080690_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080916_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080690_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080910_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080758_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080962_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080758_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080816_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080759_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080815_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080759_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080855_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080815_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080816_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080916_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080952_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080952_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080961_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080961_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080962_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13080961_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143989_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081088_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081215_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081088_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081099_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081305_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081099_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081343_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081110_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081263_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081110_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081121_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081259_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081121_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081132_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081267_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081132_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081143_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081305_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081143_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081215_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081260_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081259_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081264_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081259_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081260_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081263_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081268_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081263_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081264_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081267_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081306_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081267_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081268_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081305_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081306_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081343_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13143941_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081579_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13159748_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081595_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081986_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081595_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082089_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081608_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082089_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081608_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081619_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081986_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081619_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081630_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081630_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082064_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081641_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081641_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082068_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081652_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081652_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082072_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081674_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081830_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081674_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081685_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081793_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081685_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081696_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081938_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081696_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081707_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081942_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081707_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081718_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081946_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081718_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081729_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081950_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081729_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081740_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081954_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081740_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081793_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081939_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081793_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081794_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081794_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081830_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081938_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081943_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081938_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081939_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081942_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081947_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081942_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081943_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081946_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081951_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081946_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081947_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081950_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081955_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081950_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081951_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081954_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084741_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081954_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081955_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13081986_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082065_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081987_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082072_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13081987_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084552_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082064_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082069_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082064_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082065_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082068_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082073_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082068_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082069_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082072_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082073_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082117_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082464_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082117_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082128_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082409_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082128_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082139_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082139_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082413_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082175_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082291_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082175_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082216_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082542_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082216_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082238_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082567_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082238_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084023_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082291_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082406_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082309_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082405_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082309_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082321_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082413_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082321_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082525_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082405_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082406_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082405_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082465_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082409_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082414_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082409_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082439_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082413_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082414_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082439_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084548_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082464_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084549_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082464_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082465_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082518_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082542_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082518_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082567_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082525_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082543_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082525_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082526_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082526_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082542_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082543_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13082599_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082817_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082599_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082610_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082825_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082610_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082621_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082829_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082621_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082632_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082819_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082632_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082643_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082829_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082643_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082819_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082687_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082899_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082687_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082901_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082698_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082698_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082899_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082709_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082863_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082709_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082817_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082845_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082825_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082830_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082825_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082826_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082826_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082844_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082829_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082830_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082844_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082845_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082844_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082864_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082863_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082902_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082863_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082864_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082901_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083095_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082901_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082902_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082929_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083117_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082929_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082940_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083204_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082940_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082973_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083094_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082973_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083160_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082984_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083020_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082984_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083054_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082995_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083020_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13082995_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083020_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084811_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083054_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083061_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083061_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083094_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083094_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083095_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083108_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083204_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083108_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083928_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083117_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083205_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083117_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083161_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083160_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083164_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083160_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083161_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083164_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083273_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083166_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083273_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083166_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083204_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083205_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083785_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083892_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083785_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083928_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083796_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083892_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083796_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084114_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13083807_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084242_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13083807_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084023_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084114_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13106714_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084118_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13097398_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084118_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13098136_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084242_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13106667_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084246_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13097486_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084246_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13098287_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084446_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144140_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084446_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144152_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084482_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13084483_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13084482_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143797_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13084548_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084549_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084548_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144141_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084552_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13144072_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13084708_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084810_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084708_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13163088_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084741_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084810_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084810_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13084811_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085291_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13165715_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085291_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085302_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13165715_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085302_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085324_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085522_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085324_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085490_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086745_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085490_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087171_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085522_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087807_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085522_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13108070_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085615_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13108069_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085615_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13085635_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085873_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085635_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085892_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085646_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085923_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085646_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085657_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085982_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085657_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085668_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 17
Port_13085668_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 17
Port_13085690_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085873_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085690_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085796_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107154_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085796_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13137440_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085827_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107150_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085827_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107152_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085831_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107154_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085831_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13107156_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085873_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085874_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085874_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13137438_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085892_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085924_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085923_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085983_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085923_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085924_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085973_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085982_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085973_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085982_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13085983_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13086223_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086223_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086636_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086234_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086644_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086234_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086245_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086245_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086638_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086256_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086644_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086256_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086638_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086267_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086741_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086267_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086278_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086701_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086278_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086716_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086289_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087091_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086289_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086302_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086451_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086302_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086313_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086443_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086313_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086324_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086451_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086324_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086701_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086337_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086697_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086337_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086443_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086452_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086451_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086452_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086636_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086717_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086644_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086711_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086697_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086702_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086697_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086698_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086698_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086745_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086701_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086702_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086711_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086716_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086716_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086717_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086741_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086746_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086741_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13100555_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086745_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086746_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086760_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087091_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086760_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087133_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086771_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087012_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086771_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087133_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086782_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13087249_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13086782_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
