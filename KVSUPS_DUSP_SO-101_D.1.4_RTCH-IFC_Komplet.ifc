Properties of the parts of a building model (IFC4), part 11 of 23

# IfcSpace: Zástupce ředitele-2 A305-2:13124563, A305-2
In: 3.NP_SO-101
LongName: Zástupce ředitele-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 72.8809 m3; NetVolume: 72.8809 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.682041; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 209.755 W; Specifikované výkonové zatížení: 272.681 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00754904 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 72.8809 m3; Plocha: 19.4869 m2
Identifikační data - Číslo: A305-2; Číslo místnosti: Neobsazené; Název: Zástupce ředitele-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Úklid-1 A0104-1:13095503, A0104-1
In: -1.PP_SO-101
LongName: Úklid-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 12.5502 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.167098; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 51.3893 W; Specifikované výkonové zatížení: 66.8061 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00184949 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 12.5502 m3; Plocha: 4.77422 m2
Identifikační data - Číslo: A0104-1; Číslo místnosti: Neobsazené; Název: Úklid-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid-1 A412-1:13099970, A412-1
In: 4.NP_SO-101
LongName: Úklid-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 4.97145 m3; NetVolume: 4.97145 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0756525; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 23.2662 W; Specifikované výkonové zatížení: 30.2461 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000837345 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 4.97145 m3; Plocha: 2.1615 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A412-1; Číslo místnosti: Neobsazené; Název: Úklid-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid-2 A0104-2:13124960, A0104-2
In: -1.PP_SO-101
LongName: Úklid-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 12.5502 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.167098; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 51.3893 W; Specifikované výkonové zatížení: 66.8061 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00184949 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 12.5502 m3; Plocha: 4.77422 m2
Identifikační data - Číslo: A0104-2; Číslo místnosti: Neobsazené; Název: Úklid-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Úklid-2 A412-2:13124474, A412-2
In: 4.NP_SO-101
LongName: Úklid-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 4.97145 m3; NetVolume: 4.97145 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0756525; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 23.2662 W; Specifikované výkonové zatížení: 30.2461 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000837345 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 4.97145 m3; Plocha: 2.1615 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A412-2; Číslo místnosti: Neobsazené; Název: Úklid-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Ředitelna-1 A301-1:13095291, A301-1
In: 3.NP_SO-101
LongName: Ředitelna-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 231.664 m3; NetVolume: 231.664 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 2.16798; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 666.74 W; Specifikované výkonové zatížení: 866.762 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 20 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0239958 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 231.664 m3; Plocha: 61.9421 m2
Identifikační data - Číslo: A301-1; Číslo místnosti: Neobsazené; Název: Ředitelna-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Ředitelna-2 A301-2:13124522, A301-2
In: 3.NP_SO-101
LongName: Ředitelna-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 231.664 m3; NetVolume: 231.664 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 2.16798; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 666.74 W; Specifikované výkonové zatížení: 866.762 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0239958 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 231.664 m3; Plocha: 61.9421 m2
Identifikační data - Číslo: A301-2; Číslo místnosti: Neobsazené; Název: Ředitelna-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šablonárna-1 A0103-1:13095500, A0103-1
In: -1.PP_SO-101
LongName: Šablonárna-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 52.6757 m3; NetVolume: 52.6757 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 52.6757 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103-1; Číslo místnosti: Neobsazené; Název: Šablonárna-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šablonárna-2 A0103-2:13124914, A0103-2
In: -1.PP_SO-101
LongName: Šablonárna-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 52.6757 m3; NetVolume: 52.6757 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.637941; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 196.193 W; Specifikované výkonové zatížení: 255.05 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00706093 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 52.6757 m3; Plocha: 18.2269 m2
Identifikační data - Číslo: A0103-2; Číslo místnosti: Neobsazené; Název: Šablonárna-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna - M A0111:13095518, A0111
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111; Číslo místnosti: Neobsazené; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - M A0115.1:13095506, A0115.1
In: -1.PP_SO-101
LongName: Šatna - M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1; Číslo místnosti: Neobsazené; Název: Šatna - M; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0108:13095515, A0108
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108; Číslo místnosti: Neobsazené; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna - Ž A0114.1:13095512, A0114.1
In: -1.PP_SO-101
LongName: Šatna - Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1; Číslo místnosti: Neobsazené; Název: Šatna - Ž; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna-M A0111:13124931, A0111
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.674 m3; NetVolume: 14.674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.2233; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6737 W; Specifikované výkonové zatížení: 89.2759 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00247155 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 14.674 m3; Plocha: 6.38 m2
Identifikační data - Číslo: A0111; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M A0114.1:13124964, A0114.1
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.5331 m3; NetVolume: 38.5331 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.586374; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 180.334 W; Specifikované výkonové zatížení: 234.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00649017 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.5331 m3; Plocha: 16.7535 m2
Identifikační data - Číslo: A0114.1; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-M A0115.1:13124965, A0115.1
In: -1.PP_SO-101
LongName: Šatna-M; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 38.9041 m3; NetVolume: 38.9041 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.59202; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 182.07 W; Specifikované výkonové zatížení: 236.691 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00655266 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 38.9041 m3; Plocha: 16.9148 m2
Identifikační data - Číslo: A0115.1; Číslo místnosti: Neobsazené; Název: Šatna-M; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna-Ž A0108:13124933, A0108
In: -1.PP_SO-101
LongName: Šatna-Ž; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 10.35 m3; NetVolume: 10.35 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.1575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 48.4376 W; Specifikované výkonové zatížení: 62.9689 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00174326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-101; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Objem: 10.35 m3; Plocha: 4.5 m2
Identifikační data - Číslo: A0108; Číslo místnosti: Neobsazené; Název: Šatna-Ž; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šicí a střihačská dílna-1 A401-1:13099985, A401-1
In: 4.NP_SO-101
LongName: Šicí a střihačská dílna-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 874.79 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 7.73182; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2377.85 W; Specifikované výkonové zatížení: 3091.2 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0855782 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 874.79 m3; Plocha: 220.909 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A401-1; Číslo místnosti: Neobsazené; Název: Šicí a střihačská dílna-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šicí a střihačská dílna-2 A401-2:13124484, A401-2
In: 4.NP_SO-101
LongName: Šicí a střihačská dílna-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 874.79 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 7.73182; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2377.85 W; Specifikované výkonové zatížení: 3091.2 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0855782 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-101; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-101
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Neohraničená výška: 4000 mm; Objem: 874.79 m3; Plocha: 220.909 m2; Výpočtová výška: 800 mm
Identifikační data - Číslo: A401-2; Číslo místnosti: Neobsazené; Název: Šicí a střihačská dílna-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcBuildingElementProxy: Trubkové otopné těleso - střední připojení:TR 1500/600 (2)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Text - Typ tělesa: TR
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Grafika - Napojení uprostřed: yes
Type - Kóty - Délka: 600 mm; Průměr trubky: 20 mm; Průměr trubky žebříku: 50 mm; Šířka: 47 mm; Výška: 1500 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.00.00; Kód sestavy: OT02; Model: Model; Nadpis OmniClass: Climate Control (HVAC); Název typu: TR 1500/600; Označení typu: 05; Popis: Otopné těleso; Popis sestavy: Trubkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Trubkové otopné těleso - střední připojení; Počet příček: 26; PZ: 25 mm
Classification: OT02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.43037 m2; NetVolume: 0.0106243 m3
Energetická analýza - Teplotní spád_Topení: 24; VÝKON TOPENÍ: 500 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000497572 m3/s; SPÁD TLAKU: 0.92 Pa
Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.0106243 m3
Jiné - AP: 180 deg; AZ: 180 deg; Id typu: 12918328; ON: 275 mm; PP: 7.5 mm; Průměr připojení: 15 mm; Rodina: Trubkové otopné těleso - střední připojení; Rodina a typ: Trubkové otopné těleso - střední připojení: TR 1500/600; Typ: TR 1500/600; VN: 150 mm
Name (Trubkové otopné těleso - střední připojení:TR 1500/600:...) | Kód prvku | Označení
12919029 | OT02.05.0096 | 0096
12919413 | OT02.05.0097 | 0097

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C2 600/66 (19)
Type - Material: <Unnamed>
Type - Energetická analýza - Teplotní spád_Topení: 15
Type - Text - Typ tělesa: ATOL C2
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; SPÁD TLAKU: 0 Pa
Type - Kóty - Celková výška: 680 mm; Šířka: 66 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.17.11; Kód sestavy: OT03; Komentáře k typům: článkové; Model: Model; Nadpis OmniClass: Radiators; Název typu: ATOL C2 600/66; Označení typu: 02; Popis: Otopné těleso; Popis sestavy: Článkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; C: 30 mm; Článek_Šířka: 60 mm; Název rodiny: Článkové otopné těleso - boční připojení; RV: 40 mm
Classification: OT03 Uniformat (Uniformat)
Energetická analýza - TEPLOTNÍ SPÁD_VYTÁPĚNÍ: 20; VÝKON TOPENÍ: 800 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od podlahy: 50 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000955338 m3/s
Kóty - Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 10 mm
Jiné - PA: 0 deg; PH: 0 mm; Rodina: Článkové otopné těleso - boční připojení; Výběr hlavice: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; Výběr šroubení: Šroubení pro otopná tělesa rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; ZA: 0 deg; ZH: 0 mm; Id typu: 12915800; PV: 540 mm; Rodina a typ: Článkové otopné těleso - boční připojení: ATOL C2 600/66; Typ: ATOL C2 600/66; ZV: 40 mm
Name (Článkové otopné těleso - boční připojení:ATOL C2 600/66:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Délka (mm) | Kód prvku | Označení | Počet článků
12782375 | 1.NP_SO-101 | 1.59861 | 0.0164343 | Podlaží : 1.NP_SO-101 | 0 | 1.NP_SO-101 | 720 | OT03.02.0003 | 0003 | 12
12782384 | 1.NP_SO-101 | 1.72752 | 0.0177825 | Podlaží : 1.NP_SO-101 | 0 | 1.NP_SO-101 | 780 | OT03.02.0004 | 0004 | 13
12782393 | 1.NP_SO-101 | 1.72752 | 0.0177825 | Podlaží : 1.NP_SO-101 | 0 | 1.NP_SO-101 | 780 | OT03.02.0005 | 0005 | 13
12782402 | 1.NP_SO-101 | 1.72752 | 0.0177825 | Podlaží : 1.NP_SO-101 | 0 | 1.NP_SO-101 | 780 | OT03.02.0006 | 0006 | 13
12783068 | 1.NP_SO-101 | 2.24318 | 0.0231751 | Podlaží : 1.NP_SO-101 | 0 | 1.NP_SO-101 | 1020 | OT03.02.0016 | 0016 | 17
12789263 | 2.NP_SO-101 | 3.14557 | 0.0326122 | Podlaží : 2.NP_SO-101 | 0 | 2.NP_SO-101 | 1440 | OT03.02.0030 | 0030 | 24
12789272 | 2.NP_SO-101 | 3.14557 | 0.0326122 | Podlaží : 2.NP_SO-101 | 0 | 2.NP_SO-101 | 1440 | OT03.02.0031 | 0031 | 24
12789765 | 2.NP_SO-101 | 1.85643 | 0.0191307 | Podlaží : 2.NP_SO-101 | 0 | 2.NP_SO-101 | 840 | OT03.02.0044 | 0044 | 14
12790060 | 2.NP_SO-101 | 0.954041 | 0.00969358 | Podlaží : 2.NP_SO-101 | -1700 | 2.NP_SO-101 | 420 | OT03.02.0046 | 0046 | 7
12792375 | 3.NP_SO-101 | 1.59861 | 0.0164343 | Podlaží : 3.NP_SO-101 | 0 | 3.NP_SO-101 | 720 | OT03.02.0055 | 0055 | 12
12792424 | 3.NP_SO-101 | 1.08295 | 0.0110417 | Podlaží : 3.NP_SO-101 | -2006 | 3.NP_SO-101 | 480 | OT03.02.0060 | 0060 | 8
12796263 | 4.NP_SO-101 | 1.46969 | 0.0150862 | Podlaží : 4.NP_SO-101 | 0 | 4.NP_SO-101 | 660 | OT03.02.0080 | 0080 | 11
12796318 | 4.NP_SO-101 | 1.46969 | 0.0150862 | Podlaží : 4.NP_SO-101 | 0 | 4.NP_SO-101 | 660 | OT03.02.0081 | 0081 | 11
12918900 | -1.PP_SO-101 | 1.59861 | 0.0164343 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | 720 | OT03.02.0093 | 0093 | 12 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12918949 | -1.PP_SO-101 | 1.46969 | 0.0150862 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | 660 | OT03.02.0094 | 0094 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12918957 | -1.PP_SO-101 | 1.46969 | 0.0150862 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | 660 | OT03.02.0095 | 0095 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12919494 | -1.PP_SO-101 | 1.08295 | 0.0110417 | Podlaží : -1.PP_SO-101 | 0 | -1.PP_SO-101 | 480 | OT03.02.0098 | 0098 | 8 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12921485 | 2.NP_SO-101 | 0.954041 | 0.00969358 | Podlaží : 2.NP_SO-101 | -1700 | 2.NP_SO-101 | 420 | OT03.02.0111 | 0111 | 7
12922132 | 3.NP_SO-101 | 1.08295 | 0.0110417 | Podlaží : 3.NP_SO-101 | -2006 | 3.NP_SO-101 | 480 | OT03.02.0113 | 0113 | 8 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C2 900/66 (2)
Type - Material: <Unnamed>
Type - Energetická analýza - Teplotní spád_Topení: 15
Type - Text - Typ tělesa: ATOL C2
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; SPÁD TLAKU: 0 Pa
Type - Kóty - Celková výška: 980 mm; Šířka: 66 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.17.11; Kód sestavy: OT03; Komentáře k typům: článkové; Model: Model; Nadpis OmniClass: Radiators; Název typu: ATOL C2 900/66; Označení typu: 04; Popis: Otopné těleso; Popis sestavy: Článkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; C: 30 mm; Článek_Šířka: 60 mm; Název rodiny: Článkové otopné těleso - boční připojení; RV: 40 mm
Classification: OT03 Uniformat (Uniformat)
Energetická analýza - TEPLOTNÍ SPÁD_VYTÁPĚNÍ: 20; VÝKON TOPENÍ: 800 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Odsazení od podlahy: 50 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000955338 m3/s
Kóty - Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 10 mm
Jiné - PA: 0 deg; PH: 0 mm; Rodina: Článkové otopné těleso - boční připojení; Výběr hlavice: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; Výběr šroubení: Šroubení pro otopná tělesa rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; ZA: 0 deg; ZH: 0 mm; Id typu: 12942086; PV: 540 mm; Rodina a typ: Článkové otopné těleso - boční připojení: ATOL C2 900/66; Typ: ATOL C2 900/66; ZV: 40 mm
Name (Článkové otopné těleso - boční připojení:ATOL C2 900/66:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Podlaží | Hostitel | Délka (mm) | Kód prvku | Označení | Počet článků
12789165 | 1.NP_SO-101 | 1.83952 | 0.0190986 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 600 | OT03.04.0023 | 0023 | 10
12797050 | 3.NP_SO-101 | 1.66074 | 0.0172144 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 540 | OT03.04.0082 | 0082 | 9

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C3 600/107 (103)
Type - Material: <Unnamed>
Type - Energetická analýza - Teplotní spád_Topení: 15
Type - Text - Typ tělesa: ATOL C3
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; SPÁD TLAKU: 0 Pa
Type - Kóty - Celková výška: 680 mm; Šířka: 107 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.17.11; Kód sestavy: OT03; Komentáře k typům: článkové; Model: Model; Nadpis OmniClass: Radiators; Název typu: ATOL C3 600/107; Označení typu: 03; Popis: Otopné těleso; Popis sestavy: Článkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; C: 30 mm; Článek_Šířka: 60 mm; Název rodiny: Článkové otopné těleso - boční připojení; RV: 40 mm
Classification: OT03 Uniformat (Uniformat)
Energetická analýza - TEPLOTNÍ SPÁD_VYTÁPĚNÍ: 20; VÝKON TOPENÍ: 800 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000955338 m3/s
Kóty - Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 10 mm
Jiné - PA: 0 deg; PH: 0 mm; Rodina: Článkové otopné těleso - boční připojení; Výběr hlavice: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; Výběr šroubení: Šroubení pro otopná tělesa rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; ZA: 0 deg; ZH: 0 mm; Id typu: 12915526; PV: 540 mm; Rodina a typ: Článkové otopné těleso - boční připojení: ATOL C3 600/107; Typ: ATOL C3 600/107; ZV: 40 mm
Name (Článkové otopné těleso - boční připojení:ATOL C3 600/107:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Odsazení od podlahy (mm) | Odsazení od stěny (mm) | Délka (mm) | Kód prvku | Označení | Počet článků
12782420 | 1.NP_SO-101 | 3.21497 | 0.0372593 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 1020 | OT03.03.0007 | 0007 | 17
12782429 | 1.NP_SO-101 | 2.84281 | 0.032906 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 900 | OT03.03.0008 | 0008 | 15
12782438 | 1.NP_SO-101 | 2.84281 | 0.032906 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 900 | OT03.03.0009 | 0009 | 15
12782451 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0010 | 0010 | 13
12782717 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0011 | 0011 | 13
12782838 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0012 | 0012 | 13
12782846 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0013 | 0013 | 13
12782858 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0014 | 0014 | 13
12783004 | 1.NP_SO-101 | 3.58712 | 0.0416126 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 1140 | OT03.03.0015 | 0015 | 19
12783084 | 1.NP_SO-101 | 3.21497 | 0.0372593 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 1020 | OT03.03.0017 | 0017 | 17
12783092 | 1.NP_SO-101 | 3.21497 | 0.0372593 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 1020 | OT03.03.0018 | 0018 | 17
12783102 | 1.NP_SO-101 | 3.21497 | 0.0372593 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 1020 | OT03.03.0019 | 0019 | 17
12788972 | 1.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 720 | OT03.03.0020 | 0020 | 12
