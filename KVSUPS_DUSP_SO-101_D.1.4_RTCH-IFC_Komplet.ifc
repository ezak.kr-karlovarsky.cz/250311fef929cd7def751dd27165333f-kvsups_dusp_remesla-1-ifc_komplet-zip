Properties of the parts of a building model (IFC4), part 22 of 23

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (670)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
13113820 | -1.PP_SO-101 | 965.474 | 0.000201032 | 0.04853 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 236 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0751 | 0751 | no
13113849 | -1.PP_SO-101 | 765.474 | 0.000201032 | 0.0384769 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 203 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0752 | 0752 | no
13113859 | -1.PP_SO-101 | 3547.45 | 0.000201032 | 0.178314 | ø16 mm | 0.000862069 | HD | -352 | -360 | -360 | -1.PP_SO-101 | 0 | -368 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3515.8 | 16 | 255 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0753 | 0753 | no
13113882 | -1.PP_SO-101 | 664.063 | 0.000201032 | 0.0333794 | ø16 mm | 0.000862069 | HD | -352 | -360 | -360 | -1.PP_SO-101 | 0 | -368 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3515.8 | 16 | 210 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0754 | 0754 | no
13113908 | -1.PP_SO-101 | 564.063 | 0.000201032 | 0.0283529 | ø16 mm | 0.000862069 | HD | -342 | -350 | -350 | -1.PP_SO-101 | 0 | -358 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3505.8 | 16 | 243 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0755 | 0755 | no
13113925 | -1.PP_SO-101 | 3647.45 | 0.000201032 | 0.183341 | ø16 mm | 0.000862069 | HD | -342 | -350 | -350 | -1.PP_SO-101 | 0 | -358 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3505.8 | 16 | 285 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0756 | 0756 | no
13114060 | -1.PP_SO-101 | 268.125 | 0.000201032 | 0.0134774 | ø16 mm | 0.000862069 | HD | -75.9375 | -344.063 | -75.9375 | -1.PP_SO-101 |  | -344.063 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3494.06 | 16 | 255 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0757 | 0757 | no
13114093 | -1.PP_SO-101 | 268.125 | 0.000201032 | 0.0134774 | ø16 mm | 0.000862069 | HD | -65.9375 | -334.063 | -65.9375 | -1.PP_SO-101 |  | -334.063 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3484.06 | 16 | 285 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0758 | 0758 | no
13114132 | -1.PP_SO-101 | 268.125 | 0.000201032 | 0.0134774 | ø16 mm | 0.000862069 | HD | -75.9375 | -75.9375 | -344.063 | -1.PP_SO-101 |  | -344.063 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3494.06 | 16 | 210 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0759 | 0759 | no
13114165 | -1.PP_SO-101 | 268.125 | 0.000201032 | 0.0134774 | ø16 mm | 0.000862069 | HD | -65.9375 | -65.9375 | -334.063 | -1.PP_SO-101 |  | -334.063 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3484.06 | 16 | 243 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0760 | 0760 | no
13121161 | -1.PP_SO-101 | 8850.67 | 0.000201032 | 0.444883 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 15 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0773 | 0773 | no
13121188 | -1.PP_SO-101 | 243.646 | 0.000201032 | 0.012247 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 93 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0774 | 0774 | no
13137298 | 2.NP_SO-101 | 1614.21 | 0.000201032 | 0.0811388 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 205 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0782 | 0782 | no
13137633 | 2.NP_SO-101 | 4998.44 | 0.000201032 | 0.251249 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 204 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0784 | 0784 | no
13137755 | 2.NP_SO-101 | 355.172 | 0.000201032 | 0.0178529 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 289 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0785 | 0785 | no
13143797 | 3.NP_SO-101 | 5005.88 | 0.000201032 | 0.251623 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 212 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0796 | 0796 | no
13143830 | 3.NP_SO-101 | 1614.62 | 0.000201032 | 0.0811598 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 208 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0798 | 0798 | no
13143941 | 2.NP_SO-101 | 1258.94 | 0.000201032 | 0.063281 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 161 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0799 | 0799 | no
13143989 | 2.NP_SO-101 | 5353.71 | 0.000201032 | 0.269107 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 163 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0800 | 0800 | no
13144072 | 3.NP_SO-101 | 1258.94 | 0.000201032 | 0.063281 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 38 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0801 | 0801 | no
13144141 | 3.NP_SO-101 | 5361.56 | 0.000201032 | 0.269502 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 39 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0802 | 0802 | no
13146304 | 1.NP_SO-101 | 711.543 | 0.000201032 | 0.0357661 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 270 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0813 | 0813 | no
13146332 | 1.NP_SO-101 | 4528.95 | 0.000201032 | 0.22765 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 150 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0814 | 0814 | no
13146655 | 4.NP_SO-101 | 5159.58 | 0.000201032 | 0.259349 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 99 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0815 | 0815 | no
13148038 | 3.NP_SO-101 | 133.335 | 0.000201032 | 0.00670216 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 285 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0817 | 0817 | no
13149638 | 4.NP_SO-101 | 47.461 | 0.000201032 | 0.00238565 | ø16 mm | 0.000862069 | HD | -102 | -110 | -110 | 4.NP_SO-101 | 0 | -118 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 11884.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0819 | 0819 | no
13149648 | 4.NP_SO-101 | 4152.43 | 0.000201032 | 0.208724 | ø16 mm | 0.000862069 | HD | -102 | -110 | -110 | 4.NP_SO-101 | 0 | -118 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 11884.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0820 | 0820 | no
13158426 | 1.NP_SO-101 | 2269.39 | 0.000201032 | 0.114072 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 138 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0843 | 0843 | no
13158430 | 1.NP_SO-101 | 724.063 | 0.000201032 | 0.0363954 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 139 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0844 | 0844
13158467 | 1.NP_SO-101 | 2237.43 | 0.000201032 | 0.112466 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 98 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0845 | 0845 | no
13158471 | 1.NP_SO-101 | 964.063 | 0.000201032 | 0.0484591 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 107 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0846 | 0846
13158703 | -1.PP_SO-101 | 9517.96 | 0.000201032 | 0.478425 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 201 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0847 | 0847 | no
13158730 | -1.PP_SO-101 | 1981.21 | 0.000201032 | 0.0995862 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 296 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0848 | 0848 | no
13159670 | 2.NP_SO-101 | 5291.16 | 0.000201032 | 0.265963 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 310 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0853 | 0853
13159687 | 2.NP_SO-101 | 201.959 | 0.000201032 | 0.0101515 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 310 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0854 | 0854
13159715 | 2.NP_SO-101 | 599.186 | 0.000201032 | 0.0301184 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 310 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0856 | 0856
13159749 | 2.NP_SO-101 | 5239.77 | 0.000201032 | 0.26338 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 35 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0857 | 0857 | no
13159765 | 2.NP_SO-101 | 450.196 | 0.000201032 | 0.0226293 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 115 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0858 | 0858
13159787 | 2.NP_SO-101 | 406.129 | 0.000201032 | 0.0204143 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 115 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0859 | 0859
13159954 | 4.NP_SO-101 | 1753.59 | 0.000201032 | 0.088145 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 245 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0861 | 0861 | no
13159970 | 4.NP_SO-101 | 80.766 | 0.000201032 | 0.00405974 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 307 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0862 | 0862
13160059 | 4.NP_SO-101 | 4766.83 | 0.000201032 | 0.239607 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 102 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0863 | 0863 | no
13160069 | 4.NP_SO-101 | 946.421 | 0.000201032 | 0.0475723 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 301 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0864 | 0864
13160144 | 4.NP_SO-101 | 293.989 | 0.000201032 | 0.0147775 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 301 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0865 | 0865
13160256 | 4.NP_SO-101 | 18077 | 0.000201032 | 0.908647 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 108 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0866 | 0866 | no
13160278 | 4.NP_SO-101 | 1488.56 | 0.000201032 | 0.0748231 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 305 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0867 | 0867 | no
13160284 | 4.NP_SO-101 | 5124.62 | 0.000201032 | 0.257591 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 307 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0868 | 0868 | no
13160444 | 4.NP_SO-101 | 99.9775 | 0.000201032 | 0.00502542 | ø16 mm | 0.000862069 | HD | -102 | -110 | -110 | 4.NP_SO-101 | 0 | -118 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 11884.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0869 | 0869
13160487 | 4.NP_SO-101 | 276.34 | 0.000201032 | 0.0138903 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 307 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0870 | 0870
13160500 | 4.NP_SO-101 | 709.4 | 0.000201032 | 0.0356583 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 307 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0871 | 0871
13163026 | 3.NP_SO-101 | 1033.8 | 0.000201032 | 0.0519645 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 285 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0873 | 0873 | no
13163058 | 3.NP_SO-101 | 438.147 | 0.000201032 | 0.0220237 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 285 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0874 | 0874
13163186 | 3.NP_SO-101 | 450.2 | 0.000201032 | 0.0226295 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 142 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0875 | 0875
13165692 | 4.NP_SO-101 | 2707.42 | 0.000201032 | 0.13609 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 310 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0883 | 0883 | no
13165716 | 4.NP_SO-101 | 3007.42 | 0.000201032 | 0.15117 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 237 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0884 | 0884 | no
13167572 | -1.PP_SO-101 | 1841.13 | 0.000201032 | 0.0925455 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 91 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0885 | 0885 | no
13167595 | -1.PP_SO-101 | 1841.13 | 0.000201032 | 0.0925455 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 13 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0886 | 0886 | no

# IfcPipeSegment: Typy trubek:Měď_domovní rozvody, Typy trubek:Měď_domovní rozvody:13155037
In: 1.NP_SO-101
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR01; Komentáře k typům: Pro veškeré domovní rozvody (EN 1057); Model: SUPERSAN/SANCO; Název typu: Měď_domovní rozvody; Označení typu: 04; Popis: CU; Popis sestavy: Měď; Výrobce: Wieland - Buntmetall
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR01 Uniformat (Uniformat); Group: HT_přívodní vodní (65 °C) 2
Qto_PipeSegmentBaseQuantities - Length: 35.7186 mm; GrossCrossSectionArea: 0.00125645 m2; NetCrossSectionArea: 0.00125645 m2; OuterSurfaceArea: 0.00448853 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm
Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Relativní drsnost: 0; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Referenční podlaží: 1.NP_SO-101; Horní výška: 19.0561 mm; Koncová střední výška: 19.0561 mm; Počáteční střední výška: -16.6625 mm; Spodní výška: -16.6625 mm; Střední výška: -16.6625 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_přívodní vodní (65 °C); Drsnost: 0 mm; Klasifikace systému: Přívod teplé vody; Název systému: HT_přívodní vodní (65 °C) 2; Obrátit výšku: -16.6625 mm; Plocha: 0.00448853 m2; Průměr: 40 mm; Řez: 99; Typ přípoje: Obecné
Kóty - Délka: 35.7186 mm; Velikost: ø40; Vnější průměr: 40 mm; Vnitřní průměr: 40 mm
Identifikační data - Kód prvku: TR01.04.0831; Označení: 0831
Jiné - Rodina: Typy trubek; Páteřní trasa: yes; Id typu: 9219992; Rodina a typ: Typy trubek: Měď_domovní rozvody; Typ: Měď_domovní rozvody

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (214)
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_uhlíková; Označení typu: 02; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.1 mm; Materiál: Kov, ocel; Popis úseku: FE; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ
Jiné - Rodina: Typy trubek; Id typu: 13106504; Rodina a typ: Typy trubek: Ocel_uhlíková; Typ: Ocel_uhlíková
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
12955056 | 2.NP_SO-101 | 3804.08 | 0.000356274 | 0.254553 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1923.36 | -1880.71 | 1923.36 | -1880.71 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2119.29 | 0.179263 | 15 | 235 | 3804.08 | ø15 | 21.3 | 16 | TR02.02.0193 | 0193 | no
12960779 | -1.PP_SO-101 | 1711.18 | 0.00285535 | 0.324162 | 40 | ø130 mm | 0.00188679 | HD | -1.PP_SO-101 | 2280.15 | 2250 | 2250 | 2219.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -926.5 | 0.268791 | 50 | 293 | 1711.18 | ø50 | 60.3 | 53 | TR02.02.0270 | 0270 | yes | 0 | Izolace - Typ izolace: Tepelná
12960786 | -1.PP_SO-101 | 2112.85 | 0.00285535 | 0.400255 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 0.331886 | 50 | 293 | 2112.85 | ø50 | 60.3 | 53 | TR02.02.0271 | 0271 | yes | 0
12960864 | -1.PP_SO-101 | 5089.79 | 0.00141175 | 0.677977 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -817.95 | 0.511681 | 32 | 289 | 5089.79 | ø32 | 42.4 | 35.9 | TR02.02.0272 | 0272 | yes | 0
12961346 | 1.NP_SO-101 | 2229.36 | 0.000568237 | 0.1884 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -953.181 | -3182.54 | -953.181 | -3182.54 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3182.54 | 0.140075 | 20 | 261 | 2229.36 | ø20 | 26.9 | 21.6 | TR02.02.0273 | 0273 | no
12961598 | -1.PP_SO-101 | 4389.79 | 0.00141175 | 0.584735 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -817.95 | 0.441309 | 32 | 194 | 4389.79 | ø32 | 42.4 | 35.9 | TR02.02.0274 | 0274 | yes | 0
12962498 | -1.PP_SO-101 | 3570.74 | 0.00285535 | 0.676433 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 0.56089 | 50 | 293 | 3570.74 | ø50 | 60.3 | 53 | TR02.02.0275 | 0275 | yes | 0
12963773 | 1.NP_SO-101 | 1175.88 | 0.000568237 | 0.0993727 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -935.92 | -949.37 | -949.37 | -962.82 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -960.17 | 0.073883 | 20 | 230 | 1175.88 | ø20 | 26.9 | 21.6 | TR02.02.0276 | 0276 | yes | 0
12964015 | 1.NP_SO-101 | 1123.48 | 0.00141175 | 0.149652 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2821.2 | 2800 | 2800 | 2778.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2782.05 | 0.112945 | 32 | 288 | 1123.48 | ø32 | 42.4 | 35.9 | TR02.02.0278 | 0278 | yes | 0
12964023 | 1.NP_SO-101 | 567.83 | 0.00141175 | 0.075637 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2821.2 | 2800 | 2800 | 2778.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2782.05 | 0.0570845 | 32 | 288 | 567.83 | ø32 | 42.4 | 35.9 | TR02.02.0279 | 0279 | yes | 0
12964579 | 1.NP_SO-101 | 3695.39 | 0.00141175 | 0.49224 | 40 | ø112 mm | 0.00278552 | HD | 1.NP_SO-101 | 2776.19 | -919.207 | 2776.19 | -919.207 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -919.207 | 0.371502 | 32 | 288 | 3695.39 | ø32 | 42.4 | 35.9 | TR02.02.0280 | 0280 | yes | Izolace - Typ izolace: Tepelná
12964870 | 1.NP_SO-101 | 881.431 | 0.000568237 | 0.0744887 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -935.92 | -949.37 | -949.37 | -962.82 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -960.17 | 0.0553819 | 20 | 230 | 881.431 | ø20 | 26.9 | 21.6 | TR02.02.0281 | 0281 | yes | 0
12964960 | 1.NP_SO-101 | 2211.67 | 0.000568237 | 0.186906 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -966.832 | -3178.51 | -966.832 | -3178.51 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3178.51 | 0.138964 | 20 | 230 | 2211.67 | ø20 | 26.9 | 21.6 | TR02.02.0283 | 0283 | yes
12965247 | 1.NP_SO-101 | 381.998 | 0.000568237 | 0.0322822 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -935.92 | -949.37 | -949.37 | -962.82 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -960.17 | 0.0240017 | 20 | 230 | 381.998 | ø20 | 26.9 | 21.6 | TR02.02.0286 | 0286 | yes | 0
12968049 | 1.NP_SO-101 | 2806.28 | 0.000891835 | 0.297106 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2779.36 | 2779.36 | -26.9188 | -26.9188 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -26.9188 | 0.220405 | 25 | 252 | 2806.28 | ø25 | 33.7 | 27.2 | TR02.02.0290 | 0290 | yes
12969324 | 1.NP_SO-101 | 763.481 | 0.00183197 | 0.11585 | 0 | ø40 mm | 0.00239234 | HD | 1.NP_SO-101 | -83.3375 | -846.819 | -83.3375 | -846.819 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -846.819 | 0.0959419 | 40 | 77 | 763.481 | ø40 | 48.3 | 41.8 | TR02.02.0294 | 0294 | yes
12969446 | 2.NP_SO-101 | 4.0025 | 0.000891835 | 0.000423751 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 3980.99 | 3980.99 | 3976.99 | 3976.99 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7976.99 | 0.000314356 | 25 | 308 | 4.0025 | ø25 | 33.7 | 27.2 | TR02.02.0296 | 0296 | yes
12969915 | 1.NP_SO-101 | 56.284 | 0.00141175 | 0.00749723 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | -878.8 | -900 | -900 | -921.2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.00565829 | 32 | 120 | 56.284 | ø32 | 42.4 | 35.9 | TR02.02.0300 | 0300 | yes | 0
12970121 | 2.NP_SO-101 | 12751.5 | 0.00141175 | 1.69855 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-101 | 7875.33 | 7875.33 | -4876.19 | -4876.19 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -876.188 | 1.28192 | 32 | 120 | 12751.5 | ø32 | 42.4 | 35.9 | TR02.02.0304 | 0304 | yes
12970420 | -1.PP_SO-101 | 454.195 | 0.00141175 | 0.0605004 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.0456607 | 32 | 194 | 454.195 | ø32 | 42.4 | 35.9 | TR02.02.0305 | 0305 | yes | 0
12970433 | 1.NP_SO-101 | 10.8663 | 0.000568237 | 0.000918302 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -886.55 | -900 | -900 | -913.45 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -910.8 | 0.000682753 | 20 | 200 | 10.8663 | ø20 | 26.9 | 21.6 | TR02.02.0306 | 0306 | yes | 0
12970443 | -1.PP_SO-101 | 2711.03 | 0.00141175 | 0.361118 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.272542 | 32 | 65 | 2711.03 | ø32 | 42.4 | 35.9 | TR02.02.0307 | 0307 | yes | 0
12970750 | 1.NP_SO-101 | 65.075 | 0.000568237 | 0.00549941 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -917.463 | -982.538 | -917.462 | -982.538 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -982.538 | 0.00408878 | 20 | 200 | 65.075 | ø20 | 26.9 | 21.6 | TR02.02.0308 | 0308 | yes
12970811 | -1.PP_SO-101 | 1376.89 | 0.000568237 | 0.116359 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -960.8 | 0.0865123 | 20 | 200 | 1376.89 | ø20 | 26.9 | 21.6 | TR02.02.0309 | 0309 | yes | 0
13058687 | -1.PP_SO-101 | 5189.83 | 0.000568237 | 0.438586 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2163.45 | 2150 | 2150 | 2136.55 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -1010.8 | 0.326086 | 20 | 200 | 5189.83 | ø20 | 26.9 | 21.6 | TR02.02.0371 | 0371 | yes | 0
13058933 | -1.PP_SO-101 | 3970.74 | 0.00285535 | 0.752208 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 0.623722 | 50 | 300 | 3970.74 | ø50 | 60.3 | 53 | TR02.02.0372 | 0372 | yes | 0
13058942 | -1.PP_SO-101 | 4739.79 | 0.00141175 | 0.631356 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -817.95 | 0.476495 | 32 | 64 | 4739.79 | ø32 | 42.4 | 35.9 | TR02.02.0373 | 0373 | yes | 0
13059091 | -1.PP_SO-101 | 5439.79 | 0.00141175 | 0.724599 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -817.95 | 0.546867 | 32 | 286 | 5439.79 | ø32 | 42.4 | 35.9 | TR02.02.0374 | 0374 | yes | 0
13069375 | 1.NP_SO-101 | 3502.38 | 0.00141175 | 0.466529 | 40 | ø112 mm | 0.00278552 | HD | 1.NP_SO-101 | 2676.19 | -826.188 | 2676.19 | -826.188 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -826.188 | 0.352097 | 32 | 285 | 3502.38 | ø32 | 42.4 | 35.9 | TR02.02.0432 | 0432 | yes | Izolace - Typ izolace: Tepelná
13069638 | 1.NP_SO-101 | 526.787 | 0.000568237 | 0.0445182 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -935.92 | -949.37 | -949.37 | -962.82 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -960.17 | 0.033099 | 20 | 220 | 526.787 | ø20 | 26.9 | 21.6 | TR02.02.0433 | 0433 | yes | 0
13069882 | -1.PP_SO-101 | 1475.88 | 0.000568237 | 0.124725 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2214.08 | 2200.63 | 2200.63 | 2187.18 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -960.17 | 0.0927326 | 20 | 220 | 1475.88 | ø20 | 26.9 | 21.6 | TR02.02.0434 | 0434 | yes | 0
13069891 | 1.NP_SO-101 | 1031.43 | 0.000568237 | 0.087165 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -935.92 | -949.37 | -949.37 | -962.82 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -960.17 | 0.0648067 | 20 | 220 | 1031.43 | ø20 | 26.9 | 21.6 | TR02.02.0435 | 0435 | yes | 0
13069993 | 1.NP_SO-101 | 2221.67 | 0.000568237 | 0.187751 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | -966.832 | -3188.51 | -966.832 | -3188.51 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3188.51 | 0.139592 | 20 | 220 | 2221.67 | ø20 | 26.9 | 21.6 | TR02.02.0436 | 0436 | yes
13070650 | 1.NP_SO-101 | 570.913 | 0.00141175 | 0.0760476 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2721.2 | 2700 | 2700 | 2678.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 2682.05 | 0.0573944 | 32 | 285 | 570.913 | ø32 | 42.4 | 35.9 | TR02.02.0439 | 0439 | yes | 0
13070672 | 1.NP_SO-101 | 1323.92 | 0.00141175 | 0.176351 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2721.2 | 2700 | 2700 | 2678.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 2682.05 | 0.133095 | 32 | 285 | 1323.92 | ø32 | 42.4 | 35.9 | TR02.02.0440 | 0440 | yes | 0
13070807 | 2.NP_SO-101 | 3714.46 | 0.000568237 | 0.313905 | 30 | ø80 mm | 0.00462963 | HD | 2.NP_SO-101 | -1217.46 | -4931.92 | -1217.46 | -4931.92 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -931.92 | 0.233386 | 20 | 68 | 3714.46 | ø20 | 26.9 | 21.6 | TR02.02.0441 | 0441 | yes | Izolace - Typ izolace: Tepelná
13070946 | 2.NP_SO-101 | 3715.08 | 0.000568237 | 0.313957 | 30 | ø80 mm | 0.00462963 | HD | 2.NP_SO-101 | -1217.46 | -4932.54 | -1217.46 | -4932.54 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -932.538 | 0.233425 | 20 | 198 | 3715.08 | ø20 | 26.9 | 21.6 | TR02.02.0442 | 0442 | yes | Izolace - Typ izolace: Tepelná
13071842 | 1.NP_SO-101 | 1192.38 | 0.000891835 | 0.126239 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 3913.01 | 3913.01 | 2720.64 | 2720.64 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2720.64 | 0.0936489 | 25 | 296 | 1192.38 | ø25 | 33.7 | 27.2 | TR02.02.0443 | 0443 | yes
13072126 | 2.NP_SO-101 | 3089.07 | 0.000568237 | 0.261054 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-101 | -36.55 | -50 | -50 | -63.45 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 3939.2 | 0.194092 | 20 | 198 | 3089.07 | ø20 | 26.9 | 21.6 | TR02.02.0444 | 0444 | yes | 0
13072188 | 1.NP_SO-101 | 1115.08 | 0.000568237 | 0.0942337 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | 3932.54 | 3932.54 | 2817.46 | 2817.46 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 2817.46 | 0.0700622 | 20 | 198 | 1115.08 | ø20 | 26.9 | 21.6 | TR02.02.0445 | 0445 | yes
13072334 | 2.NP_SO-101 | 3087.54 | 0.000568237 | 0.260924 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-101 | -36.55 | -50 | -50 | -63.45 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 3939.2 | 0.193996 | 20 | 68 | 3087.54 | ø20 | 26.9 | 21.6 | TR02.02.0446 | 0446 | yes | 0
13072403 | 1.NP_SO-101 | 1115.08 | 0.000568237 | 0.0942337 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | 3932.54 | 3932.54 | 2817.46 | 2817.46 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 2817.46 | 0.0700622 | 20 | 68 | 1115.08 | ø20 | 26.9 | 21.6 | TR02.02.0447 | 0447 | yes
13072947 | -1.PP_SO-101 | 586.816 | 0.00141175 | 0.0781659 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -917.95 | 0.0589932 | 32 | 64 | 586.816 | ø32 | 42.4 | 35.9 | TR02.02.0448 | 0448 | yes | 0
13073303 | -1.PP_SO-101 | 320.738 | 0.00141175 | 0.0427234 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.0322441 | 32 | 197 | 320.738 | ø32 | 42.4 | 35.9 | TR02.02.0449 | 0449 | yes | 0
13073312 | -1.PP_SO-101 | 2428.39 | 0.00141175 | 0.32347 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.2 | 2200 | 2200 | 2178.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -967.95 | 0.244128 | 32 | 197 | 2428.39 | ø32 | 42.4 | 35.9 | TR02.02.0450 | 0450 | yes | 0 | Izolace - Typ izolace: Tepelná
13074910 | -1.PP_SO-101 | 75.1556 | 0.00141175 | 0.010011 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -967.32 | 0.00755546 | 32 | 270 | 75.1556 | ø32 | 42.4 | 35.9 | TR02.02.0451 | 0451 | yes | 0 | Izolace - Typ izolace: Tepelná
13075687 | -1.PP_SO-101 | 2767.38 | 0.00141175 | 0.368624 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2171.2 | 2150 | 2150 | 2128.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -1017.95 | 0.278207 | 32 | 27 | 2767.38 | ø32 | 42.4 | 35.9 | TR02.02.0452 | 0452 | yes | 0
13075769 | -1.PP_SO-101 | 1395.08 | 0.000568237 | 0.117896 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -960.8 | 0.0876551 | 20 | 30 | 1395.08 | ø20 | 26.9 | 21.6 | TR02.02.0453 | 0453 | yes | 0
13075771 | -1.PP_SO-101 | 5135.62 | 0.000568237 | 0.434005 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2163.45 | 2150 | 2150 | 2136.55 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -1010.8 | 0.32268 | 20 | 30 | 5135.62 | ø20 | 26.9 | 21.6 | TR02.02.0454 | 0454 | yes | 0
13075840 | -1.PP_SO-101 | 2312.85 | 0.00285535 | 0.438142 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 0.363302 | 50 | 300 | 2312.85 | ø50 | 60.3 | 53 | TR02.02.0455 | 0455 | yes | 0
13075849 | -1.PP_SO-101 | 1391.18 | 0.00285535 | 0.263542 | 40 | ø130 mm | 0.00188679 | HD | -1.PP_SO-101 | 2280.15 | 2250 | 2250 | 2219.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -926.5 | 0.218526 | 50 | 300 | 1391.18 | ø50 | 60.3 | 53 | TR02.02.0456 | 0456 | yes | 0 | Izolace - Typ izolace: Tepelná
13076102 | 2.NP_SO-101 | 2239.36 | 0.000568237 | 0.189245 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-101 | -4953.18 | -7192.54 | -4953.18 | -7192.54 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3192.54 | 0.140703 | 20 | 227 | 2239.36 | ø20 | 26.9 | 21.6 | TR02.02.0457 | 0457 | no
13076557 | 4.NP_SO-101 | 622.013 | 0.000568237 | 0.0525656 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-101 | -86.55 | -100 | -100 | -113.45 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 11889.2 | 0.0390822 | 20 | 257 | 622.012 | ø20 | 26.9 | 21.6 | TR02.02.0463 | 0463 | no | 0
13076681 | 2.NP_SO-101 | 3909.93 | 0.000891835 | 0.413951 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 7876.92 | 7876.92 | 3966.99 | 3966.99 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7966.99 | 0.307085 | 25 | 254 | 3909.93 | ø25 | 33.7 | 27.2 | TR02.02.0464 | 0464 | yes
13077736 | 4.NP_SO-101 | 412.589 | 0.000568237 | 0.0348674 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-101 | -86.55 | -100 | -100 | -113.45 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 11889.2 | 0.0259237 | 20 | 263 | 412.589 | ø20 | 26.9 | 21.6 | TR02.02.0465 | 0465 | no | 0
13077811 | 2.NP_SO-101 | 3896.93 | 0.000891835 | 0.412575 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 7873.92 | 7873.92 | 3976.99 | 3976.99 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7976.99 | 0.306064 | 25 | 260 | 3896.93 | ø25 | 33.7 | 27.2 | TR02.02.0466 | 0466 | yes
13078212 | 4.NP_SO-101 | 707.013 | 0.000568237 | 0.0597488 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-101 | 628.506 | 628.506 | -78.5062 | -78.5063 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 11921.5 | 0.0444229 | 20 | 265 | 707.013 | ø20 | 26.9 | 21.6 | TR02.02.0469 | 0469 | no
13085796 | 4.NP_SO-101 | 697.012 | 0.000568237 | 0.0589037 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-101 | 618.506 | 618.506 | -78.5063 | -78.5062 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 11921.5 | 0.0437946 | 20 | 259 | 697.012 | ø20 | 26.9 | 21.6 | TR02.02.0616 | 0616 | no
13090200 | -1.PP_SO-101 | 4929.2 | 0.00183197 | 0.747952 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -820.9 | 0.619422 | 40 | 204 | 4929.2 | ø40 | 48.3 | 41.8 | TR02.02.0656 | 0656 | yes | 0
13090637 | -1.PP_SO-101 | 5129.2 | 0.00183197 | 0.778299 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -820.9 | 0.644554 | 40 | 279 | 5129.2 | ø40 | 48.3 | 41.8 | TR02.02.0657 | 0657 | yes | 0
13090646 | -1.PP_SO-101 | 5332.38 | 0.00141175 | 0.710291 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -817.95 | 0.536069 | 32 | 64 | 5332.38 | ø32 | 42.4 | 35.9 | TR02.02.0658 | 0658 | yes | 0
13090672 | -1.PP_SO-101 | 5532.38 | 0.00141175 | 0.736932 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -817.95 | 0.556175 | 32 | 194 | 5532.38 | ø32 | 42.4 | 35.9 | TR02.02.0659 | 0659 | yes | 0
13090681 | -1.PP_SO-101 | 5722.85 | 0.00285535 | 1.08413 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 0.898943 | 50 | 300 | 5722.85 | ø50 | 60.3 | 53 | TR02.02.0660 | 0660 | yes | 0
13090690 | -1.PP_SO-101 | 5922.85 | 0.00285535 | 1.12201 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 0.930359 | 50 | 293 | 5922.85 | ø50 | 60.3 | 53 | TR02.02.0661 | 0661 | yes | 0
13090871 | -1.PP_SO-101 | 3744.97 | 0.00285535 | 0.70944 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 0.588258 | 50 | 293 | 3744.97 | ø50 | 60.3 | 53 | TR02.02.0662 | 0662 | yes | 0
13091287 | -1.PP_SO-101 | 3744.97 | 0.00285535 | 0.70944 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 0.588258 | 50 | 300 | 3744.97 | ø50 | 60.3 | 53 | TR02.02.0663 | 0663 | yes | 0
13092903 | -1.PP_SO-101 | 7268.43 | 0.00285535 | 1.37692 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 1.14172 | 50 | 293 | 7268.43 | ø50 | 60.3 | 53 | TR02.02.0664 | 0664 | yes | 0
13092938 | -1.PP_SO-101 | 6868.43 | 0.00285535 | 1.30114 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 1.07889 | 50 | 300 | 6868.43 | ø50 | 60.3 | 53 | TR02.02.0665 | 0665 | yes | 0
13093146 | -1.PP_SO-101 | 6487.48 | 0.00141175 | 0.864156 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -817.95 | 0.652193 | 32 | 194 | 6487.48 | ø32 | 42.4 | 35.9 | TR02.02.0666 | 0666 | yes | 0
13093155 | -1.PP_SO-101 | 6087.48 | 0.00141175 | 0.810874 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -817.95 | 0.611981 | 32 | 64 | 6087.48 | ø32 | 42.4 | 35.9 | TR02.02.0667 | 0667 | yes | 0
13093164 | -1.PP_SO-101 | 5681.13 | 0.00183197 | 0.862049 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -820.9 | 0.713912 | 40 | 279 | 5681.13 | ø40 | 48.3 | 41.8 | TR02.02.0668 | 0668 | yes | 0
13093173 | -1.PP_SO-101 | 5281.13 | 0.00183197 | 0.801354 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -820.9 | 0.663647 | 40 | 204 | 5281.13 | ø40 | 48.3 | 41.8 | TR02.02.0669 | 0669 | yes | 0
13094085 | -1.PP_SO-101 | 3769.08 | 0.00141175 | 0.502055 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -817.95 | 0.378909 | 32 | 194 | 3769.08 | ø32 | 42.4 | 35.9 | TR02.02.0670 | 0670 | yes | 0
13094094 | -1.PP_SO-101 | 3769.08 | 0.00141175 | 0.502055 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -817.95 | 0.378909 | 32 | 64 | 3769.08 | ø32 | 42.4 | 35.9 | TR02.02.0671 | 0671 | yes | 0
13094103 | -1.PP_SO-101 | 3755.59 | 0.00183197 | 0.569869 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -820.9 | 0.471941 | 40 | 279 | 3755.59 | ø40 | 48.3 | 41.8 | TR02.02.0672 | 0672 | yes | 0
13094112 | -1.PP_SO-101 | 3755.59 | 0.00183197 | 0.569869 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -820.9 | 0.471941 | 40 | 204 | 3755.59 | ø40 | 48.3 | 41.8 | TR02.02.0673 | 0673 | yes | 0
13097367 | 1.NP_SO-101 | 159.363 | 0.000356274 | 0.0106639 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 2097 | 0.00750978 | 15 | 229 | 159.363 | ø15 | 21.3 | 16 | TR02.02.0674 | 0674 | no | 0
13097375 | 1.NP_SO-101 | 425.075 | 0.000356274 | 0.0284443 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 2097 | 0.0200312 | 15 | 225 | 425.075 | ø15 | 21.3 | 16 | TR02.02.0675 | 0675 | no | 0
13097392 | 1.NP_SO-101 | 149.363 | 0.000356274 | 0.00999473 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2097 | 0.00703854 | 15 | 196 | 149.363 | ø15 | 21.3 | 16 | TR02.02.0676 | 0676 | no | 0
13097398 | 1.NP_SO-101 | 425.075 | 0.000356274 | 0.0284443 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2097 | 0.0200312 | 15 | 181 | 425.075 | ø15 | 21.3 | 16 | TR02.02.0677 | 0677 | no | 0
13097480 | 1.NP_SO-101 | 201.65 | 0.000356274 | 0.0134936 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2097 | 0.00950253 | 15 | 230 | 201.65 | ø15 | 21.3 | 16 | TR02.02.0678 | 0678 | no | 0
13097486 | 1.NP_SO-101 | 425.075 | 0.000356274 | 0.0284443 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2097 | 0.0200312 | 15 | 226 | 425.075 | ø15 | 21.3 | 16 | TR02.02.0679 | 0679 | no | 0
13097505 | 1.NP_SO-101 | 201.65 | 0.000356274 | 0.0134936 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2097 | 0.00950253 | 15 | 243 | 201.65 | ø15 | 21.3 | 16 | TR02.02.0680 | 0680 | no | 0
13097511 | 1.NP_SO-101 | 425.075 | 0.000356274 | 0.0284443 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-101 | 2115.65 | 2105 | 2105 | 2094.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2097 | 0.0200312 | 15 | 235 | 425.075 | ø15 | 21.3 | 16 | TR02.02.0681 | 0681 | no | 0
13097563 | 3.NP_SO-101 | 325.715 | 0.000356274 | 0.0217956 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-101 | -2045.35 | -2056 | -2056 | -2066.65 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 5936 | 0.015349 | 15 | 230 | 325.715 | ø15 | 21.3 | 16 | TR02.02.0682 | 0682 | no | 0
13097570 | 2.NP_SO-101 | 143.817 | 0.000356274 | 0.00962367 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 5936 | 0.00677723 | 15 | 230 | 143.817 | ø15 | 21.3 | 16 | TR02.02.0683 | 0683 | no | 0
13097612 | 2.NP_SO-101 | 3804.08 | 0.000356274 | 0.254553 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1923.36 | -1880.71 | 1923.36 | -1880.71 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 2119.29 | 0.179263 | 15 | 225 | 3804.08 | ø15 | 21.3 | 16 | TR02.02.0684 | 0684 | no
13097640 | 2.NP_SO-101 | 1964.63 | 0.000356274 | 0.131465 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 3929.27 | 1964.64 | 3929.27 | 1964.64 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 5964.64 | 0.0925811 | 15 | 213 | 1964.63 | ø15 | 21.3 | 16 | TR02.02.0685 | 0685 | no
13098076 | 3.NP_SO-101 | 475.717 | 0.000356274 | 0.0318331 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-101 | -2045.35 | -2056 | -2056 | -2066.65 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5936 | 0.0224177 | 15 | 197 | 475.717 | ø15 | 21.3 | 16 | TR02.02.0686 | 0686 | no | 0
13098085 | 2.NP_SO-101 | 243.816 | 0.000356274 | 0.0163152 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5936 | 0.0114896 | 15 | 197 | 243.816 | ø15 | 21.3 | 16 | TR02.02.0687 | 0687 | no | 0
13098136 | 2.NP_SO-101 | 3804.08 | 0.000356274 | 0.254553 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1923.36 | -1880.71 | 1923.36 | -1880.71 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2119.29 | 0.179263 | 15 | 181 | 3804.08 | ø15 | 21.3 | 16 | TR02.02.0688 | 0688 | no
13098145 | 2.NP_SO-101 | 1954.63 | 0.000356274 | 0.130796 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 3919.27 | 1964.64 | 3919.27 | 1964.64 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5964.64 | 0.0921098 | 15 | 183 | 1954.63 | ø15 | 21.3 | 16 | TR02.02.0689 | 0689 | no
13098165 | 2.NP_SO-101 | 125.075 | 0.000356274 | 0.00836951 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5936 | 0.00589402 | 15 | 238 | 125.075 | ø15 | 21.3 | 16 | TR02.02.0690 | 0690 | no | 0
13098174 | 2.NP_SO-101 | 1964.63 | 0.000356274 | 0.131465 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 3929.27 | 1964.64 | 3929.27 | 1964.64 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5964.64 | 0.0925811 | 15 | 236 | 1964.63 | ø15 | 21.3 | 16 | TR02.02.0691 | 0691 | no
13098177 | 2.NP_SO-101 | 385.713 | 0.000356274 | 0.0258103 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5936 | 0.0181763 | 15 | 238 | 385.713 | ø15 | 21.3 | 16 | TR02.02.0692 | 0692 | no | 0
13098200 | 2.NP_SO-101 | 535.713 | 0.000356274 | 0.0358477 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5936 | 0.0252449 | 15 | 231 | 535.713 | ø15 | 21.3 | 16 | TR02.02.0693 | 0693 | no | 0
13098209 | 2.NP_SO-101 | 225.075 | 0.000356274 | 0.0150611 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1954.65 | 1944 | 1944 | 1933.35 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5936 | 0.0106064 | 15 | 231 | 225.075 | ø15 | 21.3 | 16 | TR02.02.0694 | 0694 | no | 0
13098287 | 2.NP_SO-101 | 3804.08 | 0.000356274 | 0.254553 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 1923.36 | -1880.71 | 1923.36 | -1880.71 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2119.29 | 0.179263 | 15 | 226 | 3804.08 | ø15 | 21.3 | 16 | TR02.02.0695 | 0695 | no
13098293 | 2.NP_SO-101 | 1954.63 | 0.000356274 | 0.130796 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-101 | 3919.27 | 1964.64 | 3919.27 | 1964.64 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5964.64 | 0.0921098 | 15 | 207 | 1954.63 | ø15 | 21.3 | 16 | TR02.02.0696 | 0696 | no
13101787 | -1.PP_SO-101 | 6129.2 | 0.00183197 | 0.930038 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 0.770218 | 40 | 39 | 6129.2 | ø40 | 48.3 | 41.8 | TR02.02.0704 | 0704 | yes | 0
13101814 | -1.PP_SO-101 | 7681.13 | 0.00183197 | 1.16553 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 0.96524 | 40 | 39 | 7681.13 | ø40 | 48.3 | 41.8 | TR02.02.0705 | 0705 | yes | 0
13101823 | -1.PP_SO-101 | 3757.67 | 0.00183197 | 0.570185 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 0.472203 | 40 | 39 | 3757.67 | ø40 | 48.3 | 41.8 | TR02.02.0706 | 0706 | yes | 0
13101832 | -1.PP_SO-101 | 3183.44 | 0.00183197 | 0.483051 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 0.400042 | 40 | 39 | 3183.44 | ø40 | 48.3 | 41.8 | TR02.02.0707 | 0707 | yes | 0
13102158 | -1.PP_SO-101 | 4493.4 | 0.000356274 | 0.30068 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1008 | 0.211746 | 15 | 27 | 4493.4 | ø15 | 21.3 | 16 | TR02.02.0708 | 0708 | yes | 0
13102166 | -1.PP_SO-101 | 1971.43 | 0.000356274 | 0.13192 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2110.65 | 2100 | 2100 | 2089.35 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1058 | 0.0929012 | 15 | 27 | 1971.43 | ø15 | 21.3 | 16 | TR02.02.0709 | 0709 | yes | 0
13102459 | -1.PP_SO-101 | 858.881 | 0.000568237 | 0.0725831 | 30 | ø80 mm | 0.00462963 | HC | -1.PP_SO-101 | 2263.45 | 2250 | 2250 | 2236.55 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -910.8 | 0.0539651 | 20 | 26 | 858.881 | ø20 | 26.9 | 21.6 | TR02.02.0710 | 0710 | yes | 0 | Izolace - Typ izolace: Tepelná
13102516 | -1.PP_SO-101 | 7958.72 | 0.000568237 | 0.672583 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 15032.5 | 15032.5 | 7073.81 | 7073.81 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 3923.81 | 0.500061 | 20 | 14 | 7958.72 | ø20 | 26.9 | 21.6 | TR02.02.0711 | 0711 | yes
13102856 | -1.PP_SO-101 | 6329.2 | 0.00183197 | 0.960386 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 0.795351 | 40 | 37 | 6329.2 | ø40 | 48.3 | 41.8 | TR02.02.0714 | 0714 | yes | 0
13102883 | -1.PP_SO-101 | 8081.13 | 0.00183197 | 1.22622 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 1.01551 | 40 | 37 | 8081.13 | ø40 | 48.3 | 41.8 | TR02.02.0715 | 0715 | yes | 0
13102892 | -1.PP_SO-101 | 3757.67 | 0.00183197 | 0.570185 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 0.472203 | 40 | 37 | 3757.67 | ø40 | 48.3 | 41.8 | TR02.02.0716 | 0716 | yes | 0
13102901 | -1.PP_SO-101 | 2783.44 | 0.00183197 | 0.422355 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 0.349777 | 40 | 37 | 2783.44 | ø40 | 48.3 | 41.8 | TR02.02.0717 | 0717 | yes | 0
13102919 | -1.PP_SO-101 | 4588.09 | 0.000356274 | 0.307016 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1008 | 0.216208 | 15 | 39 | 4588.09 | ø15 | 21.3 | 16 | TR02.02.0718 | 0718 | yes | 0
13102928 | -1.PP_SO-101 | 1193.88 | 0.000568237 | 0.100894 | 30 | ø80 mm | 0.00462963 | HC | -1.PP_SO-101 | 2263.45 | 2250 | 2250 | 2236.55 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -910.8 | 0.0750138 | 20 | 36 | 1193.88 | ø20 | 26.9 | 21.6 | TR02.02.0719 | 0719 | yes | 0 | Izolace - Typ izolace: Tepelná
13102946 | -1.PP_SO-101 | 2021.43 | 0.000356274 | 0.135266 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2110.65 | 2100 | 2100 | 2089.35 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1058 | 0.0952574 | 15 | 39 | 2021.43 | ø15 | 21.3 | 16 | TR02.02.0720 | 0720 | yes | 0
13103456 | -1.PP_SO-101 | 1721.83 | 0.00183197 | 0.261269 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 0.216372 | 40 | 37 | 1721.83 | ø40 | 48.3 | 41.8 | TR02.02.0721 | 0721 | yes | 0
13103919 | 2.NP_SO-101 | 811.725 | 0.000356274 | 0.0543173 | 0 | ø15 mm | 0.00625 | HC | 2.NP_SO-101 | -89.35 | -100 | -100 | -110.65 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 3892 | 0.0382516 | 15 | 16 | 811.725 | ø15 | 21.3 | 16 | TR02.02.0725 | 0725 | no | 0
13103926 | 2.NP_SO-101 | 5672.25 | 0.000356274 | 0.379564 | 0 | ø15 mm | 0.00625 | HC | 2.NP_SO-101 | -89.35 | -100 | -100 | -110.65 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 3892 | 0.267299 | 15 | 16 | 5672.25 | ø15 | 21.3 | 16 | TR02.02.0726 | 0726 | no | 0
13104083 | 2.NP_SO-101 | 5869.97 | 0.000356274 | 0.392794 | 0 | ø15 mm | 0.00625 | HC | 2.NP_SO-101 | -89.35 | -100 | -100 | -110.65 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3892 | 0.276616 | 15 | 27 | 5869.97 | ø15 | 21.3 | 16 | TR02.02.0727 | 0727 | no | 0
13104191 | -1.PP_SO-101 | 58.725 | 0.000568237 | 0.00496278 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 7026.19 | 7026.19 | 6967.46 | 6967.46 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 3817.46 | 0.0036898 | 20 | 26 | 58.725 | ø20 | 26.9 | 21.6 | TR02.02.0728 | 0728 | yes
13108939 | -1.PP_SO-101 | 46.025 | 0.00141175 | 0.00613069 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2219.84 | 2173.81 | 2219.84 | 2173.81 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -976.188 | 0.00462694 | 32 | 27 | 46.025 | ø32 | 42.4 | 35.9 | TR02.02.0732 | 0732 | yes
13108942 | -1.PP_SO-101 | 191.965 | 0.00141175 | 0.0255704 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2249.85 | 2250 | 2228.65 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -918.098 | 0.0192984 | 32 | 69 | 191.965 | ø32 | 42.4 | 35.9 | TR02.02.0733 | 0733 | yes | 0.076903
13109209 | -1.PP_SO-101 | 42.0563 | 0.000356274 | 0.00281423 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2206.34 | 2164.29 | 2206.34 | 2164.29 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -985.713 | 0.00198185 | 15 | 27 | 42.0563 | ø15 | 21.3 | 16 | TR02.02.0734 | 0734 | yes
13109212 | -1.PP_SO-101 | 924.653 | 0.00183197 | 0.140306 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2274.15 | 2250 | 2250 | 2225.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -920.9 | 0.116195 | 40 | 39 | 924.653 | ø40 | 48.3 | 41.8 | TR02.02.0735 | 0735 | yes | 0
13109255 | -1.PP_SO-101 | 42.0563 | 0.000356274 | 0.00281423 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2206.34 | 2164.29 | 2206.34 | 2164.29 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -985.713 | 0.00198185 | 15 | 39 | 42.0563 | ø15 | 21.3 | 16 | TR02.02.0736 | 0736 | yes
13109258 | -1.PP_SO-101 | 964.653 | 0.00183197 | 0.146375 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2274.15 | 2250 | 2250 | 2225.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -920.9 | 0.121222 | 40 | 37 | 964.653 | ø40 | 48.3 | 41.8 | TR02.02.0737 | 0737 | yes | 0
13109399 | -1.PP_SO-101 | 1816.06 | 0.000568237 | 0.153473 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -960.8 | 0.114107 | 20 | 30 | 1816.06 | ø20 | 26.9 | 21.6 | TR02.02.0738 | 0738 | yes | 0
13109409 | -1.PP_SO-101 | 1322.54 | 0.000568237 | 0.111766 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -960.8 | 0.0830975 | 20 | 30 | 1322.54 | ø20 | 26.9 | 21.6 | TR02.02.0739 | 0739 | yes | 0
13109435 | -1.PP_SO-101 | 1766.06 | 0.000568237 | 0.149248 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -960.8 | 0.110965 | 20 | 200 | 1766.06 | ø20 | 26.9 | 21.6 | TR02.02.0740 | 0740 | yes | 0
13109443 | -1.PP_SO-101 | 1472.54 | 0.000568237 | 0.124442 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2213.45 | 2200 | 2200 | 2186.55 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -960.8 | 0.0925223 | 20 | 200 | 1472.54 | ø20 | 26.9 | 21.6 | TR02.02.0741 | 0741 | yes | 0
