Properties of the parts of a building model (IFC4), part 16 of 23

# IfcPipeFitting: M_Koleno, obecné:Standardní (335)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12945595 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0018 | 0018 | no | 15.9375 | 9.5875
12945597 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0019 | 0019 | no | 15.9375 | 9.5875
12946454 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0026 | 0026 | no | 15.9375 | 9.5875
12946639 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0031 | 0031 | no | 15.9375 | 9.5875
12947079 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0032 | 0032 | no | 15.9375 | 9.5875
12947745 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0041 | 0041 | no | 15.9375 | 9.5875
12947781 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0044 | 0044 | no | 15.9375 | 9.5875
12947978 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0045 | 0045 | no | 15.9375 | 9.5875
12948284 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0052 | 0052 | no | 15.9375 | 9.5875
12948815 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0056 | 0056 | no | 15.9375 | 9.5875
12949477 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0060 | 0060 | no | 15.9375 | 9.5875
12949541 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0064 | 0064 | no | 15.9375 | 9.5875
12949581 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0067 | 0067 | no | 15.9375 | 9.5875
12949837 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0070 | 0070 | no | 15.9375 | 9.5875
12950540 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0075 | 0075 | no | 15.9375 | 9.5875
12951719 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0081 | 0081 | no | 15.9375 | 9.5875
12951879 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0084 | 0084 | no | 15.9375 | 9.5875
12951930 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0086 | 0086 | no | 15.9375 | 9.5875
12951977 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0089 | 0089 | no | 15.9375 | 9.5875
12952055 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0092 | 0092 | no | 15.9375 | 9.5875
12953544 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0093 | 0093 | no | 17.4625 | 11.1125
12953767 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0095 | 0095 | no | 15.9375 | 9.5875
12953780 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0096 | 0096 | no | 15.9375 | 9.5875
12953856 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0097 | 0097 | no | 15.9375 | 9.5875
12953860 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0098 | 0098 | no | 14.2875 | 7.9375
12955255 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0099 | 0099 | no | 15.9375 | 9.5875
12955372 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0100 | 0100 | no | 15.9375 | 9.5875
12955374 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0101 | 0101 | no | 15.9375 | 9.5875
12955491 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0103 | 0103 | no | 14.2875 | 7.9375
12956740 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0105 | 0105 | no | 15.9375 | 9.5875
12956903 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0108 | 0108 | no | 15.9375 | 9.5875
12956913 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0109 | 0109 | no | 15.9375 | 9.5875
12957038 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0110 | 0110 | no | 15.9375 | 9.5875
12957042 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 150 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0111 | 0111 | no | 15.9375 | 9.5875
12957052 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 150 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0112 | 0112 | no | 15.9375 | 9.5875
12957548 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0119 | 0119 | no | 15.9375 | 9.5875
12957638 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0120 | 0120 | no | 15.9375 | 9.5875
12958566 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0121 | 0121 | no | 15.9375 | 9.5875
12958662 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0123 | 0123 | no | 15.9375 | 9.5875
12958690 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0124 | 0124 | no | 15.9375 | 9.5875
12958741 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0126 | 0126 | no | 15.9375 | 9.5875
12958806 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0127 | 0127 | no | 15.9375 | 9.5875
12958957 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0131 | 0131 | no | 15.9375 | 9.5875
12959016 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0132 | 0132 | no | 15.9375 | 9.5875
12959129 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0135 | 0135 | no | 15.9375 | 9.5875
12959236 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0136 | 0136 | no | 15.9375 | 9.5875
12959404 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0138 | 0138 | no | 15.9375 | 9.5875
12959723 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 8.37581e-07 | 1.45431 | 10.4277 | ø16-ø16 | 0.699895 | 19.175 | TT01.01.0142 | 0142 | no | 15.9375 | 9.5875
12959727 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 8.37581e-07 | 1.45431 | 10.4277 | ø16-ø16 | 0.699895 | 19.175 | TT01.01.0143 | 0143 | no | 15.9375 | 9.5875
12960127 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0146 | 0146 | no | 15.9375 | 9.5875
12960171 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0148 | 0148 | no | 15.9375 | 9.5875
12960342 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0149 | 0149 | no | 15.9375 | 9.5875
12960358 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0151 | 0151 | no | 15.9375 | 9.5875
12960424 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0152 | 0152 | no | 15.9375 | 9.5875
12960428 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0153 | 0153 | no | 15.9375 | 9.5875
12960452 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0154 | 0154 | no | 15.9375 | 9.5875
12960460 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0155 | 0155 | no | 15.9375 | 9.5875
12960470 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0156 | 0156 | no | 15.9375 | 9.5875
12960544 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0158 | 0158 | no | 15.9375 | 9.5875
12964031 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0160 | 0160 | yes | 23.8125 | 17.4625
12964878 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -949.37 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0161 | 0161 | yes | 17.4625 | 11.1125
12964962 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -949.37 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0162 | 0162 | yes | 17.4625 | 11.1125
12965124 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -949.37 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0164 | 0164 | yes | 17.4625 | 11.1125
12966867 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0165 | 0165 | no | 15.9375 | 9.5875
12967907 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0167 | 0167 | no | 15.9375 | 9.5875
12969382 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0171 | 0171 | no | 15.9375 | 9.5875
12969511 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0173 | 0173 | no | 15.9375 | 9.5875
12969579 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0175 | 0175 | no | 15.9375 | 9.5875
12970079 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -100 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0176 | 0176 | no | 15.9375 | 9.5875
12970438 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0178 | 0178 | yes | 23.8125 | 17.4625
12972145 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0180 | 0180 | no | 15.9375 | 9.5875
13054700 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0183 | 0183 | no | 15.9375 | 9.5875
13055277 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0189 | 0189 | no | 15.9375 | 9.5875
13055388 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0190 | 0190 | no | 15.9375 | 9.5875
13055409 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0191 | 0191 | no | 15.9375 | 9.5875
13055411 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0192 | 0192 | no | 15.9375 | 9.5875
13056102 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0195 | 0195 | no | 15.9375 | 9.5875
13056138 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0196 | 0196 | no | 15.9375 | 9.5875
13056577 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0197 | 0197 | no | 15.9375 | 9.5875
13056600 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -360 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0199 | 0199 | no | 15.9375 | 9.5875
13057058 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0203 | 0203 | no | 15.9375 | 9.5875
13057079 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0204 | 0204 | no | 15.9375 | 9.5875
13057814 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 8.37581e-07 | 1.45431 | 10.4277 | ø16-ø16 | 0.699895 | 19.175 | TT01.01.0206 | 0206 | no | 15.9375 | 9.5875
13057845 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 8.37581e-07 | 1.45431 | 10.4277 | ø16-ø16 | 0.699895 | 19.175 | TT01.01.0207 | 0207 | no | 15.9375 | 9.5875
13058096 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0211 | 0211 | no | 15.9375 | 9.5875
13064763 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0212 | 0212 | no | 15.9375 | 9.5875
13065093 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0217 | 0217 | no | 15.9375 | 9.5875
13065843 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0226 | 0226 | no | 15.9375 | 9.5875
13065870 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0229 | 0229 | no | 15.9375 | 9.5875
13065988 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0230 | 0230 | no | 15.9375 | 9.5875
13066037 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0231 | 0231 | no | 15.9375 | 9.5875
13066231 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0234 | 0234 | no | 15.9375 | 9.5875
13066348 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0236 | 0236 | no | 15.9375 | 9.5875
13066515 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0238 | 0238 | no | 15.9375 | 9.5875
13066667 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0239 | 0239 | no | 15.9375 | 9.5875
13066812 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0242 | 0242 | no | 15.9375 | 9.5875
13069910 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -949.37 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0246 | 0246 | yes | 17.4625 | 11.1125
13070025 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -949.37 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0247 | 0247 | yes | 17.4625 | 11.1125
13070166 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -3210 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0249 | 0249 | no | 15.9375 | 9.5875
13070170 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 0.00000481939 | 9.20152 | 60 | ø16-ø16 | 4.42828 | 19.175 | TT01.01.0250 | 0250 | no | 15.9375 | 9.5875
13070259 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -3200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0251 | 0251 | no | 15.9375 | 9.5875
13070263 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000481939 | 9.20152 | 60 | ø16-ø16 | 4.42828 | 19.175 | TT01.01.0252 | 0252 | no | 15.9375 | 9.5875
13070658 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0253 | 0253 | yes | 23.8125 | 17.4625
13071509 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0254 | 0254 | no | 15.9375 | 9.5875
13072194 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | 3950 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0255 | 0255 | yes | 17.4625 | 11.1125
13072409 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | 3950 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0256 | 0256 | yes | 17.4625 | 11.1125
13076331 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0260 | 0260 | no | 17.4625 | 11.1125
13076358 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0261 | 0261 | no | 15.9375 | 9.5875
13077815 | 2.NP_SO-101 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-101 | 7900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0263 | 0263 | no | 18.9375 | 12.5875
13078214 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -100 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0264 | 0264 | no | 15.9375 | 9.5875
13078601 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0268 | 0268 | no | 15.9375 | 9.5875
13078641 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0270 | 0270 | no | 15.9375 | 9.5875
13078677 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0271 | 0271 | no | 15.9375 | 9.5875
13078930 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0274 | 0274 | no | 15.9375 | 9.5875
13078951 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0275 | 0275 | no | 15.9375 | 9.5875
13079874 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0281 | 0281 | no | 15.9375 | 9.5875
13079912 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0282 | 0282 | no | 15.9375 | 9.5875
13080298 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0286 | 0286 | no | 15.9375 | 9.5875
13080448 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0288 | 0288 | no | 15.9375 | 9.5875
13080544 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0289 | 0289 | no | 15.9375 | 9.5875
13080614 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0291 | 0291 | no | 15.9375 | 9.5875
13080855 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0294 | 0294 | no | 15.9375 | 9.5875
13080910 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0295 | 0295 | no | 15.9375 | 9.5875
13081215 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0298 | 0298 | no | 15.9375 | 9.5875
13081343 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0303 | 0303 | no | 15.9375 | 9.5875
13081830 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0305 | 0305 | no | 15.9375 | 9.5875
13082089 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0315 | 0315 | no | 15.9375 | 9.5875
13082291 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0316 | 0316 | no | 15.9375 | 9.5875
13082567 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0323 | 0323 | no | 15.9375 | 9.5875
13082817 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0324 | 0324 | no | 15.9375 | 9.5875
13082819 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0325 | 0325 | no | 15.9375 | 9.5875
13082899 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0330 | 0330 | no | 15.9375 | 9.5875
13083054 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0333 | 0333 | no | 15.9375 | 9.5875
13083273 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0338 | 0338 | no | 15.9375 | 9.5875
13083892 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0339 | 0339 | no | 15.9375 | 9.5875
13083928 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0340 | 0340 | no | 15.9375 | 9.5875
13084023 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0341 | 0341 | no | 15.9375 | 9.5875
13084114 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0342 | 0342 | no | 15.9375 | 9.5875
13084118 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0343 | 0343 | no | 14.2875 | 7.9375
13084242 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0344 | 0344 | no | 15.9375 | 9.5875
13084246 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0345 | 0345 | no | 14.2875 | 7.9375
13084552 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0348 | 0348 | no | 15.9375 | 9.5875
13085827 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | 7900 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0351 | 0351 | no | 15.9375 | 9.5875
13085831 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -100 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0352 | 0352 | no | 15.9375 | 9.5875
13085892 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 640 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0354 | 0354 | no | 15.9375 | 9.5875
13086443 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0357 | 0357 | no | 15.9375 | 9.5875
13086636 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0359 | 0359 | no | 15.9375 | 9.5875
13086638 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0360 | 0360 | no | 15.9375 | 9.5875
13087008 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0367 | 0367 | no | 15.9375 | 9.5875
13087012 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0368 | 0368 | no | 15.9375 | 9.5875
13087133 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0370 | 0370 | no | 15.9375 | 9.5875
13087171 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0371 | 0371 | no | 15.9375 | 9.5875
13087235 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 140 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0372 | 0372 | no | 15.9375 | 9.5875
13087239 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 140 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0373 | 0373 | no | 15.9375 | 9.5875
13087589 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0377 | 0377 | no | 15.9375 | 9.5875
13087636 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0378 | 0378 | no | 15.9375 | 9.5875
13087860 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0380 | 0380 | no | 15.9375 | 9.5875
13088318 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -110 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0381 | 0381 | no | 15.9375 | 9.5875
13092667 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0382 | 0382 | yes | 33.3375 | 26.9875
13092705 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0383 | 0383 | yes | 33.3375 | 26.9875
13094444 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0384 | 0384 | yes | 23.8125 | 17.4625
13094495 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0385 | 0385 | yes | 23.8125 | 17.4625
13094539 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0386 | 0386 | yes | 23.8125 | 17.4625
13094581 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0388 | 0388 | yes | 23.8125 | 17.4625
13097669 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7.5 | 15 | 0.00000444143 | 14.2845 | 89.9881 | ø15-ø15 | 6.34868 | 15.875 | TT01.01.0395 | 0395 | no | 14.2875 | 7.9375
13098142 | 3.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-101 | -2056 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.0000044417 | 14.2859 | 89.9935 | ø15-ø15 | 6.34928 | 15.875 | TT01.01.0396 | 0396 | no | 14.2875 | 7.9375
13098183 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0399 | 0399 | no | 14.2875 | 7.9375
13098290 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0400 | 0400 | no | 14.2875 | 7.9375
13100622 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0404 | 0404 | no | 15.9375 | 9.5875
13100655 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0405 | 0405 | no | 15.9375 | 9.5875
13101877 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0406 | 0406 | yes | 26.9875 | 20.6375
13102836 | 4.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 4.NP_SO-101 | -100 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0407 | 0407 | no | 17.4625 | 11.1125
13102992 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0408 | 0408 | yes | 26.9875 | 20.6375
13103737 | 4.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 4.NP_SO-101 | -100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0409 | 0409 | no | 17.4625 | 11.1125
13103768 | 4.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 4.NP_SO-101 | -100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0410 | 0410 | no | 17.4625 | 11.1125
13104188 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HC | 2.NP_SO-101 | -100 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0411 | 0411 | no | 14.2875 | 7.9375
13107313 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0431 | 0431 | no | 15.9375 | 9.5875
13107376 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0433 | 0433 | no | 15.9375 | 9.5875
13108668 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0436 | 0436 | yes | 26.9875 | 20.6375
13108951 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0438 | 0438 | yes | 23.8125 | 17.4625
13109155 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0439 | 0439 | yes | 26.9875 | 20.6375
13109415 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0444 | 0444 | yes | 17.4625 | 11.1125
13109449 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0445 | 0445 | yes | 17.4625 | 11.1125
13109490 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0446 | 0446 | yes | 14.2875 | 7.9375
13109922 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0447 | 0447 | yes | 26.9875 | 20.6375
13110965 | 1.NP_SO-101 | 0 | ø50 mm-ø50 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0448 | 0448 | yes | 33.3375 | 26.9875
13110969 | 1.NP_SO-101 | 0 | ø50 mm-ø50 mm | HD | 1.NP_SO-101 | -900 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0449 | 0449 | yes | 33.3375 | 26.9875
13111136 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0450 | 0450 | yes | 23.8125 | 17.4625
13111156 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2250 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0451 | 0451 | yes | 23.8125 | 17.4625
13111183 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0452 | 0452 | yes | 23.8125 | 17.4625
13111660 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -100 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0453 | 0453 | no | 15.9375 | 9.5875
13111662 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | 7900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0454 | 0454 | yes | 15.9375 | 9.5875
13114062 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0463 | 0463 | no | 15.9375 | 9.5875
13114072 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -360 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0464 | 0464 | no | 15.9375 | 9.5875
13114095 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0465 | 0465 | no | 15.9375 | 9.5875
13114105 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0466 | 0466 | no | 15.9375 | 9.5875
13114134 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -360 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0467 | 0467 | no | 15.9375 | 9.5875
13114144 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0468 | 0468 | no | 15.9375 | 9.5875
13114167 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0469 | 0469 | no | 15.9375 | 9.5875
13114177 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0470 | 0470 | no | 15.9375 | 9.5875
13114991 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0471 | 0471 | no | 15.9375 | 9.5875
13116859 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0472 | 0472 | yes | 23.8125 | 17.4625
13116861 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0473 | 0473 | yes | 23.8125 | 17.4625
13116967 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0474 | 0474 | yes | 23.8125 | 17.4625
13116969 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0475 | 0475 | yes | 23.8125 | 17.4625
13117010 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2250 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0476 | 0476 | yes | 23.8125 | 17.4625
13117024 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2250 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0477 | 0477 | yes | 23.8125 | 17.4625
13117028 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0478 | 0478 | yes | 23.8125 | 17.4625
13117032 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0479 | 0479 | yes | 23.8125 | 17.4625
13117038 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0480 | 0480 | yes | 23.8125 | 17.4625
13120538 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0481 | 0481 | yes | 26.9875 | 20.6375
13120551 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0482 | 0482 | yes | 26.9875 | 20.6375
13120553 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0483 | 0483 | yes | 26.9875 | 20.6375
13120572 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0484 | 0484 | yes | 23.8125 | 17.4625
13120574 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0485 | 0485 | yes | 23.8125 | 17.4625
13120591 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0486 | 0486 | yes | 23.8125 | 17.4625
13120593 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0487 | 0487 | yes | 23.8125 | 17.4625
13120612 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0488 | 0488 | yes | 33.3375 | 26.9875
13120614 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0489 | 0489 | yes | 33.3375 | 26.9875
13120631 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0490 | 0490 | yes | 33.3375 | 26.9875
13120633 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0491 | 0491 | yes | 33.3375 | 26.9875
13120650 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0492 | 0492 | yes | 26.9875 | 20.6375
13120652 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0493 | 0493 | yes | 26.9875 | 20.6375
13120669 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0494 | 0494 | yes | 26.9875 | 20.6375
13120671 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0495 | 0495 | yes | 26.9875 | 20.6375
13127720 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0498 | 0498 | yes | 23.8125 | 17.4625
