Properties of the parts of a building model (IFC4), part 18 of 23

# IfcPipeFitting: M_Spoj T, obecný:Standardní (265)
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
12944429 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0002 | 0002 | no | 9.5875
12944450 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0003 | 0003 | no | 9.5875
12944471 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0004 | 0004 | no | 9.5875
12944492 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0005 | 0005 | no | 9.5875
12944513 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0006 | 0006 | no | 9.5875
12944577 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0009 | 0009 | no | 9.5875
12944589 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0010 | 0010 | no | 9.5875
12944601 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0011 | 0011 | no | 9.5875
12944648 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0012 | 0012 | no | 9.5875
12945377 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0014 | 0014 | no | 9.5875
12945402 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0015 | 0015 | no | 9.5875
12945427 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0016 | 0016 | no | 9.5875
12945452 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0017 | 0017 | no | 9.5875
12945683 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0020 | 0020 | no | 9.5875
12945708 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0021 | 0021 | no | 9.5875
12945733 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0022 | 0022 | no | 9.5875
12946350 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0023 | 0023 | no | 9.5875
12946402 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0024 | 0024 | no | 9.5875
12946450 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0025 | 0025 | no | 9.5875
12946538 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0027 | 0027 | no | 9.5875
12946542 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0028 | 0028 | no | 9.5875
12946571 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0029 | 0029 | no | 9.5875
12946611 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0030 | 0030 | no | 9.5875
12947370 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0033 | 0033 | no | 9.5875
12947395 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0034 | 0034 | no | 9.5875
12947420 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0035 | 0035 | no | 9.5875
12947469 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0036 | 0036 | no | 9.5875
12947553 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0037 | 0037 | no | 9.5875
12947566 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0038 | 0038 | no | 9.5875
12947579 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0039 | 0039 | no | 9.5875
12947592 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0040 | 0040 | no | 9.5875
12947747 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0042 | 0042 | no | 9.5875
12947751 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0043 | 0043 | no | 9.5875
12947982 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0046 | 0046 | no | 9.5875
12947986 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0047 | 0047 | no | 9.5875
12948258 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0048 | 0048 | no | 9.5875
12948262 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0049 | 0049 | no | 9.5875
12948266 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0050 | 0050 | no | 9.5875
12948270 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0051 | 0051 | no | 9.5875
12948669 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0053 | 0053 | no | 9.5875
12948673 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0054 | 0054 | no | 9.5875
12948677 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0055 | 0055 | no | 9.5875
12948846 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0057 | 0057 | no | 9.5875
12949068 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0058 | 0058 | no | 9.5875
12949116 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0059 | 0059 | no | 9.5875
12949479 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0061 | 0061 | no | 9.5875
12949491 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0062 | 0062 | no | 9.5875
12949495 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0063 | 0063 | no | 9.5875
12949556 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0065 | 0065 | no | 9.5875
12949577 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0066 | 0066 | no | 9.5875
12949760 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0068 | 0068 | no | 9.5875
12949833 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0069 | 0069 | no | 9.5875
12950380 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0071 | 0071 | no | 9.5875
12950444 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0072 | 0072 | no | 9.5875
12950496 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0073 | 0073 | no | 9.5875
12950500 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0074 | 0074 | no | 9.5875
12950550 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0076 | 0076 | no | 9.5875
12950725 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0077 | 0077 | no | 9.5875
12950729 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0078 | 0078 | no | 9.5875
12951638 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0079 | 0079 | no | 9.5875
12951715 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0080 | 0080 | no | 9.5875
12951755 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0082 | 0082 | no | 9.5875
12951860 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0083 | 0083 | no | 9.5875
12951892 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0085 | 0085 | no | 9.5875
12951932 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0087 | 0087 | no | 9.5875
12951951 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0088 | 0088 | no | 9.5875
12952005 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0090 | 0090 | no | 9.5875
12952022 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0091 | 0091 | no | 9.5875
12953737 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0094 | 0094 | no | 9.5875
12955389 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0102 | 0102 | no | 9.5875
12956593 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0104 | 0104 | no | 9.5875
12956742 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0106 | 0106 | no | 9.5875
12956746 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0107 | 0107 | no | 9.5875
12957073 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 150 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0113 | 0113 | no | 9.5875
12957084 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 150 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0114 | 0114 | no | 9.5875
12957097 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0115 | 0115 | no | 9.5875
12957266 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0116 | 0116 | no | 9.5875
12957391 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0117 | 0117 | no | 9.5875
12957517 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0118 | 0118 | no | 9.5875
12958587 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0122 | 0122 | no | 9.5875
12958692 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0125 | 0125 | no | 9.5875
12958896 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0128 | 0128 | no | 9.5875
12958913 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0129 | 0129 | no | 9.5875
12958917 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0130 | 0130 | no | 9.5875
12959018 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0133 | 0133 | no | 9.5875
12959089 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0134 | 0134 | no | 9.5875
12959238 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0137 | 0137 | no | 9.5875
12959406 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0139 | 0139 | no | 9.5875
12959410 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0140 | 0140 | no | 9.5875
12959414 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0141 | 0141 | no | 9.5875
12960066 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0144 | 0144 | no | 9.5875
12960108 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0145 | 0145 | no | 9.5875
12960129 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0147 | 0147 | no | 9.5875
12960354 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0150 | 0150 | no | 9.5875
12960540 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0157 | 0157 | no | 9.5875
12961358 | 1.NP_SO-101 | 0 | ø50 mm-ø50 mm-ø50 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.02.0159 | 0159 | yes | 26.9875
12965075 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0163 | 0163 | no | 9.5875
12967903 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0166 | 0166 | no | 9.5875
12969252 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0168 | 0168 | no | 9.5875
12969355 | 1.NP_SO-101 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.02.0169 | 0169 | yes | 20.6375
12969378 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0170 | 0170 | no | 9.5875
12969507 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0172 | 0172 | no | 9.5875
12969575 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0174 | 0174 | no | 9.5875
12970419 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0177 | 0177 | yes | 17.4625
12970442 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0179 | 0179 | yes | 17.4625
13054669 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0181 | 0181 | no | 9.5875
13054696 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0182 | 0182 | no | 9.5875
13054829 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0184 | 0184 | no | 9.5875
13054919 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0185 | 0185 | no | 9.5875
13055185 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0186 | 0186 | no | 9.5875
13055204 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0187 | 0187 | no | 9.5875
13055256 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0188 | 0188 | no | 9.5875
13055644 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0193 | 0193 | no | 9.5875
13055805 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0194 | 0194 | no | 9.5875
13056596 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -360 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0198 | 0198 | no | 9.5875
13056838 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0200 | 0200 | no | 9.5875
13056897 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0201 | 0201 | no | 9.5875
13056958 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0202 | 0202 | no | 9.5875
13057081 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -910 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0205 | 0205 | no | 9.5875
13057978 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0208 | 0208 | no | 9.5875
13058051 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0209 | 0209 | no | 9.5875
13058085 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0210 | 0210 | no | 9.5875
13064829 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0213 | 0213 | no | 9.5875
13064850 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0214 | 0214 | no | 9.5875
13064886 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0215 | 0215 | no | 9.5875
13064949 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0216 | 0216 | no | 9.5875
13065162 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0218 | 0218 | no | 9.5875
13065266 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0219 | 0219 | no | 9.5875
13065356 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0220 | 0220 | no | 9.5875
13065423 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0221 | 0221 | no | 9.5875
13065549 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0222 | 0222 | no | 9.5875
13065628 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0223 | 0223 | no | 9.5875
13065685 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0224 | 0224 | no | 9.5875
13065712 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0225 | 0225 | no | 9.5875
13065845 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0227 | 0227 | no | 9.5875
13065866 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0228 | 0228 | no | 9.5875
13066070 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0232 | 0232 | no | 9.5875
13066170 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0233 | 0233 | no | 9.5875
13066288 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0235 | 0235 | no | 9.5875
13066350 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0237 | 0237 | no | 9.5875
13066698 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0240 | 0240 | no | 9.5875
13066723 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0241 | 0241 | no | 9.5875
13067620 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0243 | 0243 | no | 9.5875
13067693 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0244 | 0244 | no | 9.5875
13067697 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0245 | 0245 | no | 9.5875
13070123 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0248 | 0248 | no | 9.5875
13075686 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.02.0257 | 0257 | yes | 17.4625
13076101 | 1.NP_SO-101 | 0 | ø50 mm-ø50 mm-ø50 mm | HD | 1.NP_SO-101 | -900 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.02.0259 | 0259 | yes | 26.9875
13076362 | -1.PP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0262 | 0262 | no | 9.5875
13078409 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0265 | 0265 | no | 9.5875
13078424 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0266 | 0266 | no | 9.5875
13078479 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0267 | 0267 | no | 9.5875
13078603 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0269 | 0269 | no | 9.5875
13078852 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0272 | 0272 | no | 9.5875
13078917 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0273 | 0273 | no | 9.5875
13078993 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0276 | 0276 | no | 9.5875
13079102 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0277 | 0277 | no | 9.5875
13079163 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0278 | 0278 | no | 9.5875
13079787 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0279 | 0279 | no | 9.5875
13079810 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0280 | 0280 | no | 9.5875
13079955 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0283 | 0283 | no | 9.5875
13079976 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0284 | 0284 | no | 9.5875
13080259 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0285 | 0285 | no | 9.5875
13080444 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0287 | 0287 | no | 9.5875
13080595 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0290 | 0290 | no | 9.5875
13080758 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0292 | 0292 | no | 9.5875
13080815 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0293 | 0293 | no | 9.5875
13080916 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0296 | 0296 | no | 9.5875
13080961 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0297 | 0297 | no | 9.5875
13081259 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0299 | 0299 | no | 9.5875
13081263 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0300 | 0300 | no | 9.5875
13081267 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0301 | 0301 | no | 9.5875
13081305 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0302 | 0302 | no | 9.5875
13081793 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0304 | 0304 | no | 9.5875
13081938 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0306 | 0306 | no | 9.5875
13081942 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0307 | 0307 | no | 9.5875
13081946 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0308 | 0308 | no | 9.5875
13081950 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0309 | 0309 | no | 9.5875
13081954 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0310 | 0310 | no | 9.5875
13081986 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0311 | 0311 | no | 9.5875
13082064 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0312 | 0312 | no | 9.5875
13082068 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0313 | 0313 | no | 9.5875
13082072 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0314 | 0314 | no | 9.5875
13082405 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0317 | 0317 | no | 9.5875
13082409 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0318 | 0318 | no | 9.5875
13082413 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0319 | 0319 | no | 9.5875
13082464 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0320 | 0320 | no | 9.5875
13082525 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0321 | 0321 | no | 9.5875
13082542 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0322 | 0322 | no | 9.5875
13082825 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0326 | 0326 | no | 9.5875
13082829 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0327 | 0327 | no | 9.5875
13082844 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0328 | 0328 | no | 9.5875
13082863 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0329 | 0329 | no | 9.5875
13082901 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0331 | 0331 | no | 9.5875
13083020 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0332 | 0332 | no | 9.5875
13083094 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0334 | 0334 | no | 9.5875
13083117 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0335 | 0335 | no | 9.5875
13083160 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0336 | 0336 | no | 9.5875
13083204 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0337 | 0337 | no | 9.5875
13084482 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0346 | 0346 | no | 9.5875
13084548 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0347 | 0347 | no | 9.5875
13084810 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0349 | 0349 | no | 9.5875
13085522 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0350 | 0350 | no | 9.5875
13085873 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 640 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0353 | 0353 | no | 9.5875
13085923 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 640 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0355 | 0355 | no | 9.5875
13085982 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 640 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0356 | 0356 | no | 9.5875
13086451 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0358 | 0358 | no | 9.5875
13086644 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0361 | 0361 | no | 9.5875
13086697 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0362 | 0362 | no | 9.5875
13086701 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0363 | 0363 | no | 9.5875
13086716 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0364 | 0364 | no | 9.5875
13086741 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0365 | 0365 | no | 9.5875
13086745 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0366 | 0366 | no | 9.5875
13087091 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0369 | 0369 | no | 9.5875
13087245 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 140 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0374 | 0374 | no | 9.5875
13087249 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 140 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0375 | 0375 | no | 9.5875
13087806 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0379 | 0379 | no | 9.5875
13097374 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0390 | 0390 | no | 7.9375
13097397 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0391 | 0391 | no | 7.9375
13097485 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0392 | 0392 | no | 7.9375
13097510 | 1.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 1.NP_SO-101 | 2105 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0393 | 0393 | no | 7.9375
13097639 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0394 | 0394 | no | 7.9375
13098144 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0397 | 0397 | no | 7.9375
13098173 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0398 | 0398 | no | 7.9375
13098292 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-101 | 1944 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.02.0401 | 0401 | no | 7.9375
13100577 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0402 | 0402 | no | 9.5875
13100598 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0403 | 0403 | no | 9.5875
13107378 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT00.02.0434 | 0434 | no | 9.5875
