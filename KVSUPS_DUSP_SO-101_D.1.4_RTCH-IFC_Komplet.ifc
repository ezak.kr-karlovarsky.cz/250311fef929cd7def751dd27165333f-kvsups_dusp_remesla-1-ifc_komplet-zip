Properties of the parts of a building model (IFC4), part 12 of 23

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C3 600/107 (103)
Name (Článkové otopné těleso - boční připojení:ATOL C3 600/107:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Odsazení od podlahy (mm) | Odsazení od stěny (mm) | Délka (mm) | Kód prvku | Označení | Počet článků
12789082 | 1.NP_SO-101 | 2.84281 | 0.032906 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 900 | OT03.03.0021 | 0021 | 15
12789090 | 1.NP_SO-101 | 2.84281 | 0.032906 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 900 | OT03.03.0022 | 0022 | 15
12789196 | 2.NP_SO-101 | 5.4479 | 0.0633789 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1740 | OT03.03.0024 | 0024 | 29
12789205 | 2.NP_SO-101 | 5.4479 | 0.0633789 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1740 | OT03.03.0025 | 0025 | 29
12789214 | 2.NP_SO-101 | 5.4479 | 0.0633789 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1740 | OT03.03.0026 | 0026 | 29
12789223 | 2.NP_SO-101 | 3.7732 | 0.0437892 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1200 | OT03.03.0027 | 0027 | 20
12789241 | 2.NP_SO-101 | 3.7732 | 0.0437892 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1200 | OT03.03.0028 | 0028 | 20
12789254 | 2.NP_SO-101 | 3.7732 | 0.0437892 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1200 | OT03.03.0029 | 0029 | 20
12789281 | 2.NP_SO-101 | 4.33143 | 0.0503191 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1380 | OT03.03.0032 | 0032 | 23
12789343 | 2.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 720 | OT03.03.0033 | 0033 | 12
12789405 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0034 | 0034 | 13
12789494 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0035 | 0035 | 13
12789502 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0036 | 0036 | 13
12789510 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0037 | 0037 | 13
12789520 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0038 | 0038 | 13
12789530 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0039 | 0039 | 13
12789542 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0040 | 0040 | 13
12789552 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0041 | 0041 | 13
12789560 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0042 | 0042 | 13
12789572 | 2.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 780 | OT03.03.0043 | 0043 | 13
12789861 | 2.NP_SO-101 | 3.58712 | 0.0416126 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1140 | OT03.03.0045 | 0045 | 19
12792079 | 2.NP_SO-101 | 1.91242 | 0.0220228 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 600 | OT03.03.0047 | 0047 | 10
12792138 | 1.NP_SO-101 | 1.35419 | 0.0154929 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 420 | OT03.03.0048 | 0048 | 7
12792313 | 3.NP_SO-101 | 4.14535 | 0.0481425 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1320 | OT03.03.0049 | 0049 | 22
12792326 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0050 | 0050 | 11
12792335 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0051 | 0051 | 11
12792344 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0052 | 0052 | 11
12792357 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0053 | 0053 | 11
12792366 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0054 | 0054 | 11
12792384 | 3.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0056 | 0056 | 24
12792393 | 3.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0057 | 0057 | 24
12792406 | 3.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0058 | 0058 | 24
12792415 | 3.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 720 | OT03.03.0059 | 0059 | 12
12792433 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0061 | 0061 | 11
12793228 | 3.NP_SO-101 | 4.70359 | 0.0546724 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1500 | OT03.03.0062 | 0062 | 25
12793242 | 3.NP_SO-101 | 3.21497 | 0.0372593 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1020 | OT03.03.0063 | 0063 | 17
12793256 | 3.NP_SO-101 | 3.58712 | 0.0416126 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1140 | OT03.03.0064 | 0064 | 19
12794056 | 2.NP_SO-101 | 3.7732 | 0.0437892 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 1200 | OT03.03.0065 | 0065 | 20
12794219 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0066 | 0066 | 24
12794232 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0067 | 0067 | 24
12794241 | 4.NP_SO-101 | 3.02889 | 0.0350827 | 48.5 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 960 | OT03.03.0068 | 0068 | 16
12794324 | 4.NP_SO-101 | 4.33143 | 0.0503191 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1380 | OT03.03.0069 | 0069 | 23
12794368 | 4.NP_SO-101 | 3.40104 | 0.0394359 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1080 | OT03.03.0070 | 0070 | 18
12794439 | 4.NP_SO-101 | 3.40104 | 0.0394359 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1080 | OT03.03.0071 | 0071 | 18
12794449 | 4.NP_SO-101 | 2.28458 | 0.0263761 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 720 | OT03.03.0072 | 0072 | 12
12794493 | 4.NP_SO-101 | 3.02889 | 0.0350827 | 700 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 960 | OT03.03.0073 | 0073 | 16
12794553 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0074 | 0074 | 24
12795423 | 4.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 750 | 50 | 720 | OT03.03.0075 | 0075 | 12
12795431 | 4.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 750 | 50 | 720 | OT03.03.0076 | 0076 | 12
12795439 | 4.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 750 | 50 | 720 | OT03.03.0077 | 0077 | 12
12795673 | 4.NP_SO-101 | 1.16811 | 0.0133163 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 360 | OT03.03.0078 | 0078 | 6
12796121 | 4.NP_SO-101 | 2.65673 | 0.0307294 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 840 | OT03.03.0079 | 0079 | 14
12797080 | 3.NP_SO-101 | 2.28458 | 0.0263761 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 720 | OT03.03.0083 | 0083 | 12
12797518 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 750 | 66.1685 | 1440 | OT03.03.0084 | 0084 | 24
12915511 | -1.PP_SO-101 | 3.02889 | 0.0350827 | -850 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 960 | OT03.03.0085 | 0085 | 16 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12915737 | -1.PP_SO-101 | 3.02889 | 0.0350827 | -850 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 960 | OT03.03.0086 | 0086 | 16 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12915745 | -1.PP_SO-101 | 3.02889 | 0.0350827 | -850 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 960 | OT03.03.0087 | 0087 | 16 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12915755 | -1.PP_SO-101 | 3.02889 | 0.0350827 | -850 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 960 | OT03.03.0088 | 0088 | 16 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12915953 | -1.PP_SO-101 | 4.88966 | 0.056849 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 1560 | OT03.03.0089 | 0089 | 26 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12916093 | -1.PP_SO-101 | 1.91242 | 0.0220228 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 600 | OT03.03.0090 | 0090 | 10 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12916105 | -1.PP_SO-101 | 1.91242 | 0.0220228 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 600 | OT03.03.0091 | 0091 | 10 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12916113 | -1.PP_SO-101 | 0.982034 | 0.0111397 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 300 | OT03.03.0092 | 0092 | 5 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12919553 | -1.PP_SO-101 | 2.0985 | 0.0241995 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 660 | OT03.03.0099 | 0099 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12919866 | -1.PP_SO-101 | 5.26182 | 0.0612023 | -850 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 1680 | OT03.03.0102 | 0102 | 28
12919876 | -1.PP_SO-101 | 2.0985 | 0.0241995 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 660 | OT03.03.0103 | 0103 | 11
12919884 | -1.PP_SO-101 | 2.0985 | 0.0241995 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 660 | OT03.03.0104 | 0104 | 11
12919892 | -1.PP_SO-101 | 2.0985 | 0.0241995 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 660 | OT03.03.0105 | 0105 | 11
12920018 | -1.PP_SO-101 | 3.02889 | 0.0350827 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 960 | OT03.03.0106 | 0106 | 16 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12920060 | -1.PP_SO-101 | 2.47066 | 0.0285528 | 0 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 50 | 50 | 780 | OT03.03.0107 | 0107 | 13
12920493 | 1.NP_SO-101 | 1.35419 | 0.0154929 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 420 | OT03.03.0108 | 0108 | 7
12921154 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0109 | 0109 | 13
12921162 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0110 | 0110 | 13
12921681 | 2.NP_SO-101 | 1.91242 | 0.0220228 | 0 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 50 | 50 | 600 | OT03.03.0112 | 0112 | 10
12922862 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0114 | 0114 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12922953 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0115 | 0115 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12922965 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0116 | 0116 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12922973 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0117 | 0117 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12922983 | 3.NP_SO-101 | 2.0985 | 0.0241995 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 660 | OT03.03.0118 | 0118 | 11 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923076 | 3.NP_SO-101 | 5.07574 | 0.0590256 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1620 | OT03.03.0119 | 0119 | 27 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923152 | 3.NP_SO-101 | 3.95928 | 0.0459658 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1260 | OT03.03.0120 | 0120 | 21 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923160 | 3.NP_SO-101 | 1.35419 | 0.0154929 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 420 | OT03.03.0121 | 0121 | 7 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923166 | 3.NP_SO-101 | 1.35419 | 0.0154929 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 420 | OT03.03.0122 | 0122 | 7 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923174 | 3.NP_SO-101 | 2.65673 | 0.0307294 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 840 | OT03.03.0123 | 0123 | 14 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923182 | 3.NP_SO-101 | 2.65673 | 0.0307294 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 840 | OT03.03.0124 | 0124 | 14 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923383 | 3.NP_SO-101 | 5.07574 | 0.0590256 | 0 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 50 | 50 | 1620 | OT03.03.0125 | 0125 | 27 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
12923478 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0126 | 0126 | 24
12923513 | 4.NP_SO-101 | 4.51751 | 0.0524957 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1440 | OT03.03.0127 | 0127 | 24
12943624 | 4.NP_SO-101 | 4.33143 | 0.0503191 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1380 | OT03.03.0128 | 0128 | 23
12943632 | 4.NP_SO-101 | 4.33143 | 0.0503191 | 0 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 50 | 50 | 1380 | OT03.03.0129 | 0129 | 23
12947445 | 1.NP_SO-101 | 2.47066 | 0.0285528 | 0 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 50 | 50 | 780 | OT03.03.0130 | 0130 | 13

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C3 900/107 (3)
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Energetická analýza - Teplotní spád_Topení: 15
Type - Text - Typ tělesa: ATOL C3
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; SPÁD TLAKU: 0 Pa
Type - Kóty - Celková výška: 980 mm; Šířka: 107 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.17.11; Kód sestavy: OT03; Komentáře k typům: článkové; Model: Model; Nadpis OmniClass: Radiators; Název typu: ATOL C3 900/107; Označení typu: 01; Popis: Otopné těleso; Popis sestavy: Článkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; C: 30 mm; Článek_Šířka: 60 mm; Název rodiny: Článkové otopné těleso - boční připojení; RV: 40 mm
Classification: OT03 Uniformat (Uniformat)
Energetická analýza - TEPLOTNÍ SPÁD_VYTÁPĚNÍ: 20; VÝKON TOPENÍ: 800 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Hostitel: Podlaží : -1.PP_SO-101; Odsazení od podlahy: 50 mm; Odsazení od stěny: 50 mm; Podlaží: -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000955338 m3/s
Kóty - Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 10 mm
Jiné - Id typu: 12926146; PA: 0 deg; PH: 0 mm; PV: 540 mm; Rodina: Článkové otopné těleso - boční připojení; Rodina a typ: Článkové otopné těleso - boční připojení: ATOL C3 900/107; Typ: ATOL C3 900/107; Výběr hlavice: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; Výběr šroubení: Šroubení pro otopná tělesa rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; ZA: 0 deg; ZH: 0 mm; ZV: 40 mm
Name (Článkové otopné těleso - boční připojení:ATOL C3 900/107:...) | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Délka (mm) | Kód prvku | Označení | Počet článků
12781478 | 5.78379 | 0.0680537 | -750 | 1320 | OT03.01.0001 | 0001 | 22
12781487 | 2.65716 | 0.0310734 | -850 | 600 | OT03.01.0002 | 0002 | 10
12919649 | 3.95992 | 0.0464819 | 0 | 900 | OT03.01.0100 | 0100 | 15 | Text - Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV

# IfcBuildingElementProxy: Článkové otopné těleso - boční připojení:ATOL C4 900/148, Článkové otopné těleso - boční připojení:ATOL C4 900/148:12919728
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Energetická analýza - Teplotní spád_Topení: 15
Type - Text - Typ tělesa: ATOL C4
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; SPÁD TLAKU: 0 Pa
Type - Kóty - Celková výška: 980 mm; Šířka: 148 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.17.11; Kód sestavy: OT03; Komentáře k typům: článkové; Model: Model; Nadpis OmniClass: Radiators; Název typu: ATOL C4 900/148; Označení typu: 06; Popis: Otopné těleso; Popis sestavy: Článkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; C: 30 mm; Článek_Šířka: 60 mm; Název rodiny: Článkové otopné těleso - boční připojení; RV: 40 mm
Classification: OT03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.18639 m2; NetVolume: 0.0644441 m3
Energetická analýza - TEPLOTNÍ SPÁD_VYTÁPĚNÍ: 20; VÝKON TOPENÍ: 800 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD; Typ hlavice: TRV; Typ šroubení: RŠ; Typ ventilu: RV
Vazby - Podlaží: -1.PP_SO-101; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-101; Odsazení od podlahy: 50 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000955338 m3/s
Kóty - Délka: 900 mm; Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; JMENOVITÝ PRŮMĚR: 10 mm; Objem: 0.0644441 m3
Identifikační data - Kód prvku: OT03.06.0101; Označení: 0101
Jiné - PA: 0 deg; PH: 0 mm; Rodina: Článkové otopné těleso - boční připojení; Výběr hlavice: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; Výběr šroubení: Šroubení pro otopná tělesa rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil přímý.LH : Připojení tělesa G 3/4; ZA: 0 deg; ZH: 0 mm; Id typu: 13096143; Počet článků: 15; PV: 540 mm; Rodina a typ: Článkové otopné těleso - boční připojení: ATOL C4 900/148; Typ: ATOL C4 900/148; ZV: 40 mm

# IfcCovering: Izolace trubky:Tepelná (27)
In: -1.PP_SO-101
PredefinedType: INSULATION; Classification: IZ01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: RQA
Fázování - Fáze vytvoření: Fáze 1
Jiné - Id typu: 9105621; Kategorie: Izolace trubky; Rodina: Izolace trubky; Rodina a typ: Izolace trubky: Tepelná; Typ: Tepelná
Požární ochrana(Type) - Požární odolnost: A1
Identifikační data(Type) - ID kategorie: IZT; Kód sestavy: IZ01; Název typu: Tepelná; Označení typu: 01; Popis: TEPELNÁ IZOLACE; Popis sestavy: Tepelná
Jiné(Type) - Kategorie: Izolace trubky; MJ: m; Název rodiny: Izolace trubky
Name (Izolace trubky:Tepelná:...) | Material | CCI Technický systém | Typ systému | Klasifikace systému | Název systému | Objem (m3) | Plocha (m2) | Tloušťka izolace (mm) | Délka (mm) | Velikost potrubí | Kód prvku | Označení
13069871 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 0.0538709 | 1.34677 | 40 | 3502.38 | ø32 | IZ01.01.0001 | 0001 | Qto_CoveringBaseQuantities - GrossArea: 0.0117649 m2
13073394 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 0.0373516 | 0.933791 | 40 | 2428.39 | ø32 | IZ01.01.0002 | 0002
13074891 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 0.0312053 | 0.780132 | 40 | 2028.79 | ø32 | IZ01.01.0003 | 0003
13074922 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 0.0311579 | 0.778947 | 40 | 2025.71 | ø32 | IZ01.01.0004 | 0004
13138870 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 0.030427 | 1.01423 | 30 | 3715.08 | ø20 | IZ01.01.0005 | 0005 | Qto_CoveringBaseQuantities - GrossArea: 0.00593013 m2
13138875 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 0.0568397 | 1.42099 | 40 | 3695.39 | ø32 | IZ01.01.0006 | 0006
13139145 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 |  |  | 30 |  | ø32-ø32 | IZ01.01.0007 | 0007
13139146 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 0.000639321 | 0.0213107 | 30 | 66.2443 | ø32 | IZ01.01.0008 | 0008
13139151 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 |  |  | 40 |  | ø32-ø20 | IZ01.01.0009 | 0009
13139152 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 |  |  | 40 |  | ø20-ø20 | IZ01.01.0010 | 0010
13139538 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 0.0366491 | 0.916227 | 40 | 2382.71 | ø32 | IZ01.01.0011 | 0011
13139549 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 0.0304219 | 1.01406 | 30 | 3714.46 | ø20 | IZ01.01.0012 | 0012 | Qto_CoveringBaseQuantities - GrossArea: 0.00593013 m2
13139550 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 0.00160442 | 0.0534806 | 30 | 166.244 | ø32 | IZ01.01.0013 | 0013
13139551 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 |  |  | 30 |  | ø20-ø20 | IZ01.01.0014 | 0014
13139552 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 |  |  | 30 |  | ø32-ø20 | IZ01.01.0015 | 0015
13139553 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 |  |  | 30 |  | ø32-ø32 | IZ01.01.0016 | 0016
13140003 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 |  |  | 40 |  | ø32-ø32 | IZ01.01.0017 | 0017
13140543 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 0.00115599 | 0.0288996 | 40 | 75.1556 | ø32 | IZ01.01.0018 | 0018 | Qto_CoveringBaseQuantities - GrossArea: 0.0117649 m2
13140545 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 |  |  | 40 |  | ø32-ø32-ø32 | IZ01.01.0019 | 0019 | Qto_CoveringBaseQuantities - GrossArea: 0.00693285 m2; Width: 114.925 mm
13140623 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 0.0033356 | 0.0833901 | 40 | 216.862 | ø32 | IZ01.01.0020 | 0020
13140625 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 |  |  | 40 |  | ø32-ø32-ø32 | IZ01.01.0021 | 0021 | Qto_CoveringBaseQuantities - GrossArea: 0.00693285 m2; Width: 114.925 mm
13145679 | 255-128-128 | HD | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 0.0301691 | 0.754228 | 40 | 1711.18 | ø50 | IZ01.01.0022 | 0022 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13145680 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0245273 | 0.613183 | 40 | 1391.18 | ø50 | IZ01.01.0023 | 0023 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13145685 | 0-255-128 | HC | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 0.00703435 | 0.234478 | 30 | 858.881 | ø20 | IZ01.01.0024 | 0024 | Qto_CoveringBaseQuantities - GrossArea: 0.00593013 m2
13145686 | 128-255-255 | HC | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 0.00977805 | 0.325935 | 30 | 1193.88 | ø20 | IZ01.01.0025 | 0025 | Qto_CoveringBaseQuantities - GrossArea: 0.00593013 m2
13158116 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 |  |  | 40 |  | ø32-ø32 | IZ01.01.0026 | 0026
13158117 | 0-128-255 | HD | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 0.0438519 | 1.0963 | 40 | 2851 | ø32 | IZ01.01.0027 | 0027

# IfcDistributionPort (3628)
Description: Flow; PredefinedType: PIPE; SystemType: HEATING
Name | FlowDirection | Group
OutPort_12781478_3 | SOURCE
InPort_12781478_4 | SINK
OutPort_12781487_3 | SOURCE
InPort_12781487_4 | SINK
OutPort_12782375_3 | SOURCE
InPort_12782375_4 | SINK
OutPort_12782384_3 | SOURCE
InPort_12782384_4 | SINK
OutPort_12782393_3 | SOURCE
InPort_12782393_4 | SINK
OutPort_12782402_3 | SOURCE
InPort_12782402_4 | SINK
OutPort_12782420_3 | SOURCE
InPort_12782420_4 | SINK
OutPort_12782429_3 | SOURCE
InPort_12782429_4 | SINK
OutPort_12782438_3 | SOURCE
InPort_12782438_4 | SINK
OutPort_12782451_3 | SOURCE
InPort_12782451_4 | SINK
OutPort_12782717_3 | SOURCE
InPort_12782717_4 | SINK
OutPort_12782838_3 | SOURCE
InPort_12782838_4 | SINK
OutPort_12782846_3 | SOURCE
InPort_12782846_4 | SINK
OutPort_12782858_3 | SOURCE
InPort_12782858_4 | SINK
OutPort_12783004_3 | SOURCE
InPort_12783004_4 | SINK
OutPort_12783068_3 | SOURCE
InPort_12783068_4 | SINK
OutPort_12783084_3 | SOURCE
InPort_12783084_4 | SINK
OutPort_12783092_3 | SOURCE
InPort_12783092_4 | SINK
OutPort_12783102_3 | SOURCE
InPort_12783102_4 | SINK
OutPort_12788972_3 | SOURCE
InPort_12788972_4 | SINK
OutPort_12789082_3 | SOURCE
InPort_12789082_4 | SINK
OutPort_12789090_3 | SOURCE
InPort_12789090_4 | SINK
OutPort_12789165_3 | SOURCE
InPort_12789165_4 | SINK
OutPort_12789196_3 | SOURCE
InPort_12789196_4 | SINK
OutPort_12789205_3 | SOURCE
InPort_12789205_4 | SINK
OutPort_12789214_3 | SOURCE
InPort_12789214_4 | SINK
OutPort_12789223_3 | SOURCE
InPort_12789223_4 | SINK
OutPort_12789241_3 | SOURCE
InPort_12789241_4 | SINK
OutPort_12789254_3 | SOURCE
InPort_12789254_4 | SINK
OutPort_12789263_3 | SOURCE
InPort_12789263_4 | SINK
OutPort_12789272_3 | SOURCE
InPort_12789272_4 | SINK
OutPort_12789281_3 | SOURCE
InPort_12789281_4 | SINK
OutPort_12789343_3 | SOURCE
InPort_12789343_4 | SINK
OutPort_12789405_3 | SOURCE
InPort_12789405_4 | SINK
OutPort_12789494_3 | SOURCE
InPort_12789494_4 | SINK
OutPort_12789502_3 | SOURCE
InPort_12789502_4 | SINK
OutPort_12789510_3 | SOURCE
InPort_12789510_4 | SINK
OutPort_12789520_3 | SOURCE
InPort_12789520_4 | SINK
OutPort_12789530_3 | SOURCE
InPort_12789530_4 | SINK
OutPort_12789542_3 | SOURCE
InPort_12789542_4 | SINK
OutPort_12789552_3 | SOURCE
InPort_12789552_4 | SINK
OutPort_12789560_3 | SOURCE
InPort_12789560_4 | SINK
OutPort_12789572_3 | SOURCE
InPort_12789572_4 | SINK
OutPort_12789765_3 | SOURCE
InPort_12789765_4 | SINK
OutPort_12789861_3 | SOURCE
InPort_12789861_4 | SINK
OutPort_12790060_3 | SOURCE
InPort_12790060_4 | SINK
OutPort_12792079_3 | SOURCE
InPort_12792079_4 | SINK
OutPort_12792138_3 | SOURCE
InPort_12792138_4 | SINK
OutPort_12792313_3 | SOURCE
InPort_12792313_4 | SINK
OutPort_12792326_3 | SOURCE
InPort_12792326_4 | SINK
OutPort_12792335_3 | SOURCE
InPort_12792335_4 | SINK
OutPort_12792344_3 | SOURCE
InPort_12792344_4 | SINK
OutPort_12792357_3 | SOURCE
InPort_12792357_4 | SINK
OutPort_12792366_3 | SOURCE
InPort_12792366_4 | SINK
OutPort_12792375_3 | SOURCE
InPort_12792375_4 | SINK
OutPort_12792384_3 | SOURCE
InPort_12792384_4 | SINK
OutPort_12792393_3 | SOURCE
InPort_12792393_4 | SINK
OutPort_12792406_3 | SOURCE
InPort_12792406_4 | SINK
OutPort_12792415_3 | SOURCE
InPort_12792415_4 | SINK
OutPort_12792424_3 | SOURCE
InPort_12792424_4 | SINK
OutPort_12792433_3 | SOURCE
InPort_12792433_4 | SINK
OutPort_12793228_3 | SOURCE
InPort_12793228_4 | SINK
OutPort_12793242_3 | SOURCE
InPort_12793242_4 | SINK
OutPort_12793256_3 | SOURCE
InPort_12793256_4 | SINK
OutPort_12794056_3 | SOURCE
InPort_12794056_4 | SINK
OutPort_12794219_3 | SOURCE
InPort_12794219_4 | SINK
OutPort_12794232_3 | SOURCE
InPort_12794232_4 | SINK
OutPort_12794241_3 | SOURCE
InPort_12794241_4 | SINK
OutPort_12794324_3 | SOURCE
InPort_12794324_4 | SINK
OutPort_12794368_3 | SOURCE
InPort_12794368_4 | SINK
OutPort_12794439_3 | SOURCE
InPort_12794439_4 | SINK
OutPort_12794449_3 | SOURCE
InPort_12794449_4 | SINK
OutPort_12794493_3 | SOURCE
InPort_12794493_4 | SINK
OutPort_12794553_3 | SOURCE
InPort_12794553_4 | SINK
OutPort_12795423_3 | SOURCE
InPort_12795423_4 | SINK
OutPort_12795431_3 | SOURCE
InPort_12795431_4 | SINK
OutPort_12795439_3 | SOURCE
InPort_12795439_4 | SINK
OutPort_12795673_3 | SOURCE
InPort_12795673_4 | SINK
OutPort_12796121_3 | SOURCE
InPort_12796121_4 | SINK
OutPort_12796263_3 | SOURCE
InPort_12796263_4 | SINK
OutPort_12796318_3 | SOURCE
InPort_12796318_4 | SINK
OutPort_12797050_3 | SOURCE
InPort_12797050_4 | SINK
OutPort_12797080_3 | SOURCE
InPort_12797080_4 | SINK
OutPort_12797518_3 | SOURCE
InPort_12797518_4 | SINK
OutPort_12915511_3 | SOURCE
InPort_12915511_4 | SINK
OutPort_12915737_3 | SOURCE
InPort_12915737_4 | SINK
OutPort_12915745_3 | SOURCE
InPort_12915745_4 | SINK
OutPort_12915755_3 | SOURCE
InPort_12915755_4 | SINK
OutPort_12915953_3 | SOURCE
InPort_12915953_4 | SINK
OutPort_12916093_3 | SOURCE
InPort_12916093_4 | SINK
OutPort_12916105_3 | SOURCE
InPort_12916105_4 | SINK
OutPort_12916113_3 | SOURCE
InPort_12916113_4 | SINK
OutPort_12918900_3 | SOURCE
InPort_12918900_4 | SINK
OutPort_12918949_3 | SOURCE
InPort_12918949_4 | SINK
OutPort_12918957_3 | SOURCE
InPort_12918957_4 | SINK
InPort_12919029_1 | SINK
OutPort_12919029_2 | SOURCE
InPort_12919413_1 | SINK
OutPort_12919413_2 | SOURCE
OutPort_12919494_3 | SOURCE
InPort_12919494_4 | SINK
OutPort_12919553_3 | SOURCE
InPort_12919553_4 | SINK
OutPort_12919649_3 | SOURCE
InPort_12919649_4 | SINK
OutPort_12919728_3 | SOURCE
InPort_12919728_4 | SINK
OutPort_12919866_3 | SOURCE
InPort_12919866_4 | SINK
OutPort_12919876_3 | SOURCE
InPort_12919876_4 | SINK
OutPort_12919884_3 | SOURCE
InPort_12919884_4 | SINK
OutPort_12919892_3 | SOURCE
InPort_12919892_4 | SINK
OutPort_12920018_3 | SOURCE
InPort_12920018_4 | SINK
OutPort_12920060_3 | SOURCE
InPort_12920060_4 | SINK
OutPort_12920493_3 | SOURCE
InPort_12920493_4 | SINK
OutPort_12921154_3 | SOURCE
InPort_12921154_4 | SINK
OutPort_12921162_3 | SOURCE
InPort_12921162_4 | SINK
OutPort_12921485_3 | SOURCE
InPort_12921485_4 | SINK
OutPort_12921681_3 | SOURCE
InPort_12921681_4 | SINK
OutPort_12922132_3 | SOURCE
InPort_12922132_4 | SINK
OutPort_12922862_3 | SOURCE
InPort_12922862_4 | SINK
OutPort_12922953_3 | SOURCE
InPort_12922953_4 | SINK
OutPort_12922965_3 | SOURCE
InPort_12922965_4 | SINK
OutPort_12922973_3 | SOURCE
InPort_12922973_4 | SINK
OutPort_12922983_3 | SOURCE
InPort_12922983_4 | SINK
OutPort_12923076_3 | SOURCE
InPort_12923076_4 | SINK
OutPort_12923152_3 | SOURCE
InPort_12923152_4 | SINK
OutPort_12923160_3 | SOURCE
InPort_12923160_4 | SINK
OutPort_12923166_3 | SOURCE
InPort_12923166_4 | SINK
OutPort_12923174_3 | SOURCE
InPort_12923174_4 | SINK
OutPort_12923182_3 | SOURCE
InPort_12923182_4 | SINK
OutPort_12923383_3 | SOURCE
InPort_12923383_4 | SINK
OutPort_12923478_3 | SOURCE
InPort_12923478_4 | SINK
OutPort_12923513_3 | SOURCE
InPort_12923513_4 | SINK
OutPort_12943624_3 | SOURCE
InPort_12943624_4 | SINK
OutPort_12943632_3 | SOURCE
InPort_12943632_4 | SINK
Port_12944109_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944408_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944109_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944154_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944513_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944154_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944165_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944492_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944165_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944176_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944471_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944176_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944189_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944450_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944189_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944202_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944429_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944202_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944403_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957266_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944403_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944408_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944514_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944429_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957267_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944429_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944430_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944430_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944450_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944450_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944451_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944451_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944471_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944471_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944472_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944472_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944492_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944492_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944493_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944493_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944513_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944513_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944514_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944524_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944601_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944524_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944541_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944533_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944541_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944533_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944550_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944558_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944550_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944558_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944578_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944569_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944577_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944569_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944577_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944590_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944577_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944578_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944581_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944589_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944581_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944589_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944602_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944589_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944590_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944601_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944602_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944601_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949557_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944640_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944648_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944640_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944648_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957315_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944648_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944649_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944649_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949541_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12944852_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955389_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12944852_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945193_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945193_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945272_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945272_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945453_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945301_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945452_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945301_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945312_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945427_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945312_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945323_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945402_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945323_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945334_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945377_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945334_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945368_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945377_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945368_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967907_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945377_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945393_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945393_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945402_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945402_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945418_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945418_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945427_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945427_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945443_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945443_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945452_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945452_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945453_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945482_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945482_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945597_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945564_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945564_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945595_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945595_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945734_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945597_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945674_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945618_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945733_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945618_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945631_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945708_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945631_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945644_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945683_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945644_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945674_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945683_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945683_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967560_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945708_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967904_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945708_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945724_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945724_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945733_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945733_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945734_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12945828_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946350_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12945828_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946350_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13080260_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946350_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946351_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946351_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946402_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946373_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946402_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946373_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946402_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946403_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946403_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079955_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946413_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946450_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946413_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946433_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946433_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946454_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946440_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946450_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946440_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946454_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946450_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946451_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946451_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958566_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946477_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946611_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946477_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946488_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946538_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946488_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946503_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946542_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946503_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946520_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946571_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946520_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958690_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946538_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946543_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946538_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946612_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946542_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946572_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946542_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946543_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946546_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958690_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946546_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958692_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946563_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946571_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946563_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946571_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946572_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946611_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969508_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946611_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946612_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946622_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946622_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946639_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946631_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946639_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946631_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107376_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946641_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107376_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946641_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107378_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12946986_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12946986_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947079_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947079_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947421_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947110_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947420_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947110_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947125_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947395_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947125_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947331_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947370_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947331_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947370_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947470_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947370_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947386_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947386_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947395_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947395_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947411_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947411_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947420_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947420_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947421_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
OutPort_12947445_3 | SOURCE
InPort_12947445_4 | SINK
Port_12947446_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947469_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947446_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947469_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158467_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947469_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947470_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947507_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065843_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947507_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065845_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947517_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065843_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947517_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947545_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947553_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947545_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947553_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13065846_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947553_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947554_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947554_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947566_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947558_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947566_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947558_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947566_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947567_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947567_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947579_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947579_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947580_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947579_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947593_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947580_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947584_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947592_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947584_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947592_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959019_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947592_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947593_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947597_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947597_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947745_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947703_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947703_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947747_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947718_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947718_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947751_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947745_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947748_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947747_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947752_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947747_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947748_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947751_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947771_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947751_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947752_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947762_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947781_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947762_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959129_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947771_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947781_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947784_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947784_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959016_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947793_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959016_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947793_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959018_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12947812_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947812_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947986_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947878_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947878_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947982_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947891_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947891_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947978_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947947_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958806_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947947_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947978_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947983_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947982_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947987_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947982_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947983_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947986_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958897_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947986_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12947987_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948072_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958913_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948072_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958917_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948081_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958913_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948081_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958957_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948094_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158466_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948094_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13158479_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948110_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948110_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948266_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948183_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948183_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948262_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948198_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948198_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948258_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948209_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948209_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948270_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948246_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948270_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948246_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948284_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948258_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948263_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948258_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969379_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948262_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948267_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948262_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948263_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948266_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948271_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948266_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948267_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948270_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948271_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948274_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948274_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948284_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12948294_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948815_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948294_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948411_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948846_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948411_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948426_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948426_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948677_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948439_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948439_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948673_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948454_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948454_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948669_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948669_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948674_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948669_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948670_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948670_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957548_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948673_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948678_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948673_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948674_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948677_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948847_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948677_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948678_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948815_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948837_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948837_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948846_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948846_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12948847_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949020_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949020_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949068_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949068_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957392_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949068_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949069_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949069_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949116_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949111_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955389_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949111_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955374_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949116_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955390_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949116_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949117_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949117_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949236_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957391_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949236_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949263_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949263_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949477_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949410_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949495_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949410_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949541_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949431_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949431_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949479_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949442_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953737_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949442_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949465_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949491_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949465_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949477_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949479_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949492_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949479_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
