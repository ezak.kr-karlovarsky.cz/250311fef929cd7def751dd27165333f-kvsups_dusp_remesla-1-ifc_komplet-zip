Properties of the parts of a building model (IFC4), part 23 of 23

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (214)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Typ systému | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
13109473 | -1.PP_SO-101 | 2272.41 | 0.000356274 | 0.152061 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1008 | 0.107085 | 15 | 27 | 2272.41 | ø15 | 21.3 | 16 | TR02.02.0742 | 0742 | yes | 0
13109481 | -1.PP_SO-101 | 1275.71 | 0.000356274 | 0.0853655 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1008 | 0.0601165 | 15 | 27 | 1275.71 | ø15 | 21.3 | 16 | TR02.02.0743 | 0743 | yes | 0
13109512 | -1.PP_SO-101 | 2272.41 | 0.000356274 | 0.152061 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1008 | 0.107085 | 15 | 39 | 2272.41 | ø15 | 21.3 | 16 | TR02.02.0744 | 0744 | yes | 0
13109520 | -1.PP_SO-101 | 1425.71 | 0.000356274 | 0.0954029 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2160.65 | 2150 | 2150 | 2139.35 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1008 | 0.0671851 | 15 | 39 | 1425.71 | ø15 | 21.3 | 16 | TR02.02.0745 | 0745 | yes | 0
13111128 | -1.PP_SO-101 | 412.375 | 0.00141175 | 0.0549298 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.0414565 | 32 | 120 | 412.375 | ø32 | 42.4 | 35.9 | TR02.02.0747 | 0747 | yes | 0
13111138 | -1.PP_SO-101 | 693.928 | 0.00141175 | 0.0924336 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2271.2 | 2250 | 2250 | 2228.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -917.95 | 0.0697612 | 32 | 120 | 693.928 | ø32 | 42.4 | 35.9 | TR02.02.0748 | 0748 | yes | 0
13111165 | -1.PP_SO-101 | 377.375 | 0.00141175 | 0.0502677 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2171.2 | 2150 | 2150 | 2128.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -1017.95 | 0.0379379 | 32 | 71 | 377.375 | ø32 | 42.4 | 35.9 | TR02.02.0749 | 0749 | yes | 0
13111173 | -1.PP_SO-101 | 746.883 | 0.00141175 | 0.0994875 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2171.2 | 2150 | 2150 | 2128.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -1017.95 | 0.0750849 | 32 | 71 | 746.883 | ø32 | 42.4 | 35.9 | TR02.02.0750 | 0750 | yes | 0
13115875 | -1.PP_SO-101 | 22626.4 | 0.00141175 | 3.01392 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -817.95 | 2.27466 | 32 | 286 | 22626.4 | ø32 | 42.4 | 35.9 | TR02.02.0761 | 0761 | yes | 0
13115905 | -1.PP_SO-101 | 22426.4 | 0.00141175 | 2.98728 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -817.95 | 2.25455 | 32 | 289 | 22426.4 | ø32 | 42.4 | 35.9 | TR02.02.0762 | 0762 | yes | 0
13115955 | -1.PP_SO-101 | 22225.6 | 0.00141175 | 2.96053 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -817.95 | 2.23436 | 32 | 64 | 22225.6 | ø32 | 42.4 | 35.9 | TR02.02.0763 | 0763 | yes | 0
13115979 | -1.PP_SO-101 | 22026.4 | 0.00141175 | 2.934 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2371.2 | 2350 | 2350 | 2328.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -817.95 | 2.21434 | 32 | 194 | 22026.4 | ø32 | 42.4 | 35.9 | TR02.02.0764 | 0764 | yes | 0
13116007 | -1.PP_SO-101 | 21569.4 | 0.00285535 | 4.08607 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -826.5 | 3.38812 | 50 | 300 | 21569.4 | ø50 | 60.3 | 53 | TR02.02.0765 | 0765 | yes | 0
13116031 | -1.PP_SO-101 | 21049.4 | 0.00285535 | 3.98756 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2380.15 | 2350 | 2350 | 2319.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -826.5 | 3.30643 | 50 | 293 | 21049.4 | ø50 | 60.3 | 53 | TR02.02.0766 | 0766 | yes | 0
13116340 | -1.PP_SO-101 | 20182.1 | 0.00183197 | 3.06241 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -820.9 | 2.53616 | 40 | 37 | 20182.1 | ø40 | 48.3 | 41.8 | TR02.02.0767 | 0767 | yes | 0
13116661 | -1.PP_SO-101 | 121.694 | 0.00141175 | 0.0162101 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2358.02 | 2256.97 | 2343.03 | 2241.98 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -905.718 | 0.0122341 | 32 | 194 | 121.694 | ø32 | 42.4 | 35.9 | TR02.02.0768 | 0768 | yes | 100
13116667 | -1.PP_SO-101 | 121.694 | 0.00141175 | 0.0162101 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2358.02 | 2256.97 | 2343.03 | 2241.98 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -905.718 | 0.0122341 | 32 | 64 | 121.694 | ø32 | 42.4 | 35.9 | TR02.02.0769 | 0769 | yes | 100
13116690 | -1.PP_SO-101 | 191.513 | 0.00141175 | 0.0255103 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2358.02 | 2343.03 | 2207.61 | 2192.61 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -955.088 | 0.019253 | 32 | 289 | 191.513 | ø32 | 42.4 | 35.9 | TR02.02.0770 | 0770 | yes | 100
13116696 | -1.PP_SO-101 | 191.513 | 0.00141175 | 0.0255103 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2358.02 | 2207.61 | 2343.03 | 2192.61 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -955.088 | 0.019253 | 32 | 286 | 191.513 | ø32 | 42.4 | 35.9 | TR02.02.0771 | 0771 | yes | 100
13119995 | 1.NP_SO-101 | 185.669 | 0.000568237 | 0.0156907 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | 2813.45 | 2800 | 2800 | 2786.55 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 2789.2 | 0.0116659 | 20 | 198 | 185.669 | ø20 | 26.9 | 21.6 | TR02.02.0772 | 0772 | yes | 0
13126729 | -1.PP_SO-101 | 20622.1 | 0.00183197 | 3.12918 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 2.59145 | 40 | 39 | 20622.1 | ø40 | 48.3 | 41.8 | TR02.02.0775 | 0775 | yes | 0
13127616 | -1.PP_SO-101 | 2271.8 | 0.00141175 | 0.302612 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.2 | 2200 | 2200 | 2178.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -967.95 | 0.228386 | 32 | 197 | 2271.8 | ø32 | 42.4 | 35.9 | TR02.02.0776 | 0776 | yes | 0
13127640 | -1.PP_SO-101 | 3001 | 0.00141175 | 0.399744 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -967.32 | 0.301694 | 32 | 289 | 3001 | ø32 | 42.4 | 35.9 | TR02.02.0777 | 0777 | yes | 0
13127669 | -1.PP_SO-101 | 2171.64 | 0.00141175 | 0.28927 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.82 | 2200.62 | 2200.62 | 2179.42 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -967.333 | 0.218317 | 32 | 69 | 2171.64 | ø32 | 42.4 | 35.9 | TR02.02.0778 | 0778 | yes | 0
13127691 | -1.PP_SO-101 | 2851 | 0.00141175 | 0.379764 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -967.32 | 0.286614 | 32 | 286 | 2851 | ø32 | 42.4 | 35.9 | TR02.02.0779 | 0779 | yes | 0 | Izolace - Typ izolace: Tepelná
13127927 | -1.PP_SO-101 | 186.915 | 0.00141175 | 0.0248977 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2269.67 | 2249.19 | 2200.81 | 2180.33 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -966.527 | 0.0187907 | 32 | 197 | 186.915 | ø32 | 42.4 | 35.9 | TR02.02.0780 | 0780 | yes | 26.795
13128243 | -1.PP_SO-101 | 183.96 | 0.00141175 | 0.0245041 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2269.52 | 2249.04 | 2201.43 | 2180.95 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -965.91 | 0.0184936 | 32 | 69 | 183.96 | ø32 | 42.4 | 35.9 | TR02.02.0781 | 0781 | yes | 26.795
13137623 | 2.NP_SO-101 | 1084.12 | 0.000891835 | 0.114777 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | -76.9875 | -1161.11 | -76.9875 | -1161.11 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2838.89 | 0.0851465 | 25 | 287 | 1084.12 | ø25 | 33.7 | 27.2 | TR02.02.0783 | 0783 | yes
13139104 | -1.PP_SO-101 | 66.2443 | 0.00141175 | 0.00882397 | 30 | ø92 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.2 | 2200 | 2200 | 2178.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -967.95 | 0.0066596 | 32 | 197 | 66.2443 | ø32 | 42.4 | 35.9 | TR02.02.0786 | 0786 | yes | 0 | Izolace - Typ izolace: Tepelná
13139518 | -1.PP_SO-101 | 166.244 | 0.00141175 | 0.0221443 | 30 | ø92 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.82 | 2200.62 | 2200.62 | 2179.42 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -967.333 | 0.0167127 | 32 | 69 | 166.244 | ø32 | 42.4 | 35.9 | TR02.02.0787 | 0787 | yes | 0 | Izolace - Typ izolace: Tepelná
13139528 | -1.PP_SO-101 | 2382.71 | 0.00141175 | 0.317386 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.82 | 2200.62 | 2200.62 | 2179.42 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -967.333 | 0.239536 | 32 | 69 | 2382.71 | ø32 | 42.4 | 35.9 | TR02.02.0788 | 0788 | yes | 0 | Izolace - Typ izolace: Tepelná
13140474 | -1.PP_SO-101 | 101.935 | 0.00141175 | 0.0135782 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2321.2 | 2300 | 2300 | 2278.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -867.95 | 0.0102477 | 32 | 285 | 101.935 | ø32 | 42.4 | 35.9 | TR02.02.0789 | 0789 | yes | 0
13140538 | -1.PP_SO-101 | 46.025 | 0.00141175 | 0.00613069 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-101 | 2276.19 | 2276.19 | 2230.16 | 2230.16 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -919.837 | 0.00462694 | 32 | 285 | 46.025 | ø32 | 42.4 | 35.9 | TR02.02.0790 | 0790 | yes
13140541 | -1.PP_SO-101 | 2025.71 | 0.00141175 | 0.269831 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -967.32 | 0.203646 | 32 | 286 | 2025.71 | ø32 | 42.4 | 35.9 | TR02.02.0791 | 0791 | yes | 0 | Izolace - Typ izolace: Tepelná
13140613 | -1.PP_SO-101 | 216.862 | 0.00141175 | 0.0288868 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -967.32 | 0.0218013 | 32 | 277 | 216.862 | ø32 | 42.4 | 35.9 | TR02.02.0792 | 0792 | yes | 0 | Izolace - Typ izolace: Tepelná
13140621 | -1.PP_SO-101 | 2028.79 | 0.00141175 | 0.270242 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-101 | 2221.83 | 2200.63 | 2200.63 | 2179.43 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -967.32 | 0.203956 | 32 | 289 | 2028.79 | ø32 | 42.4 | 35.9 | TR02.02.0793 | 0793 | yes | 0 | Izolace - Typ izolace: Tepelná
13140955 | 1.NP_SO-101 | 184.138 | 0.000568237 | 0.0155612 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-101 | 2813.45 | 2800 | 2800 | 2786.55 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 2789.2 | 0.0115697 | 20 | 68 | 184.138 | ø20 | 26.9 | 21.6 | TR02.02.0794 | 0794 | yes | 0
13142742 | -1.PP_SO-101 | 705.075 | 0.000568237 | 0.0595851 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 2972.54 | 2267.46 | 2972.54 | 2267.46 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -882.537 | 0.0443012 | 20 | 36 | 705.075 | ø20 | 26.9 | 21.6 | TR02.02.0795 | 0795 | yes
13143820 | 2.NP_SO-101 | 3946.03 | 0.000891835 | 0.417772 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 3923.01 | 3923.01 | -23.0125 | -23.0125 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3976.99 | 0.30992 | 25 | 201 | 3946.03 | ø25 | 33.7 | 27.2 | TR02.02.0797 | 0797 | yes
13144145 | 2.NP_SO-101 | 3946.03 | 0.000891835 | 0.417772 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 3913.01 | 3913.01 | -33.0125 | -33.0125 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3966.99 | 0.30992 | 25 | 276 | 3946.03 | ø25 | 33.7 | 27.2 | TR02.02.0803 | 0803 | yes
13144211 | 1.NP_SO-101 | 40.4687 | 0.000891835 | 0.00428449 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2716.85 | 2700 | 2700 | 2683.15 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2686.4 | 0.0031784 | 25 | 296 | 40.4687 | ø25 | 33.7 | 27.2 | TR02.02.0804 | 0804 | yes | 0
13144390 | 1.NP_SO-101 | 2716.28 | 0.000891835 | 0.287577 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2679.36 | 2679.36 | -36.9188 | -36.9188 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -36.9188 | 0.213336 | 25 | 279 | 2716.28 | ø25 | 33.7 | 27.2 | TR02.02.0805 | 0805 | yes
13144398 | 1.NP_SO-101 | 30.4687 | 0.000891835 | 0.00322578 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2716.85 | 2700 | 2700 | 2683.15 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2686.4 | 0.00239301 | 25 | 279 | 30.4688 | ø25 | 33.7 | 27.2 | TR02.02.0806 | 0806 | yes | 0
13144423 | 1.NP_SO-101 | 959.617 | 0.00141175 | 0.127824 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2721.2 | 2700 | 2700 | 2678.8 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 2682.05 | 0.0964712 | 32 | 307 | 959.617 | ø32 | 42.4 | 35.9 | TR02.02.0807 | 0807 | yes | 0
13144560 | 1.NP_SO-101 | 580.118 | 0.00141175 | 0.0772738 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-101 | 2821.2 | 2800 | 2800 | 2778.8 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2782.05 | 0.0583199 | 32 | 288 | 580.118 | ø32 | 42.4 | 35.9 | TR02.02.0808 | 0808 | yes | 0
13144573 | 1.NP_SO-101 | 240.28 | 0.000891835 | 0.0254388 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2816.85 | 2800 | 2800 | 2783.15 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 2786.4 | 0.0188715 | 25 | 252 | 240.28 | ø25 | 33.7 | 27.2 | TR02.02.0809 | 0809 | yes | 0
13144728 | 2.NP_SO-101 | 1077.67 | 0.000356274 | 0.0721134 | 0 | ø15 mm | 0.00625 | HC | 2.NP_SO-101 | -89.35 | -100 | -100 | -110.65 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3892 | 0.0507841 | 15 | 27 | 1077.67 | ø15 | 21.3 | 16 | TR02.02.0810 | 0810 | no | 0
13146067 | 2.NP_SO-101 | 61.1186 | 0.00183197 | 0.00927407 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-101 | -3965.54 | -3965.54 | -4026.66 | -4026.66 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -26.6625 | 0.00768039 | 40 | 297 | 61.1186 | ø40 | 48.3 | 41.8 | TR02.02.0812 | 0812 | yes
13147571 | 2.NP_SO-101 | 3940.37 | 0.000568237 | 0.332996 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-101 | 7928.51 | 7928.51 | 3988.13 | 3988.13 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7988.13 | 0.247581 | 20 | 291 | 3940.37 | ø20 | 26.9 | 21.6 | TR02.02.0816 | 0816 | yes
13149067 | 2.NP_SO-101 | 12841.5 | 0.00141175 | 1.71054 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-101 | 7865.33 | 7865.33 | -4976.19 | -4976.19 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -976.188 | 1.29097 | 32 | 71 | 12841.5 | ø32 | 42.4 | 35.9 | TR02.02.0818 | 0818 | yes
13151634 | 1.NP_SO-101 | 375.075 | 0.000568237 | 0.0316972 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-101 | 3813.45 | 3800 | 3800 | 3786.55 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 3789.2 | 0.0235667 | 20 | 26 | 375.075 | ø20 | 26.9 | 21.6 | TR02.02.0821 | 0821 | yes | 0
13151681 | -1.PP_SO-101 | 3925.08 | 0.000568237 | 0.331704 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 6932.54 | 3007.46 | 6932.54 | 3007.46 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -142.538 | 0.24662 | 20 | 26 | 3925.08 | ø20 | 26.9 | 21.6 | TR02.02.0822 | 0822 | yes
13151774 | -1.PP_SO-101 | 375.075 | 0.000568237 | 0.0316972 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 3003.45 | 2990 | 2990 | 2976.55 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -170.8 | 0.0235667 | 20 | 26 | 375.075 | ø20 | 26.9 | 21.6 | TR02.02.0823 | 0823 | yes | 0
13151782 | -1.PP_SO-101 | 705.075 | 0.000568237 | 0.0595851 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 2972.54 | 2972.54 | 2267.46 | 2267.46 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -882.537 | 0.0443012 | 20 | 26 | 705.075 | ø20 | 26.9 | 21.6 | TR02.02.0824 | 0824 | yes
13152235 | -1.PP_SO-101 | 3925.08 | 0.000568237 | 0.331704 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 6932.54 | 3007.46 | 6932.54 | 3007.46 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -142.538 | 0.24662 | 20 | 36 | 3925.08 | ø20 | 26.9 | 21.6 | TR02.02.0825 | 0825 | yes
13152537 | -1.PP_SO-101 | 269.763 | 0.000568237 | 0.0227973 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 3003.45 | 2990 | 2990 | 2976.55 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -170.8 | 0.0169497 | 20 | 36 | 269.763 | ø20 | 26.9 | 21.6 | TR02.02.0826 | 0826 | yes | 0
13152601 | 1.NP_SO-101 | 269.862 | 0.000568237 | 0.0228057 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-101 | 3813.45 | 3800 | 3800 | 3786.55 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3789.2 | 0.0169559 | 20 | 36 | 269.862 | ø20 | 26.9 | 21.6 | TR02.02.0827 | 0827 | yes | 0
13152811 | 2.NP_SO-101 | 95.5327 | 0.000356274 | 0.00639266 | 0 | ø15 mm | 0.00625 | HC | 2.NP_SO-101 | -89.35 | -100 | -100 | -110.65 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3892 | 0.00450187 | 15 | 27 | 95.5327 | ø15 | 21.3 | 16 | TR02.02.0828 | 0828 | yes | 0
13152978 | -1.PP_SO-101 | 58.725 | 0.000568237 | 0.00496278 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 7026.19 | 6967.46 | 7026.19 | 6967.46 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3817.46 | 0.0036898 | 20 | 36 | 58.725 | ø20 | 26.9 | 21.6 | TR02.02.0829 | 0829 | yes
13152990 | -1.PP_SO-101 | 7958.72 | 0.000568237 | 0.672583 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-101 | 15032.5 | 7073.81 | 15032.5 | 7073.81 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 3923.81 | 0.500061 | 20 | 9 | 7958.72 | ø20 | 26.9 | 21.6 | TR02.02.0830 | 0830 | yes
13155511 | 2.NP_SO-101 | 3944.37 | 0.000568237 | 0.333335 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-101 | 7918.51 | 7918.51 | 3974.13 | 3974.13 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7974.13 | 0.247832 | 20 | 313 | 3944.37 | ø20 | 26.9 | 21.6 | TR02.02.0832 | 0832 | yes
13155952 | 2.NP_SO-101 | 714.588 | 0.00183197 | 0.108431 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-101 | -4093.34 | -4093.34 | -4807.93 | -4807.93 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -807.925 | 0.0897977 | 40 | 299 | 714.588 | ø40 | 48.3 | 41.8 | TR02.02.0833 | 0833 | yes
13157151 | -1.PP_SO-101 | 1921.83 | 0.00183197 | 0.291617 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2374.15 | 2350 | 2350 | 2325.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -820.9 | 0.241505 | 40 | 39 | 1921.83 | ø40 | 48.3 | 41.8 | TR02.02.0834 | 0834 | yes | 0
13157880 | -1.PP_SO-101 | 119.064 | 0.00183197 | 0.0180667 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2359.17 | 2257.9 | 2342.1 | 2240.83 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -906.874 | 0.014962 | 40 | 37 | 119.064 | ø40 | 48.3 | 41.8 | TR02.02.0835 | 0835 | yes | 100
13157899 | -1.PP_SO-101 | 648.498 | 0.00183197 | 0.0984023 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2274.15 | 2250 | 2250 | 2225.85 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -920.9 | 0.0814926 | 40 | 37 | 648.498 | ø40 | 48.3 | 41.8 | TR02.02.0836 | 0836 | yes | 0
13157925 | -1.PP_SO-101 | 119.064 | 0.00183197 | 0.0180667 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2359.17 | 2257.9 | 2342.1 | 2240.83 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -906.874 | 0.014962 | 40 | 39 | 119.064 | ø40 | 48.3 | 41.8 | TR02.02.0837 | 0837 | yes | 100
13157937 | -1.PP_SO-101 | 543.185 | 0.00183197 | 0.0824223 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-101 | 2274.15 | 2250 | 2250 | 2225.85 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -920.9 | 0.0682587 | 40 | 39 | 543.185 | ø40 | 48.3 | 41.8 | TR02.02.0838 | 0838 | yes | 0
13157965 | -1.PP_SO-101 | 113.804 | 0.00285535 | 0.0215587 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2361.55 | 2259.76 | 2340.24 | 2238.45 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -908.974 | 0.0178762 | 50 | 293 | 113.804 | ø50 | 60.3 | 53 | TR02.02.0839 | 0839 | yes | 100
13157982 | -1.PP_SO-101 | 359.205 | 0.00285535 | 0.0680471 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2280.15 | 2250 | 2250 | 2219.85 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -926.5 | 0.0564238 | 50 | 293 | 359.205 | ø50 | 60.3 | 53 | TR02.02.0840 | 0840 | yes | 0
13158005 | -1.PP_SO-101 | 113.804 | 0.00285535 | 0.0215587 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2361.55 | 2259.76 | 2340.24 | 2238.45 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -908.974 | 0.0178762 | 50 | 300 | 113.804 | ø50 | 60.3 | 53 | TR02.02.0841 | 0841 | yes | 100
13158021 | -1.PP_SO-101 | 209.238 | 0.00285535 | 0.0396376 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-101 | 2280.15 | 2250 | 2250 | 2219.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -926.5 | 0.032867 | 50 | 300 | 209.238 | ø50 | 60.3 | 53 | TR02.02.0842 | 0842 | yes | 0
13159023 | 2.NP_SO-101 | 2734.59 | 0.000891835 | 0.289515 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | -1220.64 | -1220.64 | -3955.23 | -3955.23 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 44.7748 | 0.214774 | 25 | 289 | 2734.59 | ø25 | 33.7 | 27.2 | TR02.02.0849 | 0849 | yes
13159386 | 1.NP_SO-101 | 88.3706 | 0.000891835 | 0.00935594 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2816.85 | 2800 | 2800 | 2783.15 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 2786.4 | 0.00694061 | 25 | 299 | 88.3706 | ø25 | 33.7 | 27.2 | TR02.02.0850 | 0850 | yes | 0
13159413 | 1.NP_SO-101 | 88.3108 | 0.000891835 | 0.00934961 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-101 | 2816.85 | 2800 | 2800 | 2783.15 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2786.4 | 0.00693591 | 25 | 289 | 88.3108 | ø25 | 33.7 | 27.2 | TR02.02.0851 | 0851 | yes | 0
13159449 | 2.NP_SO-101 | 2749.99 | 0.000891835 | 0.291146 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | -1220.64 | -1220.64 | -3970.63 | -3970.63 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 29.3748 | 0.215984 | 25 | 299 | 2749.99 | ø25 | 33.7 | 27.2 | TR02.02.0852 | 0852 | yes
13159698 | 2.NP_SO-101 | 1092.37 | 0.000891835 | 0.115651 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | -86.9844 | -86.9875 | -1179.36 | -1179.36 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2820.64 | 0.0857946 | 25 | 289 | 1092.37 | ø25 | 33.7 | 27.2 | TR02.02.0855 | 0855 | yes | 536274
13159821 | 2.NP_SO-101 | 1102.38 | 0.000891835 | 0.11671 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | -76.9875 | -76.9875 | -1179.36 | -1179.36 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 2820.64 | 0.0865803 | 25 | 299 | 1102.38 | ø25 | 33.7 | 27.2 | TR02.02.0860 | 0860 | yes
13162986 | 2.NP_SO-101 | 3946.03 | 0.000891835 | 0.417772 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 3913.02 | 3913.01 | -33.0125 | -33.0156 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3966.98 | 0.30992 | 25 | 315 | 3946.03 | ø25 | 33.7 | 27.2 | TR02.02.0872 | 0872 | yes | 535303
13163197 | 2.NP_SO-101 | 3946.02 | 0.000891835 | 0.417772 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-101 | 3923.01 | 3923.01 | -23.0125 | -23.0125 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3976.99 | 0.30992 | 25 | 300 | 3946.02 | ø25 | 33.7 | 27.2 | TR02.02.0876 | 0876 | yes
13164255 | -1.PP_SO-101 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2135.71 | 2135.71 | 2114.29 | 2114.29 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1035.71 | 0.00100963 | 15 | 27 | 21.425 | ø15 | 21.3 | 16 | TR02.02.0877 | 0877 | yes
13164268 | -1.PP_SO-101 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2135.71 | 2135.71 | 2114.29 | 2114.29 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1035.71 | 0.00100963 | 15 | 39 | 21.425 | ø15 | 21.3 | 16 | TR02.02.0878 | 0878 | yes
13164281 | -1.PP_SO-101 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2135.71 | 2114.29 | 2135.71 | 2114.29 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | -1035.71 | 0.00100963 | 15 | 27 | 21.425 | ø15 | 21.3 | 16 | TR02.02.0879 | 0879 | yes
13164294 | -1.PP_SO-101 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-101 | 2135.71 | 2135.71 | 2114.29 | 2114.29 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | -1035.71 | 0.00100963 | 15 | 39 | 21.425 | ø15 | 21.3 | 16 | TR02.02.0880 | 0880 | yes
13164465 | -1.PP_SO-101 | 15.075 | 0.000568237 | 0.00127397 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2182.54 | 2182.54 | 2167.46 | 2167.46 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | -982.538 | 0.00094719 | 20 | 30 | 15.075 | ø20 | 26.9 | 21.6 | TR02.02.0881 | 0881 | yes
13164476 | -1.PP_SO-101 | 15.075 | 0.000568237 | 0.00127397 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-101 | 2182.54 | 2182.54 | 2167.46 | 2167.46 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | -982.538 | 0.00094719 | 20 | 200 | 15.075 | ø20 | 26.9 | 21.6 | TR02.02.0882 | 0882 | yes

# IfcPipeSegment: Typy trubek:Ocel_černá, Typy trubek:Ocel_černá:13144960
In: 1.NP_SO-101
Type - Material: 0-128-255
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_černá; Označení typu: 03; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat); Group: HT_vratné vodní (45 °C) 1
Qto_PipeSegmentBaseQuantities - Length: 38.8937 mm; GrossCrossSectionArea: 0.00285535 m2; NetCrossSectionArea: 0.00285535 m2; OuterSurfaceArea: 0.00736795 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm
Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Relativní drsnost: 0.00188679; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Referenční podlaží: 1.NP_SO-101; Horní výška: -821.419 mm; Koncová střední výška: -821.419 mm; Počáteční střední výška: -860.313 mm; Spodní výška: -860.313 mm; Střední výška: -860.313 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Materiál: Kov, ocel; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ; Typ systému: HT_vratné vodní (45 °C); Drsnost: 0.1 mm; Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_vratné vodní (45 °C) 1; Obrátit výšku: -860.313 mm; Plocha: 0.00610941 m2; Popis úseku: FE; Průměr: 50 mm; Řez: 229; Typ přípoje: Obecné
Kóty - Délka: 38.8937 mm; Velikost: ø50; Vnější průměr: 60.3 mm; Vnitřní průměr: 53 mm
Identifikační data - Kód prvku: TR02.03.0811; Označení: 0811
Jiné - Rodina: Typy trubek; Páteřní trasa: yes; Id typu: 12487561; Rodina a typ: Typy trubek: Ocel_černá; Typ: Ocel_černá

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 5717.73 m2; Hrubý objem: 21015.1 m3; Obsazená plocha: 5717.73 m2; Obsazený objem: 21015.1 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
