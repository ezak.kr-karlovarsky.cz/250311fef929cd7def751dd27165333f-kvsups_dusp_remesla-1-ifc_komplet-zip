Properties of the parts of a building model (IFC4), part 17 of 23

# IfcPipeFitting: M_Koleno, obecné:Standardní (335)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
13128213 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.00000597196 | 3.13498 | 15 | ø32-ø32 | 1.83919 | 34.925 | TT01.01.0499 | 0499 | yes | 23.8125 | 17.4625
13128217 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2250 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.00000597196 | 3.13498 | 15 | ø32-ø32 | 1.83919 | 34.925 | TT01.01.0500 | 0500 | yes | 23.8125 | 17.4625
13128420 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2249.85 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.00000595442 | 3.12567 | 14.956 | ø32-ø32 | 1.83373 | 34.925 | TT01.01.0501 | 0501 | yes | 23.8125 | 17.4625
13128594 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200.62 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0502 | 0502 | yes | 23.8125 | 17.4625
13128596 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200.62 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.00000597196 | 3.13498 | 15 | ø32-ø32 | 1.83919 | 34.925 | TT01.01.0503 | 0503 | yes | 23.8125 | 17.4625
13137417 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 650 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0504 | 0504 | no | 15.9375 | 9.5875
13137438 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | 640 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0506 | 0506 | no | 15.9375 | 9.5875
13139143 | -1.PP_SO-101 | 30 | ø92 mm-ø92 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0511 | 0511 | yes | 23.8125 | 17.4625 | Izolace - Typ izolace: Tepelná
13139147 | 2.NP_SO-101 | 40 | ø100 mm-ø100 mm | HD | 2.NP_SO-101 | -4950 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0512 | 0512 | yes | 17.4625 | 11.1125 | Izolace - Typ izolace: Tepelná
13139524 | 2.NP_SO-101 | 30 | ø80 mm-ø80 mm | HD | 2.NP_SO-101 | -4949.38 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0514 | 0514 | yes | 17.4625 | 11.1125 | Izolace - Typ izolace: Tepelná
13139539 | -1.PP_SO-101 | 30 | ø92 mm-ø92 mm | HD | -1.PP_SO-101 | 2200.62 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0516 | 0516 | yes | 23.8125 | 17.4625 | Izolace - Typ izolace: Tepelná
13139760 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0517 | 0517 | yes | 23.8125 | 17.4625
13140001 | -1.PP_SO-101 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-101 | 2200.63 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0518 | 0518 | yes | 23.8125 | 17.4625 | Izolace - Typ izolace: Tepelná
13140456 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200.63 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0520 | 0520 | yes | 17.4625 | 11.1125
13140550 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | -850 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0523 | 0523 | yes | 23.8125 | 17.4625
13140554 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2300 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0524 | 0524 | yes | 23.8125 | 17.4625
13140618 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0525 | 0525 | yes | 23.8125 | 17.4625
13140938 | 2.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-101 | -1200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0527 | 0527 | yes | 17.4625 | 11.1125
13140942 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0528 | 0528 | yes | 17.4625 | 11.1125
13140969 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | 2800 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0529 | 0529 | yes | 17.4625 | 11.1125
13140973 | 2.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-101 | -1200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0530 | 0530 | yes | 17.4625 | 11.1125
13144189 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0540 | 0540 | no | 15.9375 | 9.5875
13144417 | 1.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0542 | 0542 | yes | 20.6375 | 14.2875
13144543 | 1.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0544 | 0544 | yes | 20.6375 | 14.2875
13144548 | 1.NP_SO-101 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0545 | 0545 | yes | 23.8125 | 17.4625
13144610 | 1.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0549 | 0549 | yes | 20.6375 | 14.2875
13144759 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HC | 2.NP_SO-101 | -100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0552 | 0552 | yes | 14.2875 | 7.9375
13146755 | 4.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 4.NP_SO-101 | -100 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0554 | 0554 | no | 17.4625 | 11.1125
13146757 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 15050 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0555 | 0555 | yes | 17.4625 | 11.1125
13148781 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -110 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0556 | 0556 | no | 15.9375 | 9.5875
13150650 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0557 | 0557 | yes | 17.4625 | 11.1125
13150673 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-101 | -1000 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0559 | 0559 | yes | 17.4625 | 11.1125
13150865 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0560 | 0560 | yes | 23.8125 | 17.4625
13150867 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -110 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0561 | 0561 | yes | 15.9375 | 9.5875
13151642 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 6950 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0563 | 0563 | yes | 17.4625 | 11.1125
13151689 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 6950 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0564 | 0564 | yes | 17.4625 | 11.1125
13151708 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2250 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0565 | 0565 | yes | 17.4625 | 11.1125
13151738 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2990 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0566 | 0566 | yes | 17.4625 | 11.1125
13151792 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2990 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0567 | 0567 | yes | 17.4625 | 11.1125
13152545 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2990 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0568 | 0568 | yes | 17.4625 | 11.1125
13152609 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 6950 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0569 | 0569 | yes | 17.4625 | 11.1125
13152788 | 4.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 4.NP_SO-101 | -100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0570 | 0570 | yes | 17.4625 | 11.1125
13152792 | 1.NP_SO-101 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-101 | 3800 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0571 | 0571 | yes | 17.4625 | 11.1125
13152987 | 2.NP_SO-101 | 0 | ø15 mm-ø15 mm | HC | 2.NP_SO-101 | -100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000222098 | 5.91808 | 45 | ø15-ø15 | 2.63026 | 15.875 | TT01.01.0572 | 0572 | yes | 14.2875 | 7.9375
13153892 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2990 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0575 | 0575 | yes | 17.4625 | 11.1125
13153896 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-101 | 2250 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0576 | 0576 | yes | 17.4625 | 11.1125
13155948 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722935 | 15.9382 | 90.0024 | ø16-ø16 | 7.67033 | 19.175 | TT01.01.0580 | 0580 | no | 15.9375 | 9.5875
13157271 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0583 | 0583 | yes | 26.9875 | 20.6375
13157273 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0584 | 0584 | yes | 26.9875 | 20.6375
13157288 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0585 | 0585 | yes | 26.9875 | 20.6375
13157290 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0586 | 0586 | yes | 26.9875 | 20.6375
13157307 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0587 | 0587 | yes | 33.3375 | 26.9875
13157309 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0588 | 0588 | yes | 33.3375 | 26.9875
13157324 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0589 | 0589 | yes | 33.3375 | 26.9875
13157326 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0590 | 0590 | yes | 33.3375 | 26.9875
13157895 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0591 | 0591 | yes | 26.9875 | 20.6375
13157911 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0592 | 0592 | yes | 26.9875 | 20.6375
13157933 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2350 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0593 | 0593 | yes | 26.9875 | 20.6375
13157949 | -1.PP_SO-101 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-101 | 2250 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 20 | 40 | 0.0000283595 | 11.1786 | 45 | ø40-ø40 | 6.83867 | 41.275 | TT01.01.0594 | 0594 | yes | 26.9875 | 20.6375
13157978 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.0595 | 0595 | yes | 33.3375 | 26.9875
13157992 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2250 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.0596 | 0596 | yes | 33.3375 | 26.9875
13158017 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.0597 | 0597 | yes | 33.3375 | 26.9875
13158031 | -1.PP_SO-101 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-101 | 2250 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.0598 | 0598 | yes | 33.3375 | 26.9875
13158110 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200.63 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0599 | 0599 | yes | 23.8125 | 17.4625
13158114 | -1.PP_SO-101 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-101 | 2200.63 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0600 | 0600 | yes | 23.8125 | 17.4625 | Izolace - Typ izolace: Tepelná
13158174 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2200.63 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0601 | 0601 | yes | 23.8125 | 17.4625
13158178 | -1.PP_SO-101 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.0602 | 0602 | yes | 23.8125 | 17.4625
13158438 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0604 | 0604 |  | 15.9375 | 9.5875
13158479 | 1.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0606 | 0606 |  | 15.9375 | 9.5875
13159425 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -1200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0609 | 0609 | yes | 20.6375 | 14.2875
13159474 | 2.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-101 | -1200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0610 | 0610 | yes | 20.6375 | 14.2875
13159598 | 1.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-101 | 2800 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0611 | 0611 | yes | 20.6375 | 14.2875
13159639 | 1.NP_SO-101 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-101 | 2800 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207911 | 20.6413 | 90.0107 | ø25-ø25 | 11.4321 | 28.575 | TT01.01.0612 | 0612 | yes | 20.6375 | 14.2875
13159727 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0615 | 0615 |  | 15.9375 | 9.5875
13159746 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0616 | 0616 |  | 15.9375 | 9.5875
13159818 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0618 | 0618 |  | 15.9375 | 9.5875
13160173 | 2.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-101 | 7950 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0622 | 0622 |  | 15.9375 | 9.5875
13160253 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0624 | 0624 | no | 15.9375 | 9.5875
13160281 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0626 | 0626 |  | 15.9375 | 9.5875
13160468 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -110 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8 | 16 | 0.00000361453 | 6.60153 | 45 | ø16-ø16 | 3.17702 | 19.175 | TT01.01.0628 | 0628 |  | 15.9375 | 9.5875
13160470 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -110 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8 | 16 | 0.00000361453 | 6.60153 | 45 | ø16-ø16 | 3.17702 | 19.175 | TT01.01.0629 | 0629 |  | 15.9375 | 9.5875
13160498 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000441777 | 8.29654 | 55 | ø16-ø16 | 3.99275 | 19.175 | TT01.01.0630 | 0630 |  | 15.9375 | 9.5875
13160508 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0631 | 0631 |  | 15.9375 | 9.5875
13162373 | 4.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0632 | 0632 |  | 15.9375 | 9.5875
13163072 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0637 | 0637 |  | 15.9375 | 9.5875
13163086 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0638 | 0638 |  | 15.9375 | 9.5875
13163088 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0639 | 0639 | no | 15.9375 | 9.5875
13163207 | 3.NP_SO-101 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0642 | 0642 |  | 15.9375 | 9.5875
13164259 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0644 | 0644 | yes | 14.2875 | 7.9375
13164263 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0645 | 0645 | yes | 14.2875 | 7.9375
13164270 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0646 | 0646 | yes | 14.2875 | 7.9375
13164272 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0647 | 0647 | yes | 14.2875 | 7.9375
13164276 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0648 | 0648 | yes | 14.2875 | 7.9375
13164283 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0649 | 0649 | yes | 14.2875 | 7.9375
13164285 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2100 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0650 | 0650 | yes | 14.2875 | 7.9375
13164289 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2100 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0651 | 0651 | yes | 14.2875 | 7.9375
13164296 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2100 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0652 | 0652 | yes | 14.2875 | 7.9375
13164298 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0653 | 0653 | yes | 14.2875 | 7.9375
13164302 | -1.PP_SO-101 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-101 | 2150 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0654 | 0654 | yes | 14.2875 | 7.9375
13164467 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0655 | 0655 | yes | 17.4625 | 11.1125
13164469 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0656 | 0656 | yes | 17.4625 | 11.1125
13164473 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0657 | 0657 | yes | 17.4625 | 11.1125
13164478 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2150 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0658 | 0658 | yes | 17.4625 | 11.1125
13164480 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0659 | 0659 | yes | 17.4625 | 11.1125
13164484 | -1.PP_SO-101 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-101 | 2200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0660 | 0660 | yes | 17.4625 | 11.1125

# IfcPipeFitting: M_Přechod, obecný:Standardní (19)
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13075812 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2150 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.0258 | 0258 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625
13106579 | 1.NP_SO-101 | ø20 mm-ø16 mm | 1.NP_SO-101 | -3194.06 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0414 | 0414 | no | 22.225 | 3048 | no | yes | 11.1125 | 9.5875
13106581 | 1.NP_SO-101 | ø20 mm-ø16 mm | 1.NP_SO-101 | -3184.06 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0415 | 0415 | no | 22.225 | 3048 | no | yes | 11.1125 | 9.5875
13106924 | 1.NP_SO-101 | ø50 mm-ø20 mm | 1.NP_SO-101 | -939.687 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.0421 | 0421 | yes | 53.975 | 3048 | yes | no | 11.1125 | 26.9875
13106926 | -1.PP_SO-101 | ø20 mm-ø16 mm | -1.PP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.0422 | 0422 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125
13107140 | 4.NP_SO-101 | ø20 mm-ø16 mm | 4.NP_SO-101 | -84.0625 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0426 | 0426 | no | 22.225 | 3048 | no | yes | 11.1125 | 9.5875
13107150 | 2.NP_SO-101 | ø25 mm-ø16 mm | 2.NP_SO-101 | 7884.06 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.0427 | 0427 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875
13107156 | 4.NP_SO-101 | ø20 mm-ø16 mm | 4.NP_SO-101 | -100 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0430 | 0430 | no | 22.225 | 3048 | no | yes | 11.1125 | 9.5875
13107327 | 1.NP_SO-101 | ø25 mm-ø16 mm | 1.NP_SO-101 | -34.0625 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.0432 | 0432 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875
13137419 | 4.NP_SO-101 | ø20 mm-ø16 mm | 4.NP_SO-101 | 628.506 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.0505 | 0505 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125
13137440 | 4.NP_SO-101 | ø20 mm-ø16 mm | 4.NP_SO-101 | 618.506 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.0507 | 0507 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125
13140004 | -1.PP_SO-101 | ø32 mm-ø20 mm | -1.PP_SO-101 | 2200.63 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.0519 | 0519 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625
13140458 | 1.NP_SO-101 | ø32 mm-ø20 mm | 1.NP_SO-101 | -949.37 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.0521 | 0521 | yes | 34.925 | 3048 | no | yes | 17.4625 | 11.1125
13144191 | 1.NP_SO-101 | ø25 mm-ø16 mm | 1.NP_SO-101 | -44.0625 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.0541 | 0541 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875
13150654 | 1.NP_SO-101 | ø32 mm-ø20 mm | 1.NP_SO-101 | -900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.0558 | 0558 | yes | 34.925 | 3048 | no | yes | 17.4625 | 11.1125
13150869 | 4.NP_SO-101 | ø32 mm-ø16 mm | 4.NP_SO-101 | -125.937 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8.73125 | 8 | 16 | 16 | 32 | 32 | 16 | 0.0000051318 | 8 | 8 | 0.00121536 | ø32-ø16 | 7.67 | 13.97 | 19.175 | 34.925 | TT03.03.0562 | 0562 | yes | 34.925 | 3048 | no | yes | 17.4625 | 9.5875
13159705 | 2.NP_SO-101 | ø25 mm-ø16 mm | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 13.2409 | 12.5001 | 0.000851965 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0614 | 0614 | yes | 28.575 | 3048.74 | yes | no | 9.5875 | 14.2875
13160175 | 2.NP_SO-101 | ø20 mm-ø16 mm | 2.NP_SO-101 | 7928.51 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.0623 | 0623 |  | 22.225 | 3048 | yes | no | 9.5875 | 11.1125
13162993 | 3.NP_SO-101 | ø25 mm-ø16 mm | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 14.0297 | 12.5 | 0.000851809 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0636 | 0636 | yes | 28.575 | 3049.53 | yes | no | 9.5875 | 14.2875

# IfcPipeFitting: M_Přechod, obecný:Standardní (2)
In: 2.NP_SO-101
Type - Material: 0-255-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø15 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: -100 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 5.55625 mm; Jmenovitý poloměr 1: 10 mm; Jmenovitý poloměr 2: 7.5 mm; Jmenovitý průměr 1: 20 mm; Jmenovitý průměr 2: 15 mm; Maximální velikost: 20 mm; Minimální velikost: 15 mm; Objem: 0.00000157471 m3; Odskok – šířka: 10; Odskok – výška: 10; Plocha: 0.000554533 m2; Velikost: ø20-ø15; Velikost značky 1: 8.89 mm; Velikost značky 2: 6.35 mm; Vnější průměr tvarovky 1: 22.225 mm; Vnější průměr tvarovky 2: 15.875 mm
Jiné - Typ: Standardní; Páteřní trasa: yes; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Viditelnost 2: yes; Viditelnost 3: no; Výškové odsazení: 3048 mm; DN tvarovky 1 (sdílený): 20 mm; DN tvarovky 2 (sdílený): 15 mm; Max. vnější průměr tvarovky 12: 22.225 mm; Vnější poloměr tvarovky 2: 7.9375 mm; Vnější proloměr tvarovky 1: 11.1125 mm
Name (M_Přechod, obecný:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13104198 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | TT03.03.0413 | 0413
13152997 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | TT03.03.0574 | 0574

# IfcPipeFitting: M_Přechod, obecný:Standardní (4)
In: -1.PP_SO-101
Type - Material: 128-255-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Vazby - Podlaží: -1.PP_SO-101
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 10.3188 mm; Jmenovitý poloměr 1: 20 mm; Jmenovitý průměr 1: 40 mm; Maximální velikost: 40 mm; Odskok – šířka: 20; Odskok – výška: 20; Velikost značky 1: 16.51 mm; Vnější průměr tvarovky 1: 41.275 mm
Jiné - Typ: Standardní; Páteřní trasa: yes; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Viditelnost 2: yes; Viditelnost 3: no; Výškové odsazení: 3048 mm; DN tvarovky 1 (sdílený): 40 mm; Max. vnější průměr tvarovky 12: 41.275 mm; Vnější proloměr tvarovky 1: 20.6375 mm
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 2 (mm) = Minimální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 2 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Vnější poloměr tvarovky 2 (mm)
13112060 | ø40 mm-ø20 mm | 2250 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 10 | 20 | 0.00000836645 | 0.0017689 | ø40-ø20 | 8.89 | 22.225 | TT03.03.0456 | 0456 | 11.1125
13112062 | ø40 mm-ø15 mm | 2216.66 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 7.5 | 15 | 0.00000700483 | 0.00162635 | ø40-ø15 | 6.35 | 15.875 | TT03.03.0457 | 0457 | 7.9375
13112074 | ø40 mm-ø20 mm | 2250 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.00000836645 | 0.0017689 | ø40-ø20 | 8.89 | 22.225 | TT03.03.0458 | 0458 | 11.1125
13112076 | ø40 mm-ø15 mm | 2216.66 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000700483 | 0.00162635 | ø40-ø15 | 6.35 | 15.875 | TT03.03.0459 | 0459 | 7.9375

# IfcPipeFitting: M_Přechod, obecný:Standardní (35)
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13094541 | -1.PP_SO-101 | 0 | ø40 mm-ø32 mm | -1.PP_SO-101 | 2350 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.0387 | 0387 | yes | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13094583 | -1.PP_SO-101 | 0 | ø40 mm-ø32 mm | -1.PP_SO-101 | 2350 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.0389 | 0389 | yes | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13106665 | 2.NP_SO-101 | 0 | ø16 mm-ø15 mm | 2.NP_SO-101 | 3929.27 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.0416 | 0416 | no | 3048 | 19.175 | no | yes | 9.5875 | 7.9375
13106667 | 2.NP_SO-101 | 0 | ø16 mm-ø15 mm | 2.NP_SO-101 | 3919.27 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.0417 | 0417 | no | 3048 | 19.175 | no | yes | 9.5875 | 7.9375
13106712 | 2.NP_SO-101 | 0 | ø16 mm-ø15 mm | 2.NP_SO-101 | 3929.27 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.0418 | 0418 | no | 3048 | 19.175 | no | yes | 9.5875 | 7.9375
13106714 | 2.NP_SO-101 | 0 | ø16 mm-ø15 mm | 2.NP_SO-101 | 3919.27 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.0419 | 0419 | no | 3048 | 19.175 | no | yes | 9.5875 | 7.9375
13106920 | -1.PP_SO-101 | 0 | ø20 mm-ø16 mm | -1.PP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.0420 | 0420 | no | 3048 | 22.225 | yes | no | 9.5875 | 11.1125
13107130 | 2.NP_SO-101 | 0 | ø25 mm-ø22 mm | 2.NP_SO-101 | 7881.06 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.0423 | 0423 | no | 3048 | 28.575 | no | yes | 14.2875 | 12.5875
13107132 | 2.NP_SO-101 | 0 | ø22 mm-ø20 mm | 2.NP_SO-101 | 7900 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.0424 | 0424 | no | 3048 | 25.175 | yes | no | 11.1125 | 12.5875
13107138 | 4.NP_SO-101 | 0 | ø20 mm-ø16 mm | 4.NP_SO-101 | -100 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0425 | 0425 | no | 3048 | 22.225 | no | yes | 11.1125 | 9.5875
13107152 | 2.NP_SO-101 | 0 | ø20 mm-ø16 mm | 2.NP_SO-101 | 7900 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0428 | 0428 | no | 3048 | 22.225 | no | yes | 11.1125 | 9.5875
13107154 | 4.NP_SO-101 | 0 | ø20 mm-ø16 mm | 4.NP_SO-101 | -84.0625 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0429 | 0429 | no | 3048 | 22.225 | no | yes | 11.1125 | 9.5875
13109309 | 1.NP_SO-101 | 0 | ø50 mm-ø20 mm | 1.NP_SO-101 | -939.687 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.0442 | 0442 | yes | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13109311 | 1.NP_SO-101 | 0 | ø50 mm-ø40 mm | 1.NP_SO-101 | -860.313 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0443 | 0443 | yes | 3048 | 53.975 | yes | no | 20.6375 | 26.9875
13111664 | 2.NP_SO-101 | 0 | ø32 mm-ø16 mm | 2.NP_SO-101 | 7875.33 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8.73125 | 16 | 8 | 32 | 16 | 32 | 16 | 0.00000513014 | 16 | 0.00121536 | ø32-ø16 | 13.97 | 7.67 | 34.925 | 19.175 | TT03.03.0455 | 0455 | yes | 3048 | 34.925 | yes | no | 9.5875 | 17.4625
13112113 | 1.NP_SO-101 | 0 | ø40 mm-ø16 mm | 1.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 10.3188 | 20 | 8 | 40 | 16 | 40 | 16 | 0.00000768525 | 20 | 0.0016814 | ø40-ø16 | 16.51 | 7.67 | 41.275 | 19.175 | TT03.03.0460 | 0460 | yes | 3048 | 41.275 | yes | no | 9.5875 | 20.6375
13137645 | 2.NP_SO-101 | 0 | ø25 mm-ø16 mm | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 12.5 | 0.00085321 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0510 | 0510 | no | 3048 | 28.575 | yes | no | 9.5875 | 14.2875
13139149 | 2.NP_SO-101 | 40 | ø112 mm-ø100 mm | 2.NP_SO-101 | -4950 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.0513 | 0513 | yes | 3048 | 34.925 | no | yes | 17.4625 | 11.1125 | Izolace - Typ izolace: Tepelná
13139526 | 2.NP_SO-101 | 30 | ø92 mm-ø80 mm | 2.NP_SO-101 | -4949.38 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.0515 | 0515 | yes | 3048 | 34.925 | no | yes | 17.4625 | 11.1125 | Izolace - Typ izolace: Tepelná
13143827 | 3.NP_SO-101 | 0 | ø25 mm-ø16 mm | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 12.5 | 0.00085321 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0532 | 0532 | yes | 3048 | 28.575 | yes | no | 9.5875 | 14.2875
13144000 | 2.NP_SO-101 | 0 | ø25 mm-ø16 mm | 2.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 12.5 | 0.00085321 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0536 | 0536 | no | 3048 | 28.575 | yes | no | 9.5875 | 14.2875
13144152 | 3.NP_SO-101 | 0 | ø25 mm-ø16 mm | 3.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 12.5 | 0.00085321 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0539 | 0539 | yes | 3048 | 28.575 | yes | no | 9.5875 | 14.2875
13144580 | 2.NP_SO-101 | 0 | ø32 mm-ø25 mm | 2.NP_SO-101 | -1169.84 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT03.03.0547 | 0547 | yes | 3048 | 34.925 | yes | no | 14.2875 | 17.4625
13144594 | 2.NP_SO-101 | 0 | ø32 mm-ø25 mm | 2.NP_SO-101 | -1200 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT03.03.0548 | 0548 | yes | 3048 | 34.925 | yes | no | 14.2875 | 17.4625
13144629 | 1.NP_SO-101 | 0 | ø32 mm-ø25 mm | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT03.03.0550 | 0550 | yes | 3048 | 34.925 | yes | no | 14.2875 | 17.4625
13144636 | 1.NP_SO-101 | 0 | ø32 mm-ø25 mm | 1.NP_SO-101 | 2700 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT03.03.0551 | 0551 | yes | 3048 | 34.925 | yes | no | 14.2875 | 17.4625
13155039 | 1.NP_SO-101 | 0 | ø40 mm-ø25 mm | 1.NP_SO-101 | 19.0561 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT03.03.0577 | 0577 | yes | 3048 | 41.275 | yes | no | 14.2875 | 20.6375
13155908 | 1.NP_SO-101 | 0 | ø50 mm-ø40 mm | 1.NP_SO-101 | -821.419 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0578 | 0578 | yes | 3048 | 53.975 | yes | no | 20.6375 | 26.9875
13155910 | 2.NP_SO-101 | 0 | ø40 mm-ø25 mm | 2.NP_SO-101 | -3965.54 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT03.03.0579 | 0579 | yes | 3048 | 41.275 | yes | no | 14.2875 | 20.6375
13155959 | 1.NP_SO-101 | 0 | ø40 mm-ø16 mm | 1.NP_SO-101 | -60 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 8 | 40 | 16 | 40 | 16 | 0.00000768525 | 20 | 0.0016814 | ø40-ø16 | 16.51 | 7.67 | 41.275 | 19.175 | TT03.03.0582 | 0582 |  | 3048 | 41.275 | yes | no | 9.5875 | 20.6375
13159828 | 2.NP_SO-101 | 0 | ø25 mm-ø16 mm | 2.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 12.5 | 0.00085321 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0620 | 0620 | yes | 3048 | 28.575 | yes | no | 9.5875 | 14.2875
13162376 | 4.NP_SO-101 | 0 | ø20 mm-ø16 mm | 4.NP_SO-101 | -75.9375 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.0633 | 0633 |  | 3048 | 22.225 | no | yes | 11.1125 | 9.5875
13162450 | 2.NP_SO-101 | 0 | ø25 mm-ø20 mm | 2.NP_SO-101 | 3980.99 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.0634 | 0634 | yes | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13163204 | 3.NP_SO-101 | 0 | ø25 mm-ø16 mm | 3.NP_SO-101 | -50 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7.14375 | 12.5 | 8 | 25 | 16 | 25 | 16 | 0.00000322346 | 19.9736 | 0.000891739 | ø25-ø16 | 11.43 | 7.67 | 28.575 | 19.175 | TT03.03.0641 | 0641 | yes | 3055.47 | 28.575 | yes | no | 9.5875 | 14.2875
13163213 | 3.NP_SO-101 | 0 | ø25 mm-ø20 mm | 3.NP_SO-101 | -33.0125 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.0643 | 0643 | yes | 3048 | 28.575 | yes | no | 11.1125 | 14.2875

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:13162985
In: 3.NP_SO-101
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat); Group: HT_vratné vodní (45 °C) 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm-ø25 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 3.NP_SO-101; Výška od podlaží: -60 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_vratné vodní (45 °C); Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_vratné vodní (45 °C) 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 12.5 mm; Jmenovitý průměr: 25 mm; Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000441423 m3; Od středu ke konci: 26.9875 mm; Úhel: 89.9893 deg; Velikost: ø25-ø25-ø25; Velikost značky: 11.43 mm; Vnější průměr tvarovky: 28.575 mm
Identifikační data - Kód prvku: TT00.02.0635; Označení: 0635
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Páteřní trasa: yes; Štítek, od středu ke konci: 26.9875 mm; Úhel 1: 89.9893 deg; Úhel tvarovky 1 (sdílený): 89.9893 deg; Vnější poloměr tvarovky: 14.2875 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní (2)
In: 2.NP_SO-101
Type - Material: 0-255-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm-ø20 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Vazby - Podlaží: 2.NP_SO-101; Výška od podlaží: -100 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg; Jmenovitý poloměr: 10 mm; Jmenovitý průměr: 20 mm; Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000240538 m3; Od středu ke konci: 23.8125 mm; Velikost: ø20-ø20-ø20; Velikost značky: 8.89 mm; Vnější průměr tvarovky: 22.225 mm
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg; Páteřní trasa: yes; Štítek, od středu ke konci: 23.8125 mm; Vnější poloměr tvarovky: 11.1125 mm
Name (M_Spoj T, obecný:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13104190 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | TT00.02.0412 | 0412
13152989 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | TT00.02.0573 | 0573

# IfcPipeFitting: M_Spoj T, obecný:Standardní (265)
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
