Properties of the parts of a building model (IFC4), part 20 of 23

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (670)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
12951782 | 4.NP_SO-101 | 1124.17 | 0.000201032 | 0.0565069 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 172 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0174 | 0174 | no
12951792 | 4.NP_SO-101 | 479.084 | 0.000201032 | 0.0240814 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 173 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0175 | 0175 | no
12951861 | 4.NP_SO-101 | 1984.95 | 0.000201032 | 0.0997747 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 161 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0176 | 0176 | no
12951886 | 4.NP_SO-101 | 280.621 | 0.000201032 | 0.0141055 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 175 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0177 | 0177 | no
12951893 | 4.NP_SO-101 | 1892.23 | 0.000201032 | 0.095114 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 168 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0178 | 0178 | no
12951927 | 4.NP_SO-101 | 8610.05 | 0.000201032 | 0.432788 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 170 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0179 | 0179 | no
12951933 | 4.NP_SO-101 | 4567.45 | 0.000201032 | 0.229585 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 169 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0180 | 0180 | no
12951952 | 4.NP_SO-101 | 1831.78 | 0.000201032 | 0.0920751 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 173 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0181 | 0181 | no
12951962 | 4.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 106 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0182 | 0182 | no
12952006 | 4.NP_SO-101 | 3516.17 | 0.000201032 | 0.176742 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 106 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0183 | 0183 | no
12952014 | 4.NP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 105 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0184 | 0184 | no
12952023 | 4.NP_SO-101 | 850.982 | 0.000201032 | 0.042775 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 171 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0185 | 0185 | no
12952026 | 4.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 104 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0186 | 0186 | no
12952049 | 4.NP_SO-101 | 6861.78 | 0.000201032 | 0.34491 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 104 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0187 | 0187 | no
12953529 | -1.PP_SO-101 | 882.878 | 0.000201032 | 0.0443783 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 245 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0188 | 0188 | no
12953728 | 3.NP_SO-101 | 2364.06 | 0.000201032 | 0.118831 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 223 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0189 | 0189 | no
12953738 | 3.NP_SO-101 | 3150.39 | 0.000201032 | 0.158356 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 31 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0190 | 0190 | no
12953761 | 3.NP_SO-101 | 358.125 | 0.000201032 | 0.0180013 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 223 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0191 | 0191 | no
12953772 | 3.NP_SO-101 | 469.188 | 0.000201032 | 0.0235839 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 223 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0192 | 0192 | no
12955245 | 3.NP_SO-101 | 428.125 | 0.000201032 | 0.0215199 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 30 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0194 | 0194 | no
12955259 | 3.NP_SO-101 | 601.993 | 0.000201032 | 0.0302595 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 30 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0195 | 0195 | no
12955390 | 3.NP_SO-101 | 1772.14 | 0.000201032 | 0.0890775 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 152 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0196 | 0196 | no
12956515 | 4.NP_SO-101 | 4562.84 | 0.000201032 | 0.229353 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 35 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0197 | 0197 | no
12956581 | 4.NP_SO-101 | 10252.1 | 0.000201032 | 0.515327 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 41 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0198 | 0198 | no
12956594 | 4.NP_SO-101 | 343.997 | 0.000201032 | 0.0172912 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 281 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0199 | 0199 | no
12956598 | 4.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 40 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0200 | 0200 | no
12956683 | 4.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 39 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0201 | 0201 | no
12956700 | 4.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 57 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0202 | 0202 | no
12956743 | 4.NP_SO-101 | 2338.75 | 0.000201032 | 0.117558 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 57 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0203 | 0203 | no
12956747 | 4.NP_SO-101 | 2808.21 | 0.000201032 | 0.141156 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 38 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0204 | 0204 | no
12956796 | 4.NP_SO-101 | 440.057 | 0.000201032 | 0.0221197 | ø16 mm | 0.000862069 | HD | 658 | 650 | 650 | 4.NP_SO-101 | 0 | 642 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 12644.2 | 16 | 35 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0205 | 0205 | no
12956891 | 4.NP_SO-101 | 1968.13 | 0.000201032 | 0.0989288 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 163 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0206 | 0206 | no
12956905 | 4.NP_SO-101 | 388.125 | 0.000201032 | 0.0195093 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 163 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0207 | 0207 | no
12956915 | 4.NP_SO-101 | 2004.98 | 0.000201032 | 0.100781 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 37 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0208 | 0208 | no
12957036 | 4.NP_SO-101 | 168.125 | 0.000201032 | 0.00845088 | ø16 mm | 0.000862069 | HD | 134.063 | 134.063 | -34.0625 | 4.NP_SO-101 |  | -34.0625 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11965.9 | 16 | 163 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0209 | 0209 | no
12957046 | 4.NP_SO-101 | 404.063 | 0.000201032 | 0.0203104 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 37 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0210 | 0210 | no
12957063 | 4.NP_SO-101 | 397.712 | 0.000201032 | 0.0199912 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 165 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0211 | 0211 | no
12957074 | 4.NP_SO-101 | 2035.42 | 0.000201032 | 0.102312 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 164 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0212 | 0212 | no
12957078 | 4.NP_SO-101 | 397.712 | 0.000201032 | 0.0199912 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 166 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0213 | 0213 | no
12957085 | 4.NP_SO-101 | 838.566 | 0.000201032 | 0.0421509 | ø16 mm | 0.000862069 | HD | 158 | 150 | 150 | 4.NP_SO-101 | 0 | 142 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 12144.2 | 16 | 163 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0214 | 0214 | no
12957089 | 4.NP_SO-101 | 408.799 | 0.000201032 | 0.0205485 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 167 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0215 | 0215 | no
12957098 | 4.NP_SO-101 | 758.342 | 0.000201032 | 0.0381184 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 162 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0216 | 0216 | no
12957160 | 3.NP_SO-101 | 4296.26 | 0.000201032 | 0.215953 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 142 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0217 | 0217 | no
12957267 | 3.NP_SO-101 | 3335.43 | 0.000201032 | 0.167657 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 6 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0218 | 0218 | no
12957315 | 3.NP_SO-101 | 1637.56 | 0.000201032 | 0.0823126 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 47 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0219 | 0219 | no
12957382 | 3.NP_SO-101 | 4337.52 | 0.000201032 | 0.218027 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 144 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0220 | 0220 | no
12957392 | 3.NP_SO-101 | 2710.79 | 0.000201032 | 0.136259 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 150 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0221 | 0221 | no
12957415 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 33 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0222 | 0222 | no
12957551 | 3.NP_SO-101 | 230.579 | 0.000201032 | 0.0115901 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 31 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0223 | 0223 | no
12957596 | 3.NP_SO-101 | 1902.45 | 0.000201032 | 0.0956274 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 168 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0224 | 0224 | no
12957664 | 3.NP_SO-101 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 147 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0225 | 0225 | no
12958370 | 2.NP_SO-101 | 4282.97 | 0.000201032 | 0.215286 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 115 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0226 | 0226 | no
12958582 | 2.NP_SO-101 | 10780.6 | 0.000201032 | 0.541891 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 27 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0227 | 0227 | no
12958588 | 2.NP_SO-101 | 3206.4 | 0.000201032 | 0.161171 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 155 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0228 | 0228 | no
12958596 | 2.NP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 159 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0229 | 0229 | no
12958687 | 2.NP_SO-101 | 1493.99 | 0.000201032 | 0.0750962 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 158 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0230 | 0230 | no
12958693 | 2.NP_SO-101 | 2385.58 | 0.000201032 | 0.119912 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 159 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0231 | 0231 | no
12958701 | 2.NP_SO-101 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 158 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0232 | 0232 | no
12958856 | 1.NP_SO-101 | 1060.88 | 0.000201032 | 0.0533254 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 90 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0233 | 0233 | no
12958897 | 1.NP_SO-101 | 2023.07 | 0.000201032 | 0.101691 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 91 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0234 | 0234 | no
12958914 | 1.NP_SO-101 | 4677.71 | 0.000201032 | 0.235127 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 108 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0235 | 0235 | no
12958918 | 1.NP_SO-101 | 4155.43 | 0.000201032 | 0.208874 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 192 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0236 | 0236 | no
12959019 | 1.NP_SO-101 | 4152.43 | 0.000201032 | 0.208724 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 123 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0237 | 0237 | no
12959084 | 1.NP_SO-101 | 2923.8 | 0.000201032 | 0.146966 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 118 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0238 | 0238 | no
12959090 | 1.NP_SO-101 | 3257.74 | 0.000201032 | 0.163752 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 122 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0239 | 0239 | no
12959137 | 1.NP_SO-101 | 561.544 | 0.000201032 | 0.0282263 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 110 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0240 | 0240 | no
12959146 | 1.NP_SO-101 | 4665 | 0.000201032 | 0.234489 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 110 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0241 | 0241 | no
12959157 | 1.NP_SO-101 | 5506.28 | 0.000201032 | 0.276776 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 117 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0242 | 0242 | no
12959209 | -1.PP_SO-101 | 3169.95 | 0.000201032 | 0.159339 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 238 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0243 | 0243 | no
12959233 | -1.PP_SO-101 | 461.775 | 0.000201032 | 0.0232113 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 285 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0244 | 0244 | no
12959239 | -1.PP_SO-101 | 885.713 | 0.000201032 | 0.0445208 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 243 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0245 | 0245 | no
12959254 | -1.PP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 25 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0246 | 0246 | no
12959348 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 79 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0247 | 0247 | no
12959361 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 80 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0248 | 0248 | no
12959374 | -1.PP_SO-101 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 81 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0249 | 0249 | no
12959396 | -1.PP_SO-101 | 2431.57 | 0.000201032 | 0.122224 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 75 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0250 | 0250 | no
12959407 | -1.PP_SO-101 | 1490.8 | 0.000201032 | 0.0749358 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 78 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0251 | 0251 | no
12959411 | -1.PP_SO-101 | 3485.43 | 0.000201032 | 0.175197 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 77 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0252 | 0252 | no
12959415 | -1.PP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 76 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0253 | 0253 | no
12959645 | -1.PP_SO-101 | 4693.36 | 0.000201032 | 0.235914 | ø16 mm | 0.000862069 | HD | -42.3954 | -50.2632 | -899.737 | -1.PP_SO-101 | 18.4034 | -907.605 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.44 | 16 | 75 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0254 | 0254 | no
12960067 | -1.PP_SO-101 | 1929.46 | 0.000201032 | 0.0969852 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 75 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0255 | 0255 | no
12960109 | -1.PP_SO-101 | 4235.43 | 0.000201032 | 0.212896 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 2 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0256 | 0256 | no
12960130 | -1.PP_SO-101 | 4190.54 | 0.000201032 | 0.210639 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 66 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0257 | 0257 | no
12960325 | -1.PP_SO-101 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 26 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0258 | 0258 | no
12960334 | -1.PP_SO-101 | 1468.13 | 0.000201032 | 0.073796 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 26 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0259 | 0259 | no
12960344 | -1.PP_SO-101 | 3125.63 | 0.000201032 | 0.157111 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 26 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0260 | 0260 | no
12960355 | -1.PP_SO-101 | 1965.15 | 0.000201032 | 0.0987792 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -4055.8 | 16 | 25 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0261 | 0261 | no
12960360 | -1.PP_SO-101 | 1476.07 | 0.000201032 | 0.0741952 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 93 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0262 | 0262 | no
12960422 | -1.PP_SO-101 | 818.125 | 0.000201032 | 0.0411234 | ø16 mm | 0.000862069 | HD | -65.9375 | -884.063 | -65.9375 | -1.PP_SO-101 |  | -884.063 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4034.06 | 16 | 93 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0263 | 0263 | no
12960442 | -1.PP_SO-101 | 2268.13 | 0.000201032 | 0.114008 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 94 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0264 | 0264 | no
12960454 | -1.PP_SO-101 | 2824.99 | 0.000201032 | 0.141999 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 94 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0265 | 0265 | no
12960462 | -1.PP_SO-101 | 5424.06 | 0.000201032 | 0.272643 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 94 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0266 | 0266 | no
12960480 | -1.PP_SO-101 | 177.713 | 0.000201032 | 0.0089328 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 95 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0267 | 0267 | no
12960489 | -1.PP_SO-101 | 8908.81 | 0.000201032 | 0.447806 | ø16 mm | 0.000862069 | HD | -892 | -900 | -900 | -1.PP_SO-101 | 0 | -908 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -4055.8 | 16 | 94 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0268 | 0268 | no
12960528 | -1.PP_SO-101 | 4517.94 | 0.000201032 | 0.227097 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 245 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0269 | 0269 | no
12963829 | -1.PP_SO-101 | 5309.29 | 0.000201032 | 0.266874 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 29 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0277 | 0277 | no
12964883 | -1.PP_SO-101 | 138.201 | 0.000201032 | 0.00694676 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 183 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0282 | 0282 | no
12965019 | -1.PP_SO-101 | 1115.25 | 0.000201032 | 0.0560586 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 183 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0284 | 0284 | no
12965076 | -1.PP_SO-101 | 1664.01 | 0.000201032 | 0.0836421 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -3205.8 | 16 | 65 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0285 | 0285 | no
12965617 | 1.NP_SO-101 | 1178.9 | 0.000201032 | 0.0592579 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 266 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0287 | 0287 | no
12967560 | 2.NP_SO-101 | 561.906 | 0.000201032 | 0.0282445 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 10 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0288 | 0288 | no
12967904 | 2.NP_SO-101 | 2362.2 | 0.000201032 | 0.118737 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 13 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0289 | 0289 | no
12969188 | 4.NP_SO-101 | 177.436 | 0.000201032 | 0.00891891 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 307 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0291 | 0291 | no
12969197 | 4.NP_SO-101 | 2224.1 | 0.000201032 | 0.111796 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 307 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0292 | 0292 | no
12969253 | 3.NP_SO-101 | 2968.57 | 0.000201032 | 0.149217 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 168 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0293 | 0293 | no
12969379 | 1.NP_SO-101 | 4778.95 | 0.000201032 | 0.240216 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 131 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0295 | 0295 | no
12969508 | 2.NP_SO-101 | 5539.77 | 0.000201032 | 0.278459 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 21 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0297 | 0297 | no
12969535 | 3.NP_SO-101 | 1075.7 | 0.000201032 | 0.0540703 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 142 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0298 | 0298 | no
12969576 | 3.NP_SO-101 | 955.788 | 0.000201032 | 0.0480432 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 7944.2 | 16 | 45 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0299 | 0299 | no
12970047 | 4.NP_SO-101 | 3888.13 | 0.000201032 | 0.195438 | ø16 mm | 0.000862069 | HD | -92 | -100 | -100 | 4.NP_SO-101 | 0 | -108 | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 11894.2 | 16 | 187 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0301 | 0301 | no
12970060 | 4.NP_SO-101 | 4771.92 | 0.000201032 | 0.239863 | ø16 mm | 0.000862069 | HD | -92 | -100 | -100 | 4.NP_SO-101 | 0 | -108 | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 11894.2 | 16 | 187 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0302 | 0302 | no
12970071 | 4.NP_SO-101 | 8295.99 | 0.000201032 | 0.417002 | ø16 mm | 0.000862069 | HD | -92 | -100 | -100 | 4.NP_SO-101 | 0 | -108 | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 11894.2 | 16 | 187 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0303 | 0303 | no
13054124 | -1.PP_SO-101 | 9517.96 | 0.000201032 | 0.478425 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | -1.PP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -3205.8 | 16 | 252 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0310 | 0310 | no
13054268 | -1.PP_SO-101 | 2081.21 | 0.000201032 | 0.104613 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 2 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0311 | 0311 | no
13054290 | -1.PP_SO-101 | 12077.7 | 0.000201032 | 0.607092 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 3 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0312 | 0312 | no
13054394 | -1.PP_SO-101 | 7914.77 | 0.000201032 | 0.39784 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 205 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0313 | 0313 | no
13054405 | -1.PP_SO-101 | 2859.16 | 0.000201032 | 0.143717 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 222 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0314 | 0314 | no
13054416 | -1.PP_SO-101 | 400 | 0.000201032 | 0.0201062 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 222 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0315 | 0315 | no
13054674 | -1.PP_SO-101 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 10 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0316 | 0316 | no
13054697 | -1.PP_SO-101 | 7470.19 | 0.000201032 | 0.375493 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 219 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0317 | 0317 | no
13054726 | -1.PP_SO-101 | 77.7125 | 0.000201032 | 0.00390626 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -3215.8 | 16 | 1 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0318 | 0318 | no
13054737 | -1.PP_SO-101 | 220.227 | 0.000201032 | 0.0110698 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -3215.8 | 16 | 3 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0319 | 0319 | no
13054748 | -1.PP_SO-101 | 641.017 | 0.000201032 | 0.032221 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 11 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0320 | 0320 | no
13054792 | -1.PP_SO-101 | 156.775 | 0.000201032 | 0.00788036 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -3215.8 | 16 | 3 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0321 | 0321 | no
13054830 | -1.PP_SO-101 | 156.892 | 0.000201032 | 0.00788627 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -3215.8 | 16 | 2 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0322 | 0322 | no
13054866 | -1.PP_SO-101 | 4169.27 | 0.000201032 | 0.20957 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -3215.8 | 16 | 2 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0323 | 0323 | no
13054920 | -1.PP_SO-101 | 284.86 | 0.000201032 | 0.0143186 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -3215.8 | 16 | 5 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0324 | 0324 | no
13054938 | -1.PP_SO-101 | 722.647 | 0.000201032 | 0.0363242 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 2 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0325 | 0325 | no
13054982 | -1.PP_SO-101 | 331.694 | 0.000201032 | 0.0166727 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 12 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0326 | 0326 | no
13055148 | -1.PP_SO-101 | 77.7125 | 0.000201032 | 0.00390626 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 8 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0327 | 0327 | no
13055186 | -1.PP_SO-101 | 299.831 | 0.000201032 | 0.0150711 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 9 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0328 | 0328 | no
13055205 | -1.PP_SO-101 | 2469.83 | 0.000201032 | 0.124147 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 1 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0329 | 0329 | no
13055249 | -1.PP_SO-101 | 3373.15 | 0.000201032 | 0.169553 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 12 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0330 | 0330 | no
13055257 | -1.PP_SO-101 | 661.775 | 0.000201032 | 0.0332644 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 13 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0331 | 0331 | no
13055293 | -1.PP_SO-101 | 5324.06 | 0.000201032 | 0.267617 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 15 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0332 | 0332 | no
13055304 | -1.PP_SO-101 | 2900.53 | 0.000201032 | 0.145796 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 15 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0333 | 0333 | no
13055315 | -1.PP_SO-101 | 2268.13 | 0.000201032 | 0.114008 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 15 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0334 | 0334 | no
13055337 | -1.PP_SO-101 | 277.712 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 16 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0335 | 0335 | no
13055480 | -1.PP_SO-101 | 126.251 | 0.000201032 | 0.00634608 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4065.8 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0336 | 0336 | no
13055544 | -1.PP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 17 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0337 | 0337 | no
13055555 | -1.PP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 18 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0338 | 0338 | no
13055566 | -1.PP_SO-101 | 157.713 | 0.000201032 | 0.00792749 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 5 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0339 | 0339 | no
13055635 | -1.PP_SO-101 | 1576.07 | 0.000201032 | 0.0792217 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0340 | 0340 | no
13055796 | -1.PP_SO-101 | 2233.55 | 0.000201032 | 0.11227 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 21 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0341 | 0341 | no
13055806 | -1.PP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 4 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0342 | 0342 | no
13056019 | -1.PP_SO-101 | 818.125 | 0.000201032 | 0.0411234 | ø16 mm | 0.000862069 | HD | -75.9375 | -894.063 | -75.9375 | -1.PP_SO-101 |  | -894.063 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4044.06 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0343 | 0343 | no
13056408 | -1.PP_SO-101 | 3342.9 | 0.000201032 | 0.168033 | ø16 mm | 0.000862069 | HD | -352 | -360 | -360 | -1.PP_SO-101 | 0 | -368 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3515.8 | 16 | 216 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0344 | 0344 | no
13056419 | -1.PP_SO-101 | 1484.06 | 0.000201032 | 0.0745971 | ø16 mm | 0.000862069 | HD | -352 | -360 | -360 | -1.PP_SO-101 | 0 | -368 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3515.8 | 16 | 216 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0345 | 0345 | no
13056526 | -1.PP_SO-101 | 561.775 | 0.000201032 | 0.0282379 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 255 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0346 | 0346 | no
13056545 | -1.PP_SO-101 | 3169.95 | 0.000201032 | 0.159339 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 205 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0347 | 0347 | no
13056615 | -1.PP_SO-101 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 8 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0348 | 0348 | no
13056626 | -1.PP_SO-101 | 1965.15 | 0.000201032 | 0.0987792 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 8 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0349 | 0349 | no
13056659 | -1.PP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 1 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0350 | 0350 | no
13056670 | -1.PP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 4 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0351 | 0351 | no
13056700 | -1.PP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 6 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0352 | 0352 | no
13056733 | -1.PP_SO-101 | 7104.73 | 0.000201032 | 0.357123 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 10 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0353 | 0353 | no
13056898 | -1.PP_SO-101 | 3485.43 | 0.000201032 | 0.175197 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 3 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0354 | 0354 | no
13056949 | -1.PP_SO-101 | 2331.57 | 0.000201032 | 0.117198 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 7 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0355 | 0355 | no
13056959 | -1.PP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 5 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0356 | 0356 | no
13056992 | -1.PP_SO-101 | 3125.63 | 0.000201032 | 0.157111 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 9 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0357 | 0357 | no
13057003 | -1.PP_SO-101 | 1268.13 | 0.000201032 | 0.0637429 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 9 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0358 | 0358 | no
13057014 | -1.PP_SO-101 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 9 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0359 | 0359 | no
13057082 | -1.PP_SO-101 | 1490.8 | 0.000201032 | 0.0749358 | ø16 mm | 0.000862069 | HD | -902 | -910 | -910 | -1.PP_SO-101 | 0 | -918 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.8 | 16 | 2 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0360 | 0360 | no
13057238 | -1.PP_SO-101 | 4693.36 | 0.000201032 | 0.235914 | ø16 mm | 0.000862069 | HD | -52.3954 | -60.2632 | -909.737 | -1.PP_SO-101 | 18.4034 | -917.605 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -4065.44 | 16 | 7 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0361 | 0361 | no
13057898 | -1.PP_SO-101 | 3881.43 | 0.000201032 | 0.195102 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 13 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0362 | 0362 | no
13057909 | -1.PP_SO-101 | 2002.59 | 0.000201032 | 0.100661 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0363 | 0363 | no
13057920 | -1.PP_SO-101 | 524.063 | 0.000201032 | 0.0263423 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0364 | 0364 | no
13057953 | -1.PP_SO-101 | 1307.52 | 0.000201032 | 0.0657229 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 210 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0365 | 0365 | no
13057979 | -1.PP_SO-101 | 1829.46 | 0.000201032 | 0.0919586 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 7 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0366 | 0366 | no
13057982 | -1.PP_SO-101 | 77.7125 | 0.000201032 | 0.00390626 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 11 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0367 | 0367 | no
13058052 | -1.PP_SO-101 | 4235.43 | 0.000201032 | 0.212896 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 15 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0368 | 0368 | no
13058086 | -1.PP_SO-101 | 4112.83 | 0.000201032 | 0.206733 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 3 | -3215.8 | 16 | 3 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0369 | 0369 | no
13058139 | -1.PP_SO-101 | 5209.29 | 0.000201032 | 0.261848 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 20 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0370 | 0370 | no
13064481 | 1.NP_SO-101 | 3471.82 | 0.000201032 | 0.174513 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 149 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0375 | 0375 | no
13064492 | 1.NP_SO-101 | 3487.21 | 0.000201032 | 0.175286 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 148 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0376 | 0376 | no
13064503 | 1.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 147 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0377 | 0377 | no
13064591 | 1.NP_SO-101 | 7562.76 | 0.000201032 | 0.380146 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 154 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0378 | 0378 | no
13064602 | 1.NP_SO-101 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 150 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0379 | 0379 | no
13064613 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 151 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0380 | 0380 | no
13064624 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 152 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0381 | 0381 | no
13064635 | 1.NP_SO-101 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 153 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0382 | 0382 | no
13064646 | 1.NP_SO-101 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 154 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0383 | 0383 | no
13064657 | 1.NP_SO-101 | 1628.01 | 0.000201032 | 0.0818328 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 139 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0384 | 0384 | no
13064830 | 1.NP_SO-101 | 3419.09 | 0.000201032 | 0.171862 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 150 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0385 | 0385 | no
13065105 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 155 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0386 | 0386 | no
13065163 | 1.NP_SO-101 | 4343.09 | 0.000201032 | 0.218308 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 154 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0387 | 0387 | no
13065191 | 1.NP_SO-101 | 3391.26 | 0.000201032 | 0.170463 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 153 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0388 | 0388 | no
13065193 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 156 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0389 | 0389 | no
13065241 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 157 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0390 | 0390 | no
13065331 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 158 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0391 | 0391 | no
13065357 | 1.NP_SO-101 | 3463.17 | 0.000201032 | 0.174078 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 152 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0392 | 0392 | no
13065424 | 1.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 151 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0393 | 0393 | no
13065440 | 1.NP_SO-101 | 3124.99 | 0.000201032 | 0.157079 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 148 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0394 | 0394 | no
13065473 | 1.NP_SO-101 | 1609.02 | 0.000201032 | 0.0808782 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 147 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0395 | 0395 | no
13065484 | 1.NP_SO-101 | 1588.79 | 0.000201032 | 0.0798613 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 146 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0396 | 0396 | no
13065517 | 1.NP_SO-101 | 3170.36 | 0.000201032 | 0.15936 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 149 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0397 | 0397 | no
13065629 | 1.NP_SO-101 | 3315.17 | 0.000201032 | 0.166638 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 141 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0398 | 0398 | no
13065686 | 1.NP_SO-101 | 6011.15 | 0.000201032 | 0.302153 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 142 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0399 | 0399 | no
13065713 | 1.NP_SO-101 | 3305.42 | 0.000201032 | 0.166149 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 140 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0400 | 0400 | no
13065738 | 1.NP_SO-101 | 2371.78 | 0.000201032 | 0.119218 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 145 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0401 | 0401 | no
13065749 | 1.NP_SO-101 | 364.063 | 0.000201032 | 0.0182998 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 145 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0402 | 0402 | no
13065777 | 1.NP_SO-101 | 160 | 0.000201032 | 0.00804248 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 144 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0403 | 0403 | no
13065840 | 1.NP_SO-101 | 62.7408 | 0.000201032 | 0.0031537 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 196 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0404 | 0404 | no
13065846 | 1.NP_SO-101 | 2592.68 | 0.000201032 | 0.130323 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | -55.8 | 16 | 195 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0405 | 0405 | no
13065867 | 1.NP_SO-101 | 2392.68 | 0.000201032 | 0.120269 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 143 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0406 | 0406 | no
13065904 | 1.NP_SO-101 | 7743.24 | 0.000201032 | 0.389218 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 133 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0407 | 0407 | no
13065926 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 136 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0408 | 0408 | no
13065937 | 1.NP_SO-101 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 135 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0409 | 0409 | no
13065948 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 137 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0410 | 0410 | no
13066061 | 1.NP_SO-101 | 2961.78 | 0.000201032 | 0.148875 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 135 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0411 | 0411 | no
13066071 | 1.NP_SO-101 | 688.142 | 0.000201032 | 0.0345898 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 133 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0412 | 0412 | no
13066171 | 1.NP_SO-101 | 2954.99 | 0.000201032 | 0.148534 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 134 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0413 | 0413 | no
13066258 | 1.NP_SO-101 | 5915.68 | 0.000201032 | 0.297355 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 28 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0414 | 0414 | no
13066269 | 1.NP_SO-101 | 584.063 | 0.000201032 | 0.0293582 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 28 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0415 | 0415 | no
13066283 | 1.NP_SO-101 | 2923.8 | 0.000201032 | 0.146966 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 133 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0416 | 0416 | no
13066345 | 1.NP_SO-101 | 3057.74 | 0.000201032 | 0.153699 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 138 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0417 | 0417 | no
13066351 | 1.NP_SO-101 | 4352.43 | 0.000201032 | 0.218777 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 139 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0418 | 0418 | no
13066386 | 1.NP_SO-101 | 384.062 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 12 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0419 | 0419 | no
13066397 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 135 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0420 | 0420 | no
13066408 | 1.NP_SO-101 | 377.712 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 14 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0421 | 0421 | no
