Properties of the parts of a building model (IFC4), part 21 of 23

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (670)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
13066419 | 1.NP_SO-101 | 384.062 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 132 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0422 | 0422 | no
13066541 | 1.NP_SO-101 | 4577.71 | 0.000201032 | 0.230101 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 136 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0423 | 0423 | no
13066699 | 1.NP_SO-101 | 4372.08 | 0.000201032 | 0.219765 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 12 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0424 | 0424 | no
13066714 | 1.NP_SO-101 | 1360.87 | 0.000201032 | 0.068405 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 132 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0425 | 0425 | no
13066724 | 1.NP_SO-101 | 2973.28 | 0.000201032 | 0.149453 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 134 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0426 | 0426 | no
13067621 | 1.NP_SO-101 | 1723.07 | 0.000201032 | 0.0866111 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 133 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0427 | 0427 | no
13067632 | 1.NP_SO-101 | 5557.68 | 0.000201032 | 0.279359 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 143 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0428 | 0428 | no
13067690 | 1.NP_SO-101 | 1274.77 | 0.000201032 | 0.0640771 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 263 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0429 | 0429 | no
13067694 | 1.NP_SO-101 | 2533.4 | 0.000201032 | 0.127343 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 137 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0430 | 0430 | no
13067698 | 1.NP_SO-101 | 4155.43 | 0.000201032 | 0.208874 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 144 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0431 | 0431 | no
13070064 | -1.PP_SO-101 | 253.671 | 0.000201032 | 0.0127509 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 210 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0437 | 0437 | no
13070124 | -1.PP_SO-101 | 1664.01 | 0.000201032 | 0.0836421 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | -3215.8 | 16 | 22 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0438 | 0438 | no
13076223 | -1.PP_SO-101 | 4767.91 | 0.000201032 | 0.239661 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 212 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0458 | 0458 | no
13076244 | -1.PP_SO-101 | 1032.88 | 0.000201032 | 0.0519181 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 212 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0459 | 0459 | no
13076355 | -1.PP_SO-101 | 1035.71 | 0.000201032 | 0.0520606 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | -1.PP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3215.8 | 16 | 210 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0460 | 0460 | no
13076445 | 1.NP_SO-101 | 3474.31 | 0.000201032 | 0.174638 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 1.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | -55.8 | 16 | 97 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0461 | 0461 | no
13076531 | 1.NP_SO-101 | 3242.35 | 0.000201032 | 0.162978 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -65.8 | 16 | 137 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0462 | 0462 | no
13077863 | 2.NP_SO-101 | 405.172 | 0.000201032 | 0.0203662 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 3944.2 | 16 | 285 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0467 | 0467 | no
13078038 | 3.NP_SO-101 | 650.681 | 0.000201032 | 0.0327068 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 292 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0468 | 0468 | no
13078287 | 2.NP_SO-101 | 634.062 | 0.000201032 | 0.0318715 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 57 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0470 | 0470 | no
13078298 | 2.NP_SO-101 | 634.062 | 0.000201032 | 0.0318715 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 56 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0471 | 0471 | no
13078309 | 2.NP_SO-101 | 6999.92 | 0.000201032 | 0.351854 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 55 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0472 | 0472 | no
13078344 | 2.NP_SO-101 | 305.425 | 0.000201032 | 0.0153523 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 59 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0473 | 0473 | no
13078355 | 2.NP_SO-101 | 305.425 | 0.000201032 | 0.0153523 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 61 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0474 | 0474 | no
13078366 | 2.NP_SO-101 | 305.425 | 0.000201032 | 0.0153523 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 60 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0475 | 0475 | no
13078377 | 2.NP_SO-101 | 2418.94 | 0.000201032 | 0.121589 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 58 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0476 | 0476 | no
13078410 | 2.NP_SO-101 | 1452.23 | 0.000201032 | 0.0729972 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 54 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0477 | 0477 | no
13078425 | 2.NP_SO-101 | 7557.23 | 0.000201032 | 0.379868 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 55 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0478 | 0478 | no
13078480 | 2.NP_SO-101 | 3463.17 | 0.000201032 | 0.174078 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 53 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0479 | 0479 | no
13078598 | 2.NP_SO-101 | 1493.99 | 0.000201032 | 0.0750962 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 56 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0480 | 0480 | no
13078604 | 2.NP_SO-101 | 2385.58 | 0.000201032 | 0.119912 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 57 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0481 | 0481 | no
13078696 | 2.NP_SO-101 | 3534.06 | 0.000201032 | 0.177641 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 51 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0482 | 0482 | no
13078707 | 2.NP_SO-101 | 1368.13 | 0.000201032 | 0.0687695 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 51 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0483 | 0483 | no
13078718 | 2.NP_SO-101 | 1588.85 | 0.000201032 | 0.0798643 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 51 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0484 | 0484 | no
13078742 | 2.NP_SO-101 | 462.944 | 0.000201032 | 0.0232701 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 44 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0485 | 0485 | no
13078764 | 2.NP_SO-101 | 1788.18 | 0.000201032 | 0.0898837 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 50 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0486 | 0486 | no
13078775 | 2.NP_SO-101 | 1788.18 | 0.000201032 | 0.0898837 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 49 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0487 | 0487 | no
13078853 | 2.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 52 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0488 | 0488 | no
13078908 | 2.NP_SO-101 | 4089.05 | 0.000201032 | 0.205538 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 37 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0489 | 0489 | no
13078988 | 2.NP_SO-101 | 3206.4 | 0.000201032 | 0.161171 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 38 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0490 | 0490 | no
13078994 | 2.NP_SO-101 | 10480.6 | 0.000201032 | 0.526811 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 41 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0491 | 0491 | no
13079164 | 2.NP_SO-101 | 5955.42 | 0.000201032 | 0.299352 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 46 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0492 | 0492 | no
13079253 | 2.NP_SO-101 | 2919.47 | 0.000201032 | 0.146748 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 42 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0493 | 0493 | no
13079738 | 2.NP_SO-101 | 312.944 | 0.000201032 | 0.0157303 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 199 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0494 | 0494 | no
13079782 | 2.NP_SO-101 | 1638.18 | 0.000201032 | 0.0823438 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 201 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0495 | 0495 | no
13079788 | 2.NP_SO-101 | 1838.23 | 0.000201032 | 0.0923995 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 199 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0496 | 0496 | no
13079805 | 2.NP_SO-101 | 1788.18 | 0.000201032 | 0.0898837 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 43 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0497 | 0497 | no
13079811 | 2.NP_SO-101 | 1538.23 | 0.000201032 | 0.0773199 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 44 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0498 | 0498 | no
13079956 | 2.NP_SO-101 | 2919.47 | 0.000201032 | 0.146748 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 146 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0499 | 0499 | no
13079977 | 2.NP_SO-101 | 3076.38 | 0.000201032 | 0.154636 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 45 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0500 | 0500 | no
13080000 | 2.NP_SO-101 | 2201.78 | 0.000201032 | 0.110673 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 204 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0501 | 0501 | no
13080233 | 2.NP_SO-101 | 93.1677 | 0.000201032 | 0.00468312 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 198 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0502 | 0502 | no
13080260 | 2.NP_SO-101 | 2782.26 | 0.000201032 | 0.139852 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 205 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0503 | 0503 | no
13080292 | 2.NP_SO-101 | 364.063 | 0.000201032 | 0.0182998 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 204 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0504 | 0504 | no
13080320 | 2.NP_SO-101 | 2201.78 | 0.000201032 | 0.110673 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 48 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0505 | 0505 | no
13080331 | 2.NP_SO-101 | 514.062 | 0.000201032 | 0.0258396 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 48 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0506 | 0506 | no
13080422 | 2.NP_SO-101 | 243.168 | 0.000201032 | 0.0122229 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 32 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0507 | 0507 | no
13080445 | 2.NP_SO-101 | 2482.26 | 0.000201032 | 0.124772 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 47 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0508 | 0508 | no
13080463 | 2.NP_SO-101 | 1779.43 | 0.000201032 | 0.089444 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 39 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0509 | 0509 | no
13080474 | 2.NP_SO-101 | 634.063 | 0.000201032 | 0.0318715 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 40 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0510 | 0510 | no
13080485 | 2.NP_SO-101 | 4799.14 | 0.000201032 | 0.241231 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 40 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0511 | 0511 | no
13080596 | 2.NP_SO-101 | 6018.7 | 0.000201032 | 0.302533 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 38 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0512 | 0512 | no
13080633 | 2.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 167 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0513 | 0513 | no
13080644 | 2.NP_SO-101 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 166 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0514 | 0514 | no
13080655 | 2.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 172 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0515 | 0515 | no
13080666 | 2.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 171 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0516 | 0516 | no
13080677 | 2.NP_SO-101 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 170 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0517 | 0517 | no
13080690 | 2.NP_SO-101 | 4362.21 | 0.000201032 | 0.219269 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 166 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0518 | 0518 | no
13080759 | 2.NP_SO-101 | 4412.89 | 0.000201032 | 0.221816 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 170 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0519 | 0519 | no
13080816 | 2.NP_SO-101 | 2931.03 | 0.000201032 | 0.14733 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 169 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0520 | 0520 | no
13080952 | 2.NP_SO-101 | 861.906 | 0.000201032 | 0.0433241 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 165 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0521 | 0521 | no
13080962 | 2.NP_SO-101 | 2062.2 | 0.000201032 | 0.103657 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 168 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0522 | 0522 | no
13081088 | 2.NP_SO-101 | 354.063 | 0.000201032 | 0.0177971 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 176 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0523 | 0523 | no
13081099 | 2.NP_SO-101 | 10494.5 | 0.000201032 | 0.52751 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 161 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0524 | 0524 | no
13081110 | 2.NP_SO-101 | 347.713 | 0.000201032 | 0.0174779 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 178 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0525 | 0525 | no
13081121 | 2.NP_SO-101 | 347.713 | 0.000201032 | 0.0174779 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 177 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0526 | 0526 | no
13081132 | 2.NP_SO-101 | 347.713 | 0.000201032 | 0.0174779 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 179 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0527 | 0527 | no
13081143 | 2.NP_SO-101 | 347.713 | 0.000201032 | 0.0174779 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 180 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0528 | 0528 | no
13081260 | 2.NP_SO-101 | 3457.6 | 0.000201032 | 0.173798 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 176 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0529 | 0529 | no
13081264 | 2.NP_SO-101 | 3455.96 | 0.000201032 | 0.173716 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 175 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0530 | 0530 | no
13081268 | 2.NP_SO-101 | 3485.57 | 0.000201032 | 0.175204 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 174 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0531 | 0531 | no
13081306 | 2.NP_SO-101 | 3455.43 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 3934.2 | 16 | 173 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0532 | 0532 | no
13081579 | 2.NP_SO-101 | 1508.88 | 0.000201032 | 0.0758444 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 2.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3934.2 | 16 | 36 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0533 | 0533 | no
13081595 | 3.NP_SO-101 | 3461.78 | 0.000201032 | 0.174008 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 185 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0534 | 0534 | no
13081608 | 3.NP_SO-101 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 185 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0535 | 0535 | no
13081619 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 186 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0536 | 0536 | no
13081630 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 187 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0537 | 0537 | no
13081641 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 188 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0538 | 0538 | no
13081652 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 189 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0539 | 0539 | no
13081674 | 3.NP_SO-101 | 294.063 | 0.000201032 | 0.0147812 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 90 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0540 | 0540 | no
13081685 | 3.NP_SO-101 | 287.713 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 91 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0541 | 0541 | no
13081696 | 3.NP_SO-101 | 287.712 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 92 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0542 | 0542 | no
13081707 | 3.NP_SO-101 | 287.712 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 93 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0543 | 0543 | no
13081718 | 3.NP_SO-101 | 287.712 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 94 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0544 | 0544 | no
13081729 | 3.NP_SO-101 | 287.712 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 95 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0545 | 0545 | no
13081740 | 3.NP_SO-101 | 287.712 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 96 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0546 | 0546 | no
13081794 | 3.NP_SO-101 | 3131.78 | 0.000201032 | 0.15742 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 90 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0547 | 0547 | no
13081939 | 3.NP_SO-101 | 3785.42 | 0.000201032 | 0.190276 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 89 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0548 | 0548 | no
13081943 | 3.NP_SO-101 | 3451.53 | 0.000201032 | 0.173493 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 88 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0549 | 0549 | no
13081947 | 3.NP_SO-101 | 3534.18 | 0.000201032 | 0.177647 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 87 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0550 | 0550 | no
13081951 | 3.NP_SO-101 | 3535.43 | 0.000201032 | 0.17771 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 86 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0551 | 0551 | no
13081955 | 3.NP_SO-101 | 3335.43 | 0.000201032 | 0.167657 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 85 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0552 | 0552 | no
13081987 | 3.NP_SO-101 | 10409.9 | 0.000201032 | 0.523259 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 38 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0553 | 0553 | no
13082065 | 3.NP_SO-101 | 3455.42 | 0.000201032 | 0.173689 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 184 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0554 | 0554 | no
13082069 | 3.NP_SO-101 | 3488.23 | 0.000201032 | 0.175338 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 183 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0555 | 0555 | no
13082073 | 3.NP_SO-101 | 3447.92 | 0.000201032 | 0.173312 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 182 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0556 | 0556 | no
13082117 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 36 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0557 | 0557 | no
13082128 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 33 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0558 | 0558 | no
13082139 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 32 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0559 | 0559 | no
13082175 | 3.NP_SO-101 | 1752.45 | 0.000201032 | 0.0880876 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 35 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0560 | 0560 | no
13082216 | 3.NP_SO-101 | 627.713 | 0.000201032 | 0.0315523 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 17 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0561 | 0561 | no
13082238 | 3.NP_SO-101 | 601.993 | 0.000201032 | 0.0302595 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 224 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0562 | 0562 | no
13082309 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 196 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0563 | 0563 | no
13082321 | 3.NP_SO-101 | 4921.54 | 0.000201032 | 0.247384 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 193 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0564 | 0564 | no
13082406 | 3.NP_SO-101 | 2968.57 | 0.000201032 | 0.149217 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 35 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0565 | 0565 | no
13082414 | 3.NP_SO-101 | 2710.79 | 0.000201032 | 0.136259 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 192 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0566 | 0566 | no
13082439 | 3.NP_SO-101 | 2237.11 | 0.000201032 | 0.11245 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 191 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0567 | 0567 | no
13082465 | 3.NP_SO-101 | 4337.52 | 0.000201032 | 0.218027 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 195 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0568 | 0568 | no
13082518 | 3.NP_SO-101 | 1671.95 | 0.000201032 | 0.0840414 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 224 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0569 | 0569 | no
13082526 | 3.NP_SO-101 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 31 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0570 | 0570 | no
13082543 | 3.NP_SO-101 | 1772.14 | 0.000201032 | 0.0890775 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 194 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0571 | 0571 | no
13082599 | 3.NP_SO-101 | 374.063 | 0.000201032 | 0.0188024 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 75 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0572 | 0572 | no
13082610 | 3.NP_SO-101 | 367.713 | 0.000201032 | 0.0184832 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0573 | 0573 | no
13082621 | 3.NP_SO-101 | 367.713 | 0.000201032 | 0.0184832 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 73 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0574 | 0574 | no
13082632 | 3.NP_SO-101 | 374.063 | 0.000201032 | 0.0188024 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 72 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0575 | 0575 | no
13082643 | 3.NP_SO-101 | 3066.78 | 0.000201032 | 0.154153 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 72 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0576 | 0576 | no
13082687 | 3.NP_SO-101 | 2160.82 | 0.000201032 | 0.108614 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 77 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0577 | 0577 | no
13082698 | 3.NP_SO-101 | 139.744 | 0.000201032 | 0.00702432 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 77 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0578 | 0578 | no
13082709 | 3.NP_SO-101 | 3671.87 | 0.000201032 | 0.184568 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 76 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0579 | 0579 | no
13082826 | 3.NP_SO-101 | 2797.23 | 0.000201032 | 0.140604 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 71 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0580 | 0580 | no
13082830 | 3.NP_SO-101 | 2898.16 | 0.000201032 | 0.145677 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 19 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0581 | 0581 | no
13082845 | 3.NP_SO-101 | 2797.23 | 0.000201032 | 0.140604 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 75 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0582 | 0582 | no
13082864 | 3.NP_SO-101 | 2707.48 | 0.000201032 | 0.136093 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 70 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0583 | 0583 | no
13082902 | 3.NP_SO-101 | 1650.47 | 0.000201032 | 0.0829615 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 69 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0584 | 0584 | no
13082929 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 83 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0585 | 0585 | no
13082940 | 3.NP_SO-101 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 82 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0586 | 0586 | no
13082973 | 3.NP_SO-101 | 7460.34 | 0.000201032 | 0.374998 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 26 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0587 | 0587 | no
13082984 | 3.NP_SO-101 | 4400.01 | 0.000201032 | 0.221169 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 67 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0588 | 0588 | no
13082995 | 3.NP_SO-101 | 444.571 | 0.000201032 | 0.0223466 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 84 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0589 | 0589 | no
13083061 | 3.NP_SO-101 | 1109.34 | 0.000201032 | 0.0557616 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 67 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0590 | 0590 | no
13083095 | 3.NP_SO-101 | 6261.52 | 0.000201032 | 0.314738 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 68 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0591 | 0591 | no
13083108 | 3.NP_SO-101 | 2064.06 | 0.000201032 | 0.103751 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 190 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0592 | 0592 | no
13083161 | 3.NP_SO-101 | 473.466 | 0.000201032 | 0.023799 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 79 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0593 | 0593 | no
13083164 | 3.NP_SO-101 | 2503.73 | 0.000201032 | 0.125851 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 78 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0594 | 0594 | no
13083166 | 3.NP_SO-101 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 78 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0595 | 0595 | no
13083205 | 3.NP_SO-101 | 3150.39 | 0.000201032 | 0.158356 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 80 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0596 | 0596 | no
13083785 | 3.NP_SO-101 | 358.125 | 0.000201032 | 0.0180013 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 190 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0597 | 0597 | no
13083796 | 3.NP_SO-101 | 619.188 | 0.000201032 | 0.0311238 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 190 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0598 | 0598 | no
13083807 | 3.NP_SO-101 | 578.125 | 0.000201032 | 0.0290597 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 224 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0599 | 0599 | no
13084446 | 3.NP_SO-101 | 600.681 | 0.000201032 | 0.0301935 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 295 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0600 | 0600 | no
13084483 | 3.NP_SO-101 | 2537.11 | 0.000201032 | 0.127529 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 3.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 7944.2 | 16 | 149 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0601 | 0601 | no
13084549 | 3.NP_SO-101 | 530.579 | 0.000201032 | 0.0266698 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7934.2 | 16 | 34 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0602 | 0602 | no
13084708 | 3.NP_SO-101 | 4624.94 | 0.000201032 | 0.232475 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 285 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0603 | 0603 | no
13084741 | 3.NP_SO-101 | 655.788 | 0.000201032 | 0.0329635 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 65 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0604 | 0604 | no
13084811 | 3.NP_SO-101 | 1937.56 | 0.000201032 | 0.0973922 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 3.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7934.2 | 16 | 66 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0605 | 0605 | no
13085291 | 4.NP_SO-101 | 1587.71 | 0.000201032 | 0.0798071 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 239 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0606 | 0606 | no
13085302 | 4.NP_SO-101 | 1133.5 | 0.000201032 | 0.0569758 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 317 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0607 | 0607 | no
13085324 | 4.NP_SO-101 | 1217.71 | 0.000201032 | 0.0612089 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 128 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0608 | 0608 | no
13085490 | 4.NP_SO-101 | 4816.63 | 0.000201032 | 0.24211 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 104 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0609 | 0609 | no
13085615 | 4.NP_SO-101 | 1587.71 | 0.000201032 | 0.0798071 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 238 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0610 | 0610 | no
13085635 | 4.NP_SO-101 | 4267.84 | 0.000201032 | 0.214525 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 198 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0611 | 0611 | no
13085646 | 4.NP_SO-101 | 627.712 | 0.000201032 | 0.0315523 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 200 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0612 | 0612 | no
13085657 | 4.NP_SO-101 | 627.712 | 0.000201032 | 0.0315523 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 202 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0613 | 0613 | no
13085668 | 4.NP_SO-101 | 650 | 0.000201032 | 0.0326726 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 17 | 12634.2 | 16 | 1 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0614 | 0614 | no
13085690 | 4.NP_SO-101 | 10152.1 | 0.000201032 | 0.5103 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 199 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0615 | 0615 | no
13085874 | 4.NP_SO-101 | 488.997 | 0.000201032 | 0.0245797 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 197 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0617 | 0617 | no
13085924 | 4.NP_SO-101 | 190.057 | 0.000201032 | 0.00955333 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 198 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0618 | 0618 | no
13085973 | 4.NP_SO-101 | 2354.69 | 0.000201032 | 0.11836 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 203 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0619 | 0619 | no
13085983 | 4.NP_SO-101 | 2808.21 | 0.000201032 | 0.141156 | ø16 mm | 0.000862069 | HD | 648 | 640 | 640 | 4.NP_SO-101 | 0 | 632 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 12634.2 | 16 | 201 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0620 | 0620 | no
13086223 | 4.NP_SO-101 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 117 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0621 | 0621 | no
13086234 | 4.NP_SO-101 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 116 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0622 | 0622 | no
13086245 | 4.NP_SO-101 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 115 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0623 | 0623 | no
13086256 | 4.NP_SO-101 | 6861.78 | 0.000201032 | 0.34491 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 115 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0624 | 0624 | no
13086267 | 4.NP_SO-101 | 1179.85 | 0.000201032 | 0.0593058 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 122 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0625 | 0625 | no
13086278 | 4.NP_SO-101 | 8910.05 | 0.000201032 | 0.447868 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 113 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0626 | 0626 | no
13086289 | 4.NP_SO-101 | 258.799 | 0.000201032 | 0.0130086 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 110 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0627 | 0627 | no
13086302 | 4.NP_SO-101 | 621.723 | 0.000201032 | 0.0312512 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 120 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0628 | 0628 | no
13086313 | 4.NP_SO-101 | 629.084 | 0.000201032 | 0.0316212 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 119 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0629 | 0629 | no
13086324 | 4.NP_SO-101 | 1124.17 | 0.000201032 | 0.0565069 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 118 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0630 | 0630 | no
13086337 | 4.NP_SO-101 | 430.621 | 0.000201032 | 0.0216454 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 121 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0631 | 0631 | no
13086452 | 4.NP_SO-101 | 1831.78 | 0.000201032 | 0.0920751 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 119 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0632 | 0632 | no
13086698 | 4.NP_SO-101 | 1892.23 | 0.000201032 | 0.095114 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 111 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0633 | 0633 | no
13086702 | 4.NP_SO-101 | 4267.45 | 0.000201032 | 0.214505 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 112 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0634 | 0634 | no
13086711 | 4.NP_SO-101 | 850.982 | 0.000201032 | 0.042775 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 114 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0635 | 0635 | no
13086717 | 4.NP_SO-101 | 3516.17 | 0.000201032 | 0.176742 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 117 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0636 | 0636 | no
13086746 | 4.NP_SO-101 | 1984.95 | 0.000201032 | 0.0997747 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 103 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0637 | 0637 | no
13086760 | 4.NP_SO-101 | 665.208 | 0.000201032 | 0.033437 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 105 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0638 | 0638 | no
13086771 | 4.NP_SO-101 | 1968.13 | 0.000201032 | 0.0989288 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 105 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0639 | 0639 | no
13086782 | 4.NP_SO-101 | 2004.98 | 0.000201032 | 0.100781 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 107 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0640 | 0640 | no
13086793 | 4.NP_SO-101 | 254.062 | 0.000201032 | 0.0127706 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 107 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0641 | 0641 | no
13086804 | 4.NP_SO-101 | 247.712 | 0.000201032 | 0.0124514 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 108 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0642 | 0642 | no
13086815 | 4.NP_SO-101 | 247.712 | 0.000201032 | 0.0124514 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 109 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0643 | 0643 | no
13086830 | 4.NP_SO-101 | 168.125 | 0.000201032 | 0.00845088 | ø16 mm | 0.000862069 | HD | 124.063 | 124.063 | -44.0625 | 4.NP_SO-101 |  | -44.0625 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11955.9 | 16 | 105 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0644 | 0644 | no
13086841 | 4.NP_SO-101 | 538.125 | 0.000201032 | 0.0270491 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 105 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0645 | 0645 | no
13087092 | 4.NP_SO-101 | 758.342 | 0.000201032 | 0.0381184 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 104 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0646 | 0646 | no
13087246 | 4.NP_SO-101 | 988.566 | 0.000201032 | 0.0496908 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 105 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0647 | 0647 | no
13087250 | 4.NP_SO-101 | 2035.42 | 0.000201032 | 0.102312 | ø16 mm | 0.000862069 | HD | 148 | 140 | 140 | 4.NP_SO-101 | 0 | 132 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12134.2 | 16 | 106 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0648 | 0648 | no
13087415 | 4.NP_SO-101 | 327.436 | 0.000201032 | 0.0164587 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 99 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0649 | 0649 | no
13087426 | 4.NP_SO-101 | 2524.1 | 0.000201032 | 0.126875 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 99 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0650 | 0650 | no
13087807 | 4.NP_SO-101 | 18377 | 0.000201032 | 0.923727 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 123 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0651 | 0651 | no
13088226 | 4.NP_SO-101 | 4641.09 | 0.000201032 | 0.233287 | ø16 mm | 0.000862069 | HD | -102 | -110 | -110 | 4.NP_SO-101 | 0 | -118 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 11884.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0652 | 0652 | no
13088237 | 4.NP_SO-101 | 8095.99 | 0.000201032 | 0.406949 | ø16 mm | 0.000862069 | HD | -102 | -110 | -110 | 4.NP_SO-101 | 0 | -118 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 11884.2 | 16 | 74 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0653 | 0653 | no
13088459 | 1.NP_SO-101 | 4915 | 0.000201032 | 0.247055 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 270 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0654 | 0654 | no
13088535 | 1.NP_SO-101 | 5756.28 | 0.000201032 | 0.289342 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 1.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -65.8 | 16 | 132 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0655 | 0655 | no
13100496 | 4.NP_SO-101 | 1921.77 | 0.000201032 | 0.0965989 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 219 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0697 | 0697 | no
13100505 | 4.NP_SO-101 | 56.5761 | 0.000201032 | 0.00284383 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 4.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11944.2 | 16 | 218 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0698 | 0698 | no
13100513 | 4.NP_SO-101 | 2071.77 | 0.000201032 | 0.104139 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 186 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0699 | 0699 | no
13100555 | 4.NP_SO-101 | 32.5718 | 0.000201032 | 0.00163724 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 185 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0700 | 0700 | no
13100599 | 4.NP_SO-101 | 4790.84 | 0.000201032 | 0.240814 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 101 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0701 | 0701 | no
13100620 | 4.NP_SO-101 | 218.125 | 0.000201032 | 0.0109642 | ø16 mm | 0.000862069 | HD | 184.063 | 184.063 | -34.0625 | 4.NP_SO-101 |  | -34.0625 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 11965.9 | 16 | 219 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0702 | 0702 | no
13100653 | 4.NP_SO-101 | 228.125 | 0.000201032 | 0.0114668 | ø16 mm | 0.000862069 | HD | 184.063 | 184.063 | -44.0625 | 4.NP_SO-101 |  | -44.0625 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11955.9 | 16 | 186 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0703 | 0703 | no
13102820 | 4.NP_SO-101 | 4488.87 | 0.000314112 | 0.282044 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11892.8 | 20 | 14 | CL_přívodní vodní (10 °C) | ø20 | 14.4 | TR13.01.0712 | 0712 | no
13102828 | 4.NP_SO-101 | 7694.46 | 0.000314112 | 0.483457 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11892.8 | 20 | 14 | CL_přívodní vodní (10 °C) | ø20 | 14.4 | TR13.01.0713 | 0713 | no
13103703 | 4.NP_SO-101 | 4169.86 | 0.000314112 | 0.262 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 11892.8 | 20 | 9 | CL_vratné vodní (15 °C) | ø20 | 14.4 | TR13.01.0722 | 0722 | no
13103714 | 4.NP_SO-101 | 4553.87 | 0.000314112 | 0.286128 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 11892.8 | 20 | 9 | CL_vratné vodní (15 °C) | ø20 | 14.4 | TR13.01.0723 | 0723 | no
13103725 | 4.NP_SO-101 | 7894.46 | 0.000314112 | 0.496024 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 11892.8 | 20 | 9 | CL_vratné vodní (15 °C) | ø20 | 14.4 | TR13.01.0724 | 0724 | no
13107371 | 2.NP_SO-101 | 4089.05 | 0.000201032 | 0.205538 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 271 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0729 | 0729 | no
13107379 | 2.NP_SO-101 | 1208.88 | 0.000201032 | 0.0607648 | ø16 mm | 0.000862069 | HD | -42 | -50 | -50 | 2.NP_SO-101 | 0 | -58 | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 3944.2 | 16 | 20 | HT_přívodní vodní (65 °C) | ø16 | 11.6 | TR13.01.0730 | 0730 | no
13108070 | 4.NP_SO-101 | 249.402 | 0.000201032 | 0.0125363 | ø16 mm | 0.000862069 | HD | -52 | -60 | -60 | 4.NP_SO-101 | 0 | -68 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11934.2 | 16 | 125 | HT_vratné vodní (45 °C) | ø16 | 11.6 | TR13.01.0731 | 0731 | no
13110789 | 4.NP_SO-101 | 4475.07 | 0.000314112 | 0.281177 | ø20 mm | 0.000694444 | HC | -90 | -100 | -100 | 4.NP_SO-101 | 0 | -110 | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11892.8 | 20 | 14 | CL_přívodní vodní (10 °C) | ø20 | 14.4 | TR13.01.0746 | 0746 | no
