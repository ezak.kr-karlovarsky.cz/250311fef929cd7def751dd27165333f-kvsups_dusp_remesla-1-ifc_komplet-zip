Properties of the parts of a building model (IFC4), part 13 of 23

# IfcDistributionPort (3628)
Name | FlowDirection | Group
Port_12953738_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949483_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949491_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949483_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949495_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949491_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949492_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949495_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949496_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949496_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949577_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949548_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949556_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949548_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949556_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949578_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949556_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949557_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949560_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949560_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949581_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949569_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949577_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949569_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949581_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949577_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949578_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949752_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949833_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949752_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949760_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113820_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949760_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13054124_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949760_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949834_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949765_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949837_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949765_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949823_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949833_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949823_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949837_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949833_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949834_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949944_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13158729_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949944_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949986_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12966867_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949986_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12949998_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960066_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12949998_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950051_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960171_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950051_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950060_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960171_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950060_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960129_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950241_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950380_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950241_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950261_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950550_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950261_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950500_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950281_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960127_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950281_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960129_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950341_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950380_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950341_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950380_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950428_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950428_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950496_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950436_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950444_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950436_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950444_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950497_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950444_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950445_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950445_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950496_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950497_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950496_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950551_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950500_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950534_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950500_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950501_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950501_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960127_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950509_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950509_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950540_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950534_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950540_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950542_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950550_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950542_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950550_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950551_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12950554_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950554_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950725_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950653_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950653_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950729_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950670_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13167571_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950670_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950725_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950730_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950725_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13167572_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950729_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960360_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950729_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950730_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950741_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950741_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959236_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950812_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13167571_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950812_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960540_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950816_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959236_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12950816_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959238_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951638_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951716_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951638_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951639_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951638_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13165692_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951639_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951642_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13165691_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951642_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951651_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13165691_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951651_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951696_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951719_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951696_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951705_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951715_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951705_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951719_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951715_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160256_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951715_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951716_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951730_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957097_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951730_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956903_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951747_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951755_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951747_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951755_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951861_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951755_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13100505_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951760_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951951_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951760_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951769_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951860_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951769_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951879_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951782_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951951_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951782_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951932_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951792_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951930_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951792_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951860_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951861_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951860_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951893_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951879_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957098_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951886_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951892_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951886_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951892_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951933_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951892_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951893_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951927_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951932_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951927_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952005_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951930_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951952_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951932_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951933_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951951_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951952_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951962_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951962_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951977_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12951977_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952006_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952005_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952023_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952005_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952006_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952014_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952022_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952014_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952022_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952049_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952022_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952023_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952026_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952026_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952055_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952049_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12952055_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953529_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13106920_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953529_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960544_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953544_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12961346_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953544_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13106920_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953728_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953737_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953728_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953767_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953737_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953738_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953761_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953767_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953761_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953780_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953772_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953780_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953772_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953856_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953856_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13106712_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953860_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097612_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12953860_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13097375_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12955056_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13098173_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955056_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955491_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955245_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955255_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955245_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955372_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955255_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13106665_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955259_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955372_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955259_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955374_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955389_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955390_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12955491_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13097511_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956515_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956593_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956515_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12972145_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956581_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956593_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956581_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956593_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956594_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956594_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137417_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956598_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956598_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956746_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956683_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956683_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956742_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956700_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956700_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956740_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956740_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956743_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956742_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956747_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956742_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956743_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956746_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956796_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956746_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956747_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956796_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12972145_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12956891_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956903_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956891_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956913_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956905_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956913_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956905_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957038_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956915_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957073_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12956915_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957052_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957036_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957038_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957036_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957042_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957042_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957085_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957046_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957052_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957046_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957063_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957073_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957063_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957073_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957074_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957074_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957084_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957078_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957084_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957078_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957084_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957085_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957089_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957097_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957089_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957097_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957098_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957160_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969575_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957160_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969579_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957266_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969576_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957266_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957267_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957315_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969575_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12957382_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969252_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957382_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957517_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957391_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13084483_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957391_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957392_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957415_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957517_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957415_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957517_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957551_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957548_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13143830_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957551_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13084482_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957596_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957638_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957596_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957638_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969253_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957664_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969252_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12957664_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958370_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969507_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958370_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969511_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958566_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958588_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958582_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958587_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958582_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13079955_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958587_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958588_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958587_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107371_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958596_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958596_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958662_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958662_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958693_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958687_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958692_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958687_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958741_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958692_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958693_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958701_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958701_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958741_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12958806_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958856_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958856_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958896_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958896_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958897_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958896_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958918_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958913_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958914_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958914_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958917_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965617_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958917_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958918_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12958957_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13076445_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959018_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959090_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959018_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959019_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959084_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959089_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959084_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959129_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959089_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959090_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959089_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959157_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959137_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13112113_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959137_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969382_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959146_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969378_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959146_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969382_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959157_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969378_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959209_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113819_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959209_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12966867_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959233_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113819_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959233_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114095_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959238_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113925_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959238_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13113908_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959239_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960540_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959239_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13114177_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12959254_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959254_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959404_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959348_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959348_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959406_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959361_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959361_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959410_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959374_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959374_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959414_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959396_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959414_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959396_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959723_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959404_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960355_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959406_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959411_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959406_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959407_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959407_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960354_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959410_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959415_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959410_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959411_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959414_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959415_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959645_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959723_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959645_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959727_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12959727_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960067_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960066_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960109_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960066_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960067_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960108_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960130_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960108_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960109_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960108_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965076_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960129_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960130_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960325_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960325_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960342_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960334_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960342_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960334_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960358_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960344_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960354_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960344_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960358_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960354_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960355_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960360_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960424_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960422_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960424_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960422_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960428_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960428_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13121188_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960442_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960452_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960442_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960460_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960452_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960489_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960454_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960460_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960454_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960470_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960462_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960470_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960462_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960480_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13121187_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960480_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960489_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13121187_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960528_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960540_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960528_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960544_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960779_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12961358_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960779_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13110965_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960786_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157309_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960786_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157978_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12960864_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13117038_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12960864_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13094539_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12961346_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13109309_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12961358_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13109309_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12961358_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13109311_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12961598_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117032_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12961598_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13094444_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12962498_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13157307_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12962498_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13092667_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12963773_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964878_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12963773_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965124_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12963829_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965075_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12963829_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964015_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144548_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964015_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964031_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964023_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964031_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964023_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140618_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964579_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140618_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964579_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140620_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964870_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964878_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964870_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964962_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964883_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13070259_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964883_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13070263_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964960_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964962_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12964960_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13106581_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965019_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965075_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965019_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13070263_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965075_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965076_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965124_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965247_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965247_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13140004_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12965617_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13071509_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967560_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967903_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967903_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967904_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967903_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137633_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12967907_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13137298_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12968049_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13107327_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12968049_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_13144543_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969188_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13087589_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969188_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969197_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13160253_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969197_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13087589_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969252_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969253_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 4
Port_12969324_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969355_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969324_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13109311_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969355_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13155037_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969355_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13112113_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969378_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969379_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969446_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163196_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969446_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13162450_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969507_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13107379_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969507_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969508_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969511_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13159765_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969535_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13163207_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969535_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969579_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969575_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969576_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_12969915_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970438_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12969915_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111136_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970047_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111660_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970047_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111662_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970060_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111660_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970060_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970079_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970071_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970079_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970071_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970121_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970438_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970121_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111664_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970419_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13073303_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970419_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970420_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970419_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970443_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970420_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13117024_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970433_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150650_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970433_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150654_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970442_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150654_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970442_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970443_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970442_3 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13111138_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970750_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150650_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970750_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150673_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970811_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164480_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_12970811_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164484_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13054124_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13158729_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 2
Port_13054268_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158702_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054268_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054290_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158702_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054290_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054394_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056577_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054394_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054405_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054696_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054405_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054700_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054416_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054700_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054416_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054669_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113849_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054669_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13158703_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054669_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054697_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054674_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054696_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054674_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054696_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054697_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13054726_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054829_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054726_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054737_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054829_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054737_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054748_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055204_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13054748_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055256_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13054792_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054919_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054792_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054829_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054830_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054830_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 4
Port_13054866_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054919_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054866_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054919_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054920_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054920_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 6
Port_13054938_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055204_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13054938_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13054982_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13054982_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055277_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055148_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055185_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055148_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055185_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055186_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055185_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055205_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055186_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055204_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055205_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055249_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055256_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055249_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055277_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055256_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055257_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055257_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13107313_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13055293_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055388_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055293_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055304_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055388_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055304_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055409_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055315_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055409_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055315_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055411_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055337_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13121160_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055337_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055411_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13121161_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055480_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13121160_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055480_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056102_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055544_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055644_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055544_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055555_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055805_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055555_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055566_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13167594_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055566_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055635_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055644_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055635_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056138_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055644_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055806_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055796_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13167594_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055796_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13076362_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055805_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13167595_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055805_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13055806_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056019_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056138_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056019_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056102_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056408_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056596_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056408_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056600_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056419_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056419_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056600_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056526_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113848_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056526_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13114062_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056545_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113848_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056545_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056577_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056596_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113859_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056596_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13113882_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13056615_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13114991_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056615_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056626_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13114991_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056626_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057081_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056659_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056838_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056659_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056670_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056897_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056670_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056700_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056958_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056700_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056733_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057978_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056733_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056838_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057082_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056838_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056898_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056897_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056959_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056897_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056898_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056949_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056958_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056949_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057814_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056958_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056959_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056992_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057079_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13056992_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057081_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057003_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057079_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057003_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057058_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057014_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057014_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057058_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057081_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057082_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057238_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057814_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057238_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057845_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057845_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057979_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057898_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13107313_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057898_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058085_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057909_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058085_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057909_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058096_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057920_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058096_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057920_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13057953_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070123_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057953_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070170_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057978_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058052_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057978_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057979_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057982_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058051_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13057982_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058051_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058052_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058051_3 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070124_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058085_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058086_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058086_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 3
Port_13058139_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13070123_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058139_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13058687_0 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13150673_2 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13058687_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13164478_1 | SOURCEANDSINK | HT_přívodní vodní (65 °C) 9
Port_13058933_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13157324_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13058933_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13092705_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13058942_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13116967_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13058942_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13094495_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 10
Port_13059091_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13116859_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13059091_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13094581_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 7
Port_13064481_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064829_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064481_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064850_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064492_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064850_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064492_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064886_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064503_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064886_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064503_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064949_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064591_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13064591_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13065093_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 1
Port_13064602_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064602_1 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064763_2 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
Port_13064613_0 | SOURCEANDSINK | HT_vratné vodní (45 °C) 2
