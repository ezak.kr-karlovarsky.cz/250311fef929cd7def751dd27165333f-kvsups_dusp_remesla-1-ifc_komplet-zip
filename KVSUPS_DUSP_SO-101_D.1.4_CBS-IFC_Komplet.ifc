Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 28a6ba9b-e14a-4780-9af8-e5a560c6e9c4, NumberOfSaves: 86], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-13T16:51:54
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject
Phase: SpD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.11 11:02

# IfcBuilding, Budova E
LongName: Budova E
Identifikační data - Název budovy: Budova E
Jiné - Datum vydání projektu: 10/2022; Kategorie: Informace o projektu; OBJEKT: SO 101; PROFESNÍ ČÁST: Elektroinstalace silnorpoud; Stav projektu: SpD; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.04.11 11:02

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-101
In: Budova E
LongName: 2.NP_SO-101; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-101
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:35
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (4)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:34
1.NP_SO-101 | 1.NP_SO-101 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:34
3.NP_SO-101 | 3.NP_SO-101 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:35
4.NP_SO-101 | 4.NP_SO-101 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 01:35

# IfcDistributionPort (131)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: ELECTRICAL
Name
Port_673722_1
Port_695491_1
Port_696465_1
Port_696476_1
Port_696535_1
Port_696897_1
Port_697363_1
Port_697419_1
Port_697538_1
Port_697794_1
Port_698288_1
Port_698329_1
Port_698743_1
Port_699034_1
Port_699520_1
Port_699644_1
Port_699789_1
Port_699871_1
Port_700007_1
Port_700240_1
Port_700248_1
Port_700305_1
Port_700563_1
Port_700576_1
Port_700876_1
Port_701027_1
Port_701200_1
Port_701305_1
Port_701348_1
Port_701822_1
Port_702188_1
Port_702226_1
Port_702327_1
Port_702429_1
Port_702905_1
Port_703218_1
Port_703326_1
Port_703372_1
Port_703513_1
Port_703770_1
Port_703932_1
Port_704263_1
Port_704392_1
Port_704670_1
Port_704853_1
Port_704961_1
Port_705133_1
Port_705297_1
Port_705328_1
Port_705897_1
Port_705971_1
Port_706139_1
Port_706297_1
Port_706314_1
Port_706892_1
Port_706961_1
Port_707265_1
Port_707275_1
Port_707390_1
Port_707521_1
Port_707986_1
Port_708061_1
Port_708110_1
Port_708321_1
Port_708493_1
Port_708673_1
Port_708815_1
Port_708982_1
Port_709191_1
Port_709494_1
Port_709742_1
Port_709924_1
Port_710471_1
Port_710687_1
Port_710785_1
Port_711053_1
Port_711125_1
Port_711298_1
Port_711502_1
Port_711815_1
Port_712095_1
Port_712500_1
Port_712508_1
Port_712952_1
Port_713033_1
Port_713045_1
Port_713324_1
Port_713538_1
Port_713760_1
Port_714250_1
Port_714411_1
Port_714974_1
Port_715370_1
Port_715620_1
Port_715748_1
Port_715859_1
Port_716116_1
Port_716173_1
Port_716413_1
Port_716613_1
Port_716846_1
Port_716915_1
Port_717322_1
Port_717550_1
Port_717741_1
Port_717863_1
Port_718054_1
Port_718312_1
Port_718553_1
Port_718616_1
Port_718796_1
Port_718845_1
Port_719057_1
Port_719166_1
Port_719378_1
Port_719641_1
Port_719651_1
Port_719867_1
Port_720212_1
Port_720317_1
Port_720327_1
Port_720444_1
Port_721012_1
Port_722605_1
Port_722645_1
Port_722775_1
Port_722788_1
Port_722864_1
Port_723128_1
Port_723851_1
Port_724358_1

# IfcDistributionSystem (20)
PredefinedType: ELECTRICAL

# IfcLightFixture: Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS (131)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2250 mm
Type - Kóty - Délka: 262 mm; Šířka: 58 mm; Výška: 188 mm
Type - Identifikační data - Číslo OmniClass: 23.85.80.11.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OS03; Komentáře k typům: 230V, osvětlení; Model: Model; Nadpis OmniClass: Lighting Controls; Název typu: Nouzové svítidlo - CBS; Označení typu: 03; Popis: CBS; Popis sestavy: Nouzové; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: Nouzové svítidlo s konektorem_hranáté.CC
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Elektroinstalace - JMENOVITÝ PROUD: 0 A; POČET FÁZÍ: 1; PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - CCI Funkční systém: P; CCI Komponenta: EAA; CCI Technický systém: ME
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V
Grafika - Geometrie: yes
Kóty - Objem: 0.001487 m3
Jiné - FAKTOR ÚČINNOSTI: 0; Id typu: 664801; Rodina: Nouzové svítidlo s konektorem_hranáté.CC; Rodina a typ: Nouzové svítidlo s konektorem_hranáté.CC: Nouzové svítidlo - CBS; Typ: Nouzové svítidlo - CBS; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:02
Name (Nouzové svítidlo s konektorem_hranáté.CC:Nouzové svítidlo - CBS:...) | In | NAPÁJENÍ_ČÍSLO OKRUHU = Číslo okruhu = Group | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
673722 | 3.NP_SO-101 | <bez názvu> | 723851 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0008 | 0008
695491 | 3.NP_SO-101 | <bez názvu> | 697419 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0009 | 0009
696465 | 3.NP_SO-101 | <bez názvu> | 698743 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0010 | 0010
696476 | 3.NP_SO-101 | <bez názvu> | 700007 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0011 | 0011
696535 | 3.NP_SO-101 | <bez názvu> | 698329 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 376.007 | OS03.03.0012 | 0012
696897 | 3.NP_SO-101 | <bez názvu> | 699644 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0013 | 0013
697363 | 3.NP_SO-101 | <bez názvu> | 700248 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0014 | 0014
697419 | 3.NP_SO-101 | <bez názvu> | 697363 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0015 | 0015
697538 | 3.NP_SO-101 | <bez názvu> | 723128 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0016 | 0016
697794 | 3.NP_SO-101 | <bez názvu> | 699871 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0017 | 0017
698288 | 3.NP_SO-101 | <bez názvu> | 696476 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0018 | 0018
698329 | 3.NP_SO-101 | <bez názvu> | 698288 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0019 | 0019
698743 | 3.NP_SO-101 | <bez názvu> | 699034 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0020 | 0020
699034 | 3.NP_SO-101 | <bez názvu> | 697538 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0021 | 0021
699520 | 3.NP_SO-101 | <bez názvu> | 705297 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0022 | 0022
699644 | 3.NP_SO-101 | <bez názvu> | 722605 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0023 | 0023
699789 | 3.NP_SO-101 | <bez názvu> | 705897 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0024 | 0024 | Jiné - Páteřní trasa: no
699871 | 3.NP_SO-101 | <bez názvu> | 699789 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0025 | 0025
700007 | 3.NP_SO-101 | <bez názvu> | 706892 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0026 | 0026
700240 | 3.NP_SO-101 | <bez názvu> | 697794 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0027 | 0027
700248 | 3.NP_SO-101 | <bez názvu> | 706139 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0028 | 0028
700305 | 3.NP_SO-101 | <bez názvu> | 722864 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0029 | 0029
700563 | 4.NP_SO-101 | <bez názvu> | 700576 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0030 | 0030
700576 | 4.NP_SO-101 | <bez názvu> | 701822 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0031 | 0031
700876 | 4.NP_SO-101 | <bez názvu> | 695491 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0032 | 0032
701027 | 4.NP_SO-101 | <bez názvu> | 702188 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0033 | 0033
701200 | 4.NP_SO-101 | <bez názvu> | 722788 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0034 | 0034
701305 | 4.NP_SO-101 | <bez názvu> | 701200 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 224.132 | OS03.03.0035 | 0035
701348 | 4.NP_SO-101 | <bez názvu> | 720317 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0036 | 0036
701822 | 4.NP_SO-101 | <bez názvu> | 673722 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0037 | 0037
702188 | 4.NP_SO-101 | <bez názvu> | 702429 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0038 | 0038
702226 | 4.NP_SO-101 | <bez názvu> | 701305 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0039 | 0039
702327 | 4.NP_SO-101 | <bez názvu> | 702226 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0040 | 0040
702429 | 4.NP_SO-101 | <bez názvu> | 720327 | 4.NP_SO-101 | Osamocené | 2250 | OS03.03.0041 | 0041
702905 | 4.NP_SO-101 | <bez názvu> | 703218 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0042 | 0042
703218 | 4.NP_SO-101 | <bez názvu> | 700305 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0043 | 0043
703326 | 2.NP_SO-101 | <bez názvu> | 703932 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0044 | 0044
703372 | 2.NP_SO-101 | <bez názvu> | 709191 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0045 | 0045
703513 | 2.NP_SO-101 | <bez názvu> | 709742 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0046 | 0046
703770 | 2.NP_SO-101 | <bez názvu> | 706961 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0047 | 0047
703932 | 2.NP_SO-101 | <bez názvu> | 710687 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0048 | 0048
704263 | 2.NP_SO-101 | <bez názvu> | 704961 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0049 | 0049
704392 | 2.NP_SO-101 | <bez názvu> | 703372 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0050 | 0050
704670 | 2.NP_SO-101 | <bez názvu> | 703770 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0051 | 0051
704853 | 2.NP_SO-101 | <bez názvu> | 703513 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0052 | 0052
704961 | 2.NP_SO-101 | <bez názvu> | 711815 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0053 | 0053
705133 | 2.NP_SO-101 | <bez názvu> | 703326 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0054 | 0054
705297 | 2.NP_SO-101 | <bez názvu> | 704670 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0055 | 0055
705328 | 2.NP_SO-101 | <bez názvu> | 704853 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0056 | 0056
705897 | 2.NP_SO-101 | <bez názvu> | 705133 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0057 | 0057
705971 | 2.NP_SO-101 | <bez názvu> | 706314 | 2.NP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0058 | 0058
706139 | 3.NP_SO-101 | <bez názvu> | 699520 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0059 | 0059
706297 | 2.NP_SO-101 | <bez názvu> | 704263 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0060 | 0060
706314 | 2.NP_SO-101 | <bez názvu> | 704392 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0061 | 0061
706892 | 2.NP_SO-101 | <bez názvu> | 705328 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0062 | 0062
706961 | 2.NP_SO-101 | <bez názvu> | 707275 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0063 | 0063
707265 | 1.NP_SO-101 | <bez názvu> | 708110 | 1.NP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0064 | 0064
707275 | 1.NP_SO-101 | <bez názvu> | 712508 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0065 | 0065
707390 | 1.NP_SO-101 | <bez názvu> | 711053 | 1.NP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0066 | 0066
707521 | 1.NP_SO-101 | <bez názvu> | 712952 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0067 | 0067
707986 | 1.NP_SO-101 | <bez názvu> | 712500 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0068 | 0068
708061 | 1.NP_SO-101 | <bez názvu> | 707390 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0069 | 0069
708110 | 1.NP_SO-101 | <bez názvu> | 707521 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0070 | 0070
708321 | 1.NP_SO-101 | <bez názvu> | 709924 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0071 | 0071
708493 | 1.NP_SO-101 | <bez názvu> | 719651 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0072 | 0072
708673 | 1.NP_SO-101 | <bez názvu> | 707986 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0073 | 0073
708815 | 1.NP_SO-101 | <bez názvu> | 708982 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0074 | 0074
708982 | 1.NP_SO-101 | <bez názvu> | 711125 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0075 | 0075
709191 | 1.NP_SO-101 | <bez názvu> | 709494 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0076 | 0076
709494 | 1.NP_SO-101 | <bez názvu> | 710471 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0077 | 0077
709742 | 1.NP_SO-101 | <bez názvu> | 710785 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0078 | 0078
709924 | 1.NP_SO-101 | <bez názvu> | 711502 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0079 | 0079
710471 | 1.NP_SO-101 | <bez názvu> | 708673 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0080 | 0080
710687 | 1.NP_SO-101 | <bez názvu> | 711298 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0081 | 0081
710785 | 1.NP_SO-101 | <bez názvu> | 707265 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0082 | 0082
711053 | 1.NP_SO-101 | <bez názvu> | 720212 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0083 | 0083
711125 | 1.NP_SO-101 | <bez názvu> | 712095 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0084 | 0084
711298 | 1.NP_SO-101 | <bez názvu> | 708815 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0085 | 0085
711502 | 1.NP_SO-101 | <bez názvu> | 708493 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0086 | 0086
711815 | 1.NP_SO-101 | <bez názvu> | 721012 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0087 | 0087
712095 | 1.NP_SO-101 | <bez názvu> | 717741 | 1.NP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0088 | 0088
712500 | 1.NP_SO-101 | <bez názvu> | 717322 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0089 | 0089
712508 | 1.NP_SO-101 | <bez názvu> | 708061 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0090 | 0090
712952 | 1.NP_SO-101 | <bez názvu> | 716846 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0092 | 0092
713033 | -1.PP_SO-101 | <bez názvu> | 724950 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0095 | 0095
713045 | -1.PP_SO-101 | <bez názvu> | 725119 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0096 | 0096
713324 | -1.PP_SO-101 | <bez názvu> | 725146 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0097 | 0097
713538 | -1.PP_SO-101 | <bez názvu> | 725178 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0098 | 0098
713760 | -1.PP_SO-101 | <bez názvu> | Nouzové svítidlo s konektorem_hranáté.CC | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0099 | 0099
714250 | -1.PP_SO-101 | <bez názvu> | 713033 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0100 | 0100
714411 | -1.PP_SO-101 | <bez názvu> | 713045 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0101 | 0101
714974 | -1.PP_SO-101 | <bez názvu> | 713324 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0102 | 0102
715370 | -1.PP_SO-101 | <bez názvu> | 713538 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0103 | 0103
715620 | -1.PP_SO-101 | <bez názvu> | 713760 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0104 | 0104
715748 | -1.PP_SO-101 | <bez názvu> | 714250 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0105 | 0105
715859 | -1.PP_SO-101 | <bez názvu> | 714411 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0106 | 0106
716116 | -1.PP_SO-101 | <bez názvu> | 714974 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0107 | 0107
716173 | -1.PP_SO-101 | <bez názvu> | 715370 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0108 | 0108
716413 | -1.PP_SO-101 | <bez názvu> | 715748 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0109 | 0109
716613 | -1.PP_SO-101 | <bez názvu> | 716116 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0110 | 0110
716846 | -1.PP_SO-101 | <bez názvu> | 716413 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0111 | 0111
716915 | -1.PP_SO-101 | <bez názvu> | 715859 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0112 | 0112
717322 | -1.PP_SO-101 | <bez názvu> | 716915 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0113 | 0113
717550 | -1.PP_SO-101 | <bez názvu> | 716173 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0114 | 0114
717741 | -1.PP_SO-101 | <bez názvu> | 716613 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0115 | 0115
717863 | -1.PP_SO-101 | <bez názvu> | 718796 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0116 | 0116
718054 | -1.PP_SO-101 | <bez názvu> | 719378 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0117 | 0117
718312 | -1.PP_SO-101 | <bez názvu> | 719057 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0118 | 0118
718553 | -1.PP_SO-101 | <bez názvu> | 715620 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0119 | 0119
718616 | -1.PP_SO-101 | <bez názvu> | 717550 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0120 | 0120
718796 | -1.PP_SO-101 | <bez názvu> | 718312 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0121 | 0121
718845 | -1.PP_SO-101 | <bez názvu> | 719641 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0122 | 0122
719057 | -1.PP_SO-101 | <bez názvu> | 719867 | -1.PP_SO-101 | Osamocené | 2250 | OS03.03.0123 | 0123
719166 | -1.PP_SO-101 | <bez názvu> | 718845 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0124 | 0124
719378 | -1.PP_SO-101 | <bez názvu> | 719166 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0125 | 0125
719641 | -1.PP_SO-101 | <bez názvu> | 718616 | -1.PP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0126 | 0126
719651 | -1.PP_SO-101 | <bez názvu> | 718553 | -1.PP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0127 | 0127
719867 | -1.PP_SO-101 | <bez názvu> | 718054 | -1.PP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0128 | 0128
720212 | 1.NP_SO-101 | <bez názvu> | 717863 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0160 | 0160
720317 | 4.NP_SO-101 | <bez názvu> | 700876 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0171 | 0171
720327 | 4.NP_SO-101 | <bez názvu> | 722775 | 4.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0172 | 0172
720444 | 4.NP_SO-101 | <bez názvu> | 702905 | 4.NP_SO-101 | <nepřiřazeno> | 2250 | OS03.03.0173 | 0173
721012 | 1.NP_SO-101 | <bez názvu> | 708321 | 1.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0193 | 0193
722605 | 3.NP_SO-101 | <bez názvu> | 722645 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0216 | 0216
722645 | 2.NP_SO-101 | <bez názvu> | 706297 | 2.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0217 | 0217
722775 | 3.NP_SO-101 | <bez názvu> | 696465 | 3.NP_SO-101 | Osamocené | 2250 | OS03.03.0220 | 0220
722788 | 3.NP_SO-101 | <bez názvu> | 696535 | 3.NP_SO-101 | Osamocené | 2250 | OS03.03.0221 | 0221
722864 | 3.NP_SO-101 | <bez názvu> | 700240 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0222 | 0222
723128 | 3.NP_SO-101 |  | 705971 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0223 | 0223
723851 | 3.NP_SO-101 | <bez názvu> | 724358 | 3.NP_SO-101 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-101_D.1.1_ASR-Model.rvt | 2250 | OS03.03.0224 | 0224
724358 | 3.NP_SO-101 | <bez názvu> | 696897 | 3.NP_SO-101 | Osamocené | 2250 | OS03.03.0225 | 0225

# IfcLightFixture: PF_úniková tabulka (dveře doleva):PF_úniková tabulka (dveře doleva) (5)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře doleva); Označení typu: 05; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře doleva)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: P; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Odsazení od hostitele: 0 mm; Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 662660; Rodina: PF_úniková tabulka (dveře doleva); Rodina a typ: PF_úniková tabulka (dveře doleva): PF_úniková tabulka (dveře doleva); Typ: PF_úniková tabulka (dveře doleva); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:04
Name (PF_úniková tabulka (dveře doleva):PF_úniková tabulka (dveře doleva):...) | In | ID_import | Podlaží | Hostitel | Kód prvku | Označení | Material
720066 | -1.PP_SO-101 | 720444 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.05.0134 | 0134
720276 | 1.NP_SO-101 | 701348 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.05.0166 | 0166 | Výchozí zdroj světla, <Unnamed>
720279 | 1.NP_SO-101 | 700563 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.05.0167 | 0167 | Výchozí zdroj světla, <Unnamed>
721904 | 1.NP_SO-101 | 701027 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.05.0196 | 0196 | Výchozí zdroj světla, <Unnamed>
742909 | -1.PP_SO-101 | 702327 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.05.0226 | 0226 | Výchozí zdroj světla, <Unnamed>

# IfcLightFixture: PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu) (75)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře dolu); Označení typu: 02; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře dolu)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: P; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 2250 mm; Výška od podlaží: 2250 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 661614; Rodina: PF_úniková tabulka (dveře dolu); Rodina a typ: PF_úniková tabulka (dveře dolu): PF_úniková tabulka (dveře dolu); Typ: PF_úniková tabulka (dveře dolu)
Name (PF_úniková tabulka (dveře dolu):PF_úniková tabulka (dveře dolu):...) | In | ID_import | Podlaží | Hostitel | Kód prvku | Označení | UPRAVIL | Material
662761 | 4.NP_SO-101 | PF_úniková tabulka (dveře doleva) | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | OS03.02.0003 | 0003 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55
662963 | 3.NP_SO-101 | 720066 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0004 | 0004 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
662966 | 3.NP_SO-101 | 720276 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
662969 | 3.NP_SO-101 | 720279 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0006 | 0006 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
662975 | 3.NP_SO-101 | 721904 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0007 | 0007 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
712990 | 1.NP_SO-101 | 742909 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0093 | 0093 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
712993 | 1.NP_SO-101 | PF_úniková tabulka (dveře dolu) | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0094 | 0094 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:04 | Výchozí zdroj světla, <Unnamed>
720048 | -1.PP_SO-101 | 662761 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720051 | -1.PP_SO-101 | 662963 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0130 | 0130 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720054 | -1.PP_SO-101 | 662966 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720057 | -1.PP_SO-101 | 662969 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0132 | 0132 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720060 | -1.PP_SO-101 | 662975 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720072 | -1.PP_SO-101 | 712990 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0135 | 0135 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720075 | -1.PP_SO-101 | 712993 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720078 | -1.PP_SO-101 | 720048 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720081 | -1.PP_SO-101 | 720051 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720084 | -1.PP_SO-101 | 720054 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720087 | -1.PP_SO-101 | 720057 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720090 | -1.PP_SO-101 | 720060 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720093 | -1.PP_SO-101 | 720072 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720096 | -1.PP_SO-101 | 720075 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720099 | -1.PP_SO-101 | 720078 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720144 | -1.PP_SO-101 | 720081 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720147 | -1.PP_SO-101 | 720084 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | OS03.02.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720175 | 1.NP_SO-101 | 720087 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720178 | 1.NP_SO-101 | 720090 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0150 | 0150 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720181 | 1.NP_SO-101 | 720093 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720184 | 1.NP_SO-101 | 720096 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720187 | 1.NP_SO-101 | 720099 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0153 | 0153 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720190 | 1.NP_SO-101 | 720144 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720193 | 1.NP_SO-101 | 720147 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0155 | 0155 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720196 | 1.NP_SO-101 | 720175 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0156 | 0156 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720199 | 1.NP_SO-101 | 720178 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0157 | 0157 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720202 | 1.NP_SO-101 | 720181 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720205 | 1.NP_SO-101 | 720184 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720233 | 1.NP_SO-101 | 720187 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720236 | 1.NP_SO-101 | 720190 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0162 | 0162 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720239 | 1.NP_SO-101 | 720193 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0163 | 0163 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720242 | 1.NP_SO-101 | 720196 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0164 | 0164 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720245 | 1.NP_SO-101 | 720199 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720285 | 1.NP_SO-101 | 720202 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720300 | 1.NP_SO-101 | 720205 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0169 | 0169 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720563 | 3.NP_SO-101 | 720233 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0174 | 0174 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720566 | 3.NP_SO-101 | 720236 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0175 | 0175 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720569 | 3.NP_SO-101 | 720239 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0176 | 0176 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720572 | 3.NP_SO-101 | 720242 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0177 | 0177 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720575 | 3.NP_SO-101 | 720245 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0178 | 0178 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720578 | 3.NP_SO-101 | 720285 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0179 | 0179 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720581 | 3.NP_SO-101 | 720300 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0180 | 0180 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720584 | 3.NP_SO-101 | 720563 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0181 | 0181 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720587 | 3.NP_SO-101 | 720566 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0182 | 0182 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720590 | 3.NP_SO-101 | 720569 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0183 | 0183 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720593 | 3.NP_SO-101 | 720572 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0184 | 0184 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720596 | 3.NP_SO-101 | 720575 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0185 | 0185 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720599 | 3.NP_SO-101 | 720578 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0186 | 0186 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720602 | 3.NP_SO-101 | 720581 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0187 | 0187 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720605 | 3.NP_SO-101 | 720584 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0188 | 0188 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720608 | 3.NP_SO-101 | 720587 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0189 | 0189 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720611 | 3.NP_SO-101 | 720590 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0190 | 0190 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
720614 | 3.NP_SO-101 | 720593 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | OS03.02.0191 | 0191 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
721910 | 1.NP_SO-101 | 720596 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0197 | 0197 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
721913 | 1.NP_SO-101 | 720599 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | OS03.02.0198 | 0198 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722120 | 2.NP_SO-101 | 720602 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0199 | 0199 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722123 | 2.NP_SO-101 | 720605 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0200 | 0200 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722126 | 2.NP_SO-101 | 720608 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0201 | 0201 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722129 | 2.NP_SO-101 | 720611 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0202 | 0202 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722132 | 2.NP_SO-101 | 720614 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0203 | 0203 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722135 | 2.NP_SO-101 | 721910 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0204 | 0204 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722138 | 2.NP_SO-101 | 721913 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0205 | 0205 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722141 | 2.NP_SO-101 | 722120 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0206 | 0206 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722144 | 2.NP_SO-101 | 722123 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0207 | 0207 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722147 | 2.NP_SO-101 | 722126 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0208 | 0208 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722150 | 2.NP_SO-101 | 722129 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0209 | 0209 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722153 | 2.NP_SO-101 | 722132 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0210 | 0210 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>
722156 | 2.NP_SO-101 | 722135 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | OS03.02.0211 | 0211 | Fruhauf.vinarice@seznam.cz 2023.07.19 06:55 | Výchozí zdroj světla, <Unnamed>

# IfcLightFixture: PF_úniková tabulka (dveře doprava):PF_úniková tabulka (dveře doprava) (7)
Type - Material: <Unnamed>
Type - Fotometrika - Barevný filtr: 16777215; Celkový faktor světelné ztráty: 1; Definice zdroje světla (rodina): Bod+Kulová; Faktor světelné ztráty: 0; Osvětlení: 11.8206 lx; Počáteční barva: 0; Počáteční intenzita: 0; Počáteční teplota barvy: 3000 K; Posunu barevné teploty při stmívání lampy: <Žádné>; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Velikost symbolu zdroje světla: 609.6 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (dveře doprava); Označení typu: 01; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (dveře doprava)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - CCI Funkční systém: P; CCI Komponenta: EAA; CCI Technický systém: ME; Označení pořadí svítidla: 1; Označení typu (A-Z): NZ
Vazby - Odsazení od hostitele: 0 mm; Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 660568; Rodina: PF_úniková tabulka (dveře doprava); Rodina a typ: PF_úniková tabulka (dveře doprava): PF_úniková tabulka (dveře doprava); Typ: PF_úniková tabulka (dveře doprava); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:05
Name (PF_úniková tabulka (dveře doprava):PF_úniková tabulka (dveře doprava):...) | In | ID_import | Hostitel | Podlaží | Kód prvku | Označení | Material
662726 | 4.NP_SO-101 | 722138 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | OS03.01.0001 | 0001
662729 | 4.NP_SO-101 | 722141 | Podlaží : 4.NP_SO-101 | 4.NP_SO-101 | OS03.01.0002 | 0002 | Výchozí zdroj světla, <Unnamed>
720138 | -1.PP_SO-101 | 722144 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | OS03.01.0146 | 0146 | Výchozí zdroj světla, <Unnamed>
720622 | 3.NP_SO-101 | 722147 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | OS03.01.0192 | 0192 | Výchozí zdroj světla, <Unnamed>
721565 | -1.PP_SO-101 | 722150 | Podlaží : -1.PP_SO-101 | -1.PP_SO-101 | OS03.01.0194 | 0194 | Výchozí zdroj světla, <Unnamed>
722690 | 2.NP_SO-101 | 722153 | Podlaží : 2.NP_SO-101 | 2.NP_SO-101 | OS03.01.0218 | 0218 | Výchozí zdroj světla, <Unnamed>
722696 | 3.NP_SO-101 | 722156 | Podlaží : 3.NP_SO-101 | 3.NP_SO-101 | OS03.01.0219 | 0219 | Výchozí zdroj světla, <Unnamed>

# IfcLightFixture: PF_úniková tabulka (schody):PF_úniková tabulka (schody) (8)
Type - Material: <Unnamed>
Type - Fotometrika - Celkový faktor světelné ztráty: 1; Faktor světelné ztráty: 0; Počáteční barva: 0; Počáteční intenzita: 0; Posunu barevné teploty při stmívání lampy: <Žádné>; Barevný filtr: 16777215; Definice zdroje světla (rodina): Bod+Kulová; Osvětlení: 11.8206 lx; Počáteční teplota barvy: 3000 K; Příkon: 9.2903 W; Světelný tok: 1380 lm; Svítivost: 109.817 cd; Účinnost: 148.542 s3*lm/kg/m2
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Velikost symbolu zdroje světla: 609.6 mm; Délka: 167 mm; pk1(střed: 62.9639 mm; pk2 (průměr: 125.928 mm; pkvč délka: 270 mm; pkvč hloubka: 46 mm; Šířka: 57 mm; Výška: 118 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; Kód sestavy: OS03; Nadpis OmniClass: Lighting; Název typu: PF_úniková tabulka (schody); Označení typu: 04; Popis sestavy: Nouzové
Type - Jiné - Kategorie: Osvětlovací tělesa; Název rodiny: PF_úniková tabulka (schody)
Classification: OS03 Uniformat (Uniformat)
Elektroinstalace – osvětlení - Vypočítat součinitel využití: no
Text - Označení pořadí svítidla: 1; CCI Funkční systém: P; CCI Komponenta: EAA; CCI Technický systém: ME; Označení typu (A-Z): NZ
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.118613 m3; Plocha: 0.583727 m2
Jiné - Id typu: 659534; Rodina: PF_úniková tabulka (schody); Rodina a typ: PF_úniková tabulka (schody): PF_úniková tabulka (schody); Typ: PF_úniková tabulka (schody); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:05
Name (PF_úniková tabulka (schody):PF_úniková tabulka (schody):...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení | Material
712945 | 1.NP_SO-101 | PF_úniková tabulka (dveře doprava) | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 2250 | OS03.04.0091 | 0091
720105 | -1.PP_SO-101 | 662726 | -1.PP_SO-101 | Podlaží : -1.PP_SO-101 | 0 | OS03.04.0145 | 0145 | Výchozí zdroj světla, <Unnamed>
720308 | 4.NP_SO-101 | 662729 | 4.NP_SO-101 | Podlaží : 4.NP_SO-101 | 0 | OS03.04.0170 | 0170 | Výchozí zdroj světla, <Unnamed>
721898 | 1.NP_SO-101 | 720138 | 1.NP_SO-101 | Podlaží : 1.NP_SO-101 | 0 | OS03.04.0195 | 0195 | Výchozí zdroj světla, <Unnamed>
722162 | 2.NP_SO-101 | 720622 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OS03.04.0212 | 0212 | Výchozí zdroj světla, <Unnamed>
722165 | 2.NP_SO-101 | 721565 | 2.NP_SO-101 | Podlaží : 2.NP_SO-101 | 0 | OS03.04.0213 | 0213 | Výchozí zdroj světla, <Unnamed>
722595 | 3.NP_SO-101 | 722690 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OS03.04.0214 | 0214 | Výchozí zdroj světla, <Unnamed>
722598 | 3.NP_SO-101 | 722696 | 3.NP_SO-101 | Podlaží : 3.NP_SO-101 | 0 | OS03.04.0215 | 0215 | Výchozí zdroj světla, <Unnamed>
